/* Local PR preview; included after default/upstream and comparison helpers. */
typedef struct {CUIBranches *branches;const char *head,*suggested;} PUIBases;
static char *PUIString(const char *text) {
    size_t n=strlen(text)+1;char *copy=(char *)malloc(n);if(copy)memcpy(copy,text,n);return copy;
}
static int PUIBaseRow(void *context,size_t at,char label[256],char name[256],char state[256]) {
    PUIBases *bases=(PUIBases *)context;const char *ref;int tracking;
    if(at>=bases->branches->count)return 0;ref=bases->branches->names[at];tracking=GSValidTrackingRef(ref);
    LocalDisplayPath(ref+(tracking?13:11),name);snprintf(label,256,"%s%.230s",tracking?"Fetched: ":"Local: ",name);
    strcpy(state,!strcmp(ref,bases->head)?"Current head; no proposed commits.":
        bases->suggested && !strcmp(ref,bases->suggested)?"Suggested default base.":tracking?"Fetched committed base.":"Local committed base.");
    return 1;
}
static char *PUIBaseDetails(void *context,size_t at) {
    PUIBases *bases=(PUIBases *)context;char *head,*base,*joined=NULL;size_t n;
    if(at>=bases->branches->count)return NULL;
    head=ChoiceIdentityDetails("Proposed reference",bases->head);
    base=ChoiceIdentityDetails("Target base reference\rSnapshot IDs are read after you choose Preview.",bases->branches->names[at]);
    if(head && base){n=strlen(head)+strlen(base)+5;joined=(char *)malloc(n);if(joined)snprintf(joined,n,"%s\r\r%s",head,base);}
    free(head);free(base);return joined;
}
static void PUILimits(PVLimits *limits) {
    MMLimits merge;NativeMergeLimits(&merge);memset(limits,0,sizeof(*limits));limits->graph=merge.graph;limits->merge=merge.tree;
    limits->files.entries=8192;limits->files.depth=64;limits->files.pathBytes=1024;limits->files.objectBytes=2UL*1024*1024;
    limits->files.encodedBytes=3UL*1024*1024;limits->files.readBytes=64UL*1024*1024;limits->files.reads=32768;
}
static int PUIActive(const DefaultReview *review) {
    return gLocal && gWork.haveHead && gWork.branch && !strcmp(gWork.branch,review->local) &&
        !memcmp(gWork.tip,review->current,20) && gWork.database.volume==review->volume && gWork.database.directory==review->directory;
}
static void PullPreviewCommand(void) {
    DefaultReview *review;CUIBranches branches;PUIBases bases;NativeChoices choices;PVPreview preview;PVLimits limits;GSRepository reader;
    char *head=NULL,*base=NULL,*owner=NULL;size_t selected,i,rows=0;unsigned char target[20],again[20];int result,closed;
    static GHCommitInfo messages[GH_HISTORY_CAPACITY];static unsigned char ids[GH_HISTORY_CAPACITY][20];
    if(!gLocal || gBusy || gLocalBlocked || gMergePending || !gWork.haveHead || !gWork.branch || strlen(gWork.branch)>1024)return;
    review=(DefaultReview *)calloc(1,sizeof(*review));if(!review){CheckoutError("Pull Request Preview",GB_MEMORY);return;}
    memset(&branches,0,sizeof(branches));PVInit(&preview);PUILimits(&limits);
    review->folder=gWork.folder;strcpy(review->local,gWork.branch);memcpy(review->current,gWork.tip,20);
    result=DefaultReadReview(review);
    if(result==GS_NOT_FOUND && review->origin && review->repository[0])result=0;
    if(result==GS_NOT_FOUND){Message("Pull Request Preview Unavailable","Refresh the repository first. A verified local HEAD and configured GitHub origin are needed. Fetch Origin configures an origin; Compare to Branch remains available for local history.");goto done;}
    if(result)goto failed;
    review->volume=gWork.database.volume;review->directory=gWork.database.directory;
    result=CUILoadNamed(&branches,1);if(result)goto failed;
    if(!branches.count){Message("No Base Branches","No local or fetched base is available. Fetch the desired base explicitly, then reopen this preview.");goto done;}
    memset(&choices,0,sizeof(choices));bases.branches=&branches;bases.head=review->local;bases.suggested=review->choice.reference[0]?review->choice.reference:NULL;
    choices.context=&bases;choices.count=branches.count;choices.row=PUIBaseRow;choices.details=PUIBaseDetails;
    choices.title="Choose Pull Request Base";choices.description="Choose the target base from local or fetched history.\rOnly committed snapshots are included; staged and working edits remain separate.";
    choices.action="Preview";choices.noun="Base branches";
    for(i=0;i<branches.count;++i)if(bases.suggested && !strcmp(branches.names[i],bases.suggested)){choices.initial=i;break;}
    selected=PickNativeChoice(&choices);if(selected>=branches.count || gDone)goto done;
    head=PUIString(review->local);base=PUIString(branches.names[selected]);owner=PUIString(review->repository);CUIFree(&branches);
    if(!head || !base || !owner){result=GB_MEMORY;goto failed;}
    result=CheckoutAttach(&review->folder);if(!result)result=GSMacEnter(&gUICheckout.store,0);
    if(!result){NetReader(&reader,&gUICheckout.store);reader.read=BCUIRead;result=NetHeadCheck(&reader,review->local,review->current,1);}
    if(!result)result=DefaultCheck(review,&gUICheckout.store);
    if(!result)result=GSReadRef(&reader,base,target);
    if(!result) {
        gBusy=1;gCancel=0;LocalEditState();SetStatus("Preparing local pull-request snapshots... Escape cancels.");
        result=PVBuild(&reader,review->current,target,'\n',&limits,HistoryProgress,NULL,&preview);
    }
    if(!result)result=BCUIReadRows(&reader,&preview.graph,BC_LEFT,0,messages,ids,&rows);
    if(!result)result=NetHeadCheck(&reader,review->local,review->current,1);
    if(!result)result=GSReadRef(&reader,base,again);
    if(!result && memcmp(target,again,20))result=GS_CONFLICT;
    if(!result)result=DefaultCheck(review,&gUICheckout.store);
    closed=CheckoutRelease();if(closed)gLocalBlocked=1;if(!result)result=closed;gBusy=0;LocalEditState();
    if(!result && !PUIActive(review))result=GS_CONFLICT;
    if(result)goto failed;if(gDone)goto done;
    LocalHistoryReset();gBranchCompare.graph=preview.graph;BCInit(&preview.graph);gBranchCompare.files=preview.files;HCInit(&preview.files);
    gBranchCompare.current=head;head=NULL;gBranchCompare.other=base;base=NULL;gBranchCompare.pullOwner=owner;owner=NULL;
    gBranchCompare.pullRequest=1;gBranchCompare.pullKind=preview.kind;gBranchCompare.pullConflicts=preview.conflicts;gBranchCompare.pullFiles=gBranchCompare.files.count;
    gBranchCompare.side=BC_LEFT;gBranchCompare.basis=gBranchCompare.graph.bases==1?0:(size_t)-1;gBranchCompare.fileSide=BC_LEFT;gBranchCompare.ready=gBranchCompare.graph.bases==1;
    gBranchCompare.rows=rows;memcpy(gBranchCompare.messages,messages,rows*sizeof(*messages));memcpy(gBranchCompare.ids,ids,rows*20);
    if(gCommitField){TEDeactivate(gCommitField==1?gSummaryEdit:gDescriptionEdit);gCommitField=0;}
    gBranchCompare.selected=-1;gTab=1;LocalEditState();
    gBranchCompare.view=0;BCUISummary();
    goto done;
failed:
    if(!gDone)CheckoutError("Pull Request Preview",result);
done:
    closed=CheckoutRelease();if(closed)gLocalBlocked=1;gBusy=0;LocalEditState();
    CUIFree(&branches);PVFree(&preview);free(head);free(base);free(owner);DefaultReviewFree(review);
}
