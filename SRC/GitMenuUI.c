/* Native menu commands. Included by Main.c after local/auth helpers. */
#include "MenuCommands.h"
#include <Aliases.h>
#include <AppleEvents.h>
#include <Devices.h>

typedef struct {
    char bytes[8001];
    short length, start, end, field;
    int valid;
} GHUndo;
static GHUndo gUndo, gRedo;
static char gFindText[256], gChangeFilter[256];
static int gFindOffset = -1;
static GHCommitInfo gLocalHistory[GH_HISTORY_CAPACITY];
static unsigned char gLocalHistoryOID[GH_HISTORY_CAPACITY][20];
static HCComparison gHistoryComparison;
static int gHistoryReady, gHistoryFile = -1;
static unsigned char (*gHistoryCursors)[20];
static size_t gHistoryCursorCount;

static void HistoryComparisonReset(void) {
    HCFree(&gHistoryComparison); gHistoryReady = 0; gHistoryFile = -1;
}
static void LocalHistoryReset(void) {
    BCUIReset();
    HistoryComparisonReset(); free(gHistoryCursors); gHistoryCursors = NULL;
    gHistoryCursorCount = 0; gLocalHistoryPage = 1;gLocalHistoryOffset=0;
}
static int HistoryRead(void *context, const char *key, unsigned char **bytes, size_t *length) {
    return GSMacReadLimit((GSMacStore *)context, key, bytes, length,
                         !strncmp(key, "objects/", 8) ? 3UL * 1024 * 1024 : 2048);
}
static int HistoryNoWrite(void *context, const char *key, const void *a, size_t an,
                            const void *b, size_t bn) {
    (void)context; (void)key; (void)a; (void)an; (void)b; (void)bn; return GB_BAD;
}
static void HistoryReader(GSRepository *r) {
    r->context = &gWork.database; r->read = HistoryRead; r->replace = HistoryNoWrite;
}
static int HistoryProgress(void *context) {
    int stopped;
    (void)context;
    stopped = PumpEvents(0);
    return stopped || gDone ? -99 : 0;
}

static void EditReset(void) {
    memset(&gUndo, 0, sizeof(gUndo));
    memset(&gRedo, 0, sizeof(gRedo));
}
static void EditSnapshot(GHUndo *state, short field) {
    TEHandle edit = field == 1 ? gSummaryEdit : gDescriptionEdit;
    state->valid = 0;
    if (!field || (*edit)->teLength > 8000)
        return;
    state->length = (*edit)->teLength;
    memcpy(state->bytes, *(*edit)->hText, state->length);
    state->bytes[state->length] = 0;
    state->start = (*edit)->selStart;
    state->end = (*edit)->selEnd;
    state->field = field;
    state->valid = 1;
}
static void EditCapture(void) {
    EditSnapshot(&gUndo, (short)gCommitField);
    gRedo.valid = 0;
}
static void EditRestore(int redo) {
    GHUndo *from = redo ? &gRedo : &gUndo, *to = redo ? &gUndo : &gRedo;
    TEHandle edit;
    if (!from->valid || !gLocal)
        return;
    EditSnapshot(to, from->field);
    if (gCommitField)
        TEDeactivate(gCommitField == 1 ? gSummaryEdit : gDescriptionEdit);
    gCommitField = from->field;
    edit = gCommitField == 1 ? gSummaryEdit : gDescriptionEdit;
    TESetText(from->bytes, from->length, edit);
    TESetSelect(from->start, from->end, edit);
    TEActivate(edit);
    from->valid = 0;
    gTab = 0;
    LocalEditState();
    InvalRect(&gWindow->portRect);
}
static void DialogText(DialogPtr d, short number, const char *text) {
    Handle item;
    short kind;
    Rect r;
    Str255 p;
    GetDialogItem(d, number, &kind, &item, &r);
    Pascal(text, p);
    SetDialogItemText(item, p);
}
static void Message(const char *title, const char *text) {
    DialogPtr d = GetNewDialog(136, NULL, (WindowPtr)-1);
    short hit = 0;
    Str255 p;
    if (!d)
        return;
    Pascal(title, p);
    SetWTitle((WindowPtr)d, p);
    PrepareDialogChrome(d, 4, 5);
    if (!PrepareMessageBody(d, text)) { DisposeDialog(d); SetPort(gWindow); return; }
    PrepareDialog(d, 1, 1);
    SetWRefCon((WindowPtr)d, GetWRefCon((WindowPtr)d) | 0x8000L);
    while (hit != 1) {
        RunModalDialog(gMessageFilter, &hit);
        if (hit == 2) {
            ZeroScrap();
            PutScrap((long)(!strncmp(text, "https://", 8) ? strcspn(text, "\r\n") : strlen(text)),
                     'TEXT', text);
        }
    }
    CloseMessageBody();
    DisposeDialog(d);
    SetPort(gWindow);
}
typedef enum { ASK_FIND,ASK_FILTER,ASK_BRANCH,ASK_REPOSITORY,ASK_AUTHOR,ASK_MESSAGE } AskRule;
typedef struct { const char *prompt;AskRule rule;int valid; } AskPrompt;
static AskPrompt *gAskPrompt;
static DialogPtr gAskDialog;
static UserItemUPP gAskArt;
static ModalFilterUPP gAskFilter;
static const char *AskLabel(AskRule rule) {
    switch(rule) {
    case ASK_FIND:return "Find text:";
    case ASK_FILTER:return "Path contains:";
    case ASK_BRANCH:return "Branch name:";
    case ASK_REPOSITORY:return "GitHub repository (owner/name):";
    case ASK_AUTHOR:return "Commit author:";
    case ASK_MESSAGE:return "Commit message:";
    }
    return "Text:";
}
static const char *AskHint(AskRule rule) {
    switch(rule) {
    case ASK_FIND:return "Enter text to find. Matching ignores letter case.";
    case ASK_FILTER:return "Leave this field empty to show all changed files.";
    case ASK_BRANCH:return "Use an ASCII Git name, such as feature/classic-mac. No spaces, colon or trailing slash.";
    case ASK_REPOSITORY:return "For example: bbenchoff/GHClientWork. Enter owner/name, without a web address.";
    case ASK_AUTHOR:return "Use Name <email>, for example: Brian <brian@example.com>.";
    case ASK_MESSAGE:return "Describe this commit in a single line. A blank message cannot be committed.";
    }
    return "Enter a single line of text.";
}
static int AskValid(AskRule rule,const char *text) {
    const unsigned char *p=(const unsigned char *)text;char ref[268];int visible=0;
    if(!text || strlen(text)>255)return 0;
    for(;*p;++p){if(*p<32 || *p==127)return 0;if(*p!=' ')visible=1;}
    if(rule==ASK_FILTER)return 1;
    if(!visible)return 0;
    switch(rule) {
    case ASK_FIND:case ASK_MESSAGE:return 1;
    case ASK_AUTHOR:return GSValidIdentity(text);
    case ASK_REPOSITORY:return GHValidRepository(text);
    case ASK_BRANCH:
        for(p=(const unsigned char *)text;*p;++p)if(*p>=128)return 0;
        snprintf(ref,sizeof(ref),"refs/heads/%s",text);return GSValidRef(ref);
    default:return 0;
    }
}
static int AskRead(DialogPtr d,char text[256]) {
    Handle item;short kind;Rect r;Str255 value;
    GetDialogItem(d,4,&kind,&item,&r);GetDialogItemText(item,value);
    memcpy(text,value+1,value[0]);text[value[0]]=0;
    return strlen(text)==value[0]; /* Refuse embedded NULs, not just their prefix. */
}
static pascal void AskDraw(DialogPtr d,short number) {
    GrafPtr saved;PenState pen;RGBColor foreground;short font,size,kind;Style face;Handle item;Rect r;
    if(d!=gAskDialog || !gAskPrompt)return;
    GetPort(&saved);SetPort((GrafPtr)d);font=((GrafPtr)d)->txFont;size=((GrafPtr)d)->txSize;face=((GrafPtr)d)->txFace;
    GetPenState(&pen);GetForeColor(&foreground);PenNormal();GetDialogItem(d,number,&kind,&item,&r);
    Box(r.left,r.top,r.right,r.bottom,255,255,255);
    OperationWrapped(&r,number==3?gAskPrompt->prompt:number==7?AskLabel(gAskPrompt->rule):AskHint(gAskPrompt->rule),gGeneva,number==3?12:9);
    RGBForeColor(&foreground);SetPenState(&pen);TextFont(font);TextSize(size);TextFace(face);SetPort(saved);
}
static int AskSync(DialogPtr d) {
    Handle button;short kind,next;Rect r;char text[256];int valid;
    if(d!=gAskDialog || !gAskPrompt)return 0;
    valid=AskRead(d,text) && AskValid(gAskPrompt->rule,text);gAskPrompt->valid=valid;
    GetDialogItem(d,1,&kind,&button,&r);next=(short)((kind&127)|(valid?0:128));
    if(kind!=next)SetDialogItem(d,1,next,button,&r);
    if((**(ControlHandle)button).contrlHilite!=(valid?0:255))HiliteControl((ControlHandle)button,valid?0:255);
    return valid;
}
static pascal Boolean AskFilter(DialogPtr d,EventRecord *event,short *hit) {
    int valid=AskSync(d);
    *hit=0; /* Editing commands must never reuse an earlier item hit. */
    if(event && (event->what==keyDown || event->what==autoKey) && !(event->modifiers&cmdKey) &&
       ((event->message&charCodeMask)==13 || (event->message&charCodeMask)==3) && !valid) {
        *hit=0;SysBeep(1);return true;
    }
    return event?NativeDialogFilter(d,event,hit):false;
}
static int AskAction(const char *title,const char *prompt,const char *action,AskRule rule,char text[256]) {
    DialogPtr d;Handle item;short kind,hit=0,number;Rect r;Str255 p;AskPrompt context;char next[256];int approved=0;
    if(gDone || gAskDialog || !text || rule<ASK_FIND || rule>ASK_MESSAGE)return 0;
    d=GetNewDialog(137,NULL,(WindowPtr)-1);if(!d)return 0;
    if(!gAskArt)gAskArt=NewUserItemProc(AskDraw);
    if(!gAskFilter)gAskFilter=NewModalFilterProc(AskFilter);
    if(!gAskArt || !gAskFilter || !PrepareDialogChrome(d,5,6)){DisposeDialog(d);SetPort(gWindow);return 0;}
    context.prompt=prompt;context.rule=rule;context.valid=0;gAskPrompt=&context;gAskDialog=d;
    Pascal(title,p);SetWTitle((WindowPtr)d,p);CheckoutButtonTitle(d,1,action);
    for(number=3;number<=8;++number)if(number==3 || number>=7) {
        GetDialogItem(d,number,&kind,&item,&r);SetDialogItem(d,number,kind,(Handle)gAskArt,&r);
    }
    DialogText(d,4,text);SelectDialogItemText(d,4,0,32767);AskSync(d);PrepareDialog(d,1,2);DrawDialog(d);
    while(!gDone && hit!=2) {
        hit=0;
        RunModalDialog(gAskFilter,&hit);
        if(!gDone && hit==1 && AskSync(d) && AskRead(d,next)){approved=1;break;}
    }
    DisposeDialog(d);gAskDialog=NULL;gAskPrompt=NULL;SetPort(gWindow);
    if(approved)strcpy(text,next);
    return approved;
}
static int Contains(const char *text, const char *needle) {
    size_t i, j;
    unsigned char a, b;
    if (!*needle)
        return 1;
    for (i = 0; text[i]; ++i) {
        for (j = 0; needle[j] && text[i + j]; ++j) {
            a = (unsigned char)text[i + j];
            b = (unsigned char)needle[j];
            if (a >= 'A' && a <= 'Z')
                a += 'a' - 'A';
            if (b >= 'A' && b <= 'Z')
                b += 'a' - 'A';
            if (a != b)
                break;
        }
        if (!needle[j])
            return 1;
    }
    return 0;
}
static int LocalMatches(const char *path) { return Contains(path, gChangeFilter); }
static int LocalFiltered(void) { return gChangeFilter[0] != 0; }
static void LocalFilterReset(void) { gChangeFilter[0] = 0; }
static void FindReset(void) { gFindOffset = -1; gDiffLeft = 0; }
static void DiffScroll(void) {
    const char *p=gPatch,*start;
    unsigned long widest=0,columns,remaining;
    int lines=0,visible=DiffVisibleRows(),inHunk=0,kind;
    short width;
    SetPort(gWindow);TextFont(gMonaco);TextSize(gDiffSize);TextFace(0);
    width=CharWidth('M');if(width<1)width=1;
    gDiffVisibleColumns=(short)((RightEdge(772)-269)/width);if(gDiffVisibleColumns<1)gDiffVisibleColumns=1;
    while(*p) {
        start=p;while(*p && *p!='\r')++p;++lines;
        if(p-start>=2 && start[0]=='@' && start[1]=='@')inHunk=1;
        kind=inHunk && (*start=='+' || *start=='-' || *start==' ');
        columns=DVColumns(start+kind,(size_t)(p-start)-kind);
        TextFace(gMonochrome && *start=='@'?bold:0);width=CharWidth('M');if(width<1)width=1;
        remaining=(unsigned long)((RightEdge(772)-(kind?269:256))/width);
        remaining=columns>remaining?columns-remaining:0;
        if(remaining>widest)widest=remaining;
        if(*p)++p;
    }
    TextFace(0);gDiffColumns=widest;
    if(gDiffLeft>gDiffColumns)gDiffLeft=gDiffColumns;
    SetControlMaximum(gDiffHorizontal,DVMaximum(gDiffColumns));
    SetControlValue(gDiffHorizontal,DVValue(gDiffLeft,gDiffColumns));
    gDiffLines = lines > visible ? lines - visible : 0;
    if (gDiffTop > gDiffLines)
        gDiffTop = gDiffLines;
    if (gDiffTop < 0)
        gDiffTop = 0;
    SetControlMaximum(gDiffScroll, (short)gDiffLines);
    SetControlValue(gDiffScroll, (short)gDiffTop);
}
static void FindText(int ask) {
    size_t i, n, start, pass, j;
    int line;
    size_t lineStart;
    char saved;
    if (ask && !AskAction("Find in Comparison",
                    "Find text in the displayed comparison or commit. Numbers and letters match "
                    "without case.",
                    "Find",ASK_FIND,gFindText))
        return;
    if (!gFindText[0])
        return;
    n = strlen(gPatch);
    start = gFindOffset >= 0 && (size_t)gFindOffset < n ? (size_t)gFindOffset + 1 : 0;
    for (pass = 0; pass < 2; ++pass) {
        for (i = pass ? 0 : start; i < (pass ? start : n); ++i) {
            j = strlen(gFindText);
            if (j > n - i)
                continue;
            saved = gPatch[i + j];
            gPatch[i + j] = 0;
            line = Contains(gPatch + i, gFindText);
            gPatch[i + j] = saved;
            if (!line)
                continue;
            line = 0;
            lineStart=0;
            for (j = 0; j < i; ++j)
                if (gPatch[j] == '\r') { ++line;lineStart=j+1; }
            gDiffTop = line;
            gDiffLeft=DVColumns(gPatch+lineStart,i-lineStart);
            if(gDiffLeft>2)gDiffLeft-=2;else gDiffLeft=0;
            DiffScroll();
            gFindOffset = (int)i;
            SetStatus("Found text; the matching line is in the comparison view.");
            return;
        }
    }
    SetStatus("Text was not found in the displayed comparison.");
}
static void FinderOpen(const FSSpec *file) {
    AliasHandle alias = NULL;
    AEAddressDesc address;
    AppleEvent event, reply;
    AEDescList list;
    OSType finder = 'MACS';
    OSErr error;
    memset(&address, 0, sizeof(address));
    memset(&event, 0, sizeof(event));
    memset(&reply, 0, sizeof(reply));
    memset(&list, 0, sizeof(list));
    error = NewAliasMinimal(file, &alias);
    if (!error)
        error = AECreateDesc(typeApplSignature, &finder, sizeof(finder), &address);
    if (!error)
        error = AECreateAppleEvent(kCoreEventClass, kAEOpenDocuments, &address,
                                   kAutoGenerateReturnID, kAnyTransactionID, &event);
    if (!error)
        error = AECreateList(NULL, 0, false, &list);
    if (!error) {
        HLock((Handle)alias);
        error = AEPutPtr(&list, 0, typeAlias, *alias, GetHandleSize((Handle)alias));
        HUnlock((Handle)alias);
    }
    if (!error)
        error = AEPutParamDesc(&event, keyDirectObject, &list);
    if (!error)
        error =
            AESend(&event, &reply, kAENoReply, kAENormalPriority, kAEDefaultTimeout, NULL, NULL);
    if (alias)
        DisposeHandle((Handle)alias);
    AEDisposeDesc(&list);
    AEDisposeDesc(&reply);
    AEDisposeDesc(&event);
    AEDisposeDesc(&address);
    if (error)
        LocalError("Ask Finder to open", error);
}
static void HistoryShowMessage(int selected, int reset) {
    GSRepository reader;
    unsigned char *body;
    size_t length, i, n;
    char type[7], hex[41], heading[256];
    int result;
    if (selected < 0 || selected >= gLocalHistoryCount)
        return;
    HistoryReader(&reader);
    result = GSGetObjectLimit(&reader, gLocalHistoryOID[selected], type, &body, &length, 2UL * 1024 * 1024);
    if (result) {
        LocalError("Read local commit", result);
        return;
    }
    if (strcmp(type, "commit")) {
        free(body);
        LocalError("Read local commit", GS_FORMAT);
        return;
    }
    if (reset) HistoryComparisonReset();
    gLocalHistorySelection = selected; gHistoryFile = -1;
    GBOIDFormat(gLocalHistoryOID[selected], hex);
    snprintf(heading, sizeof(heading), "Commit %s\rAuthor: %.180s\r\r", hex,
             gLocalHistory[selected].author);
    strcpy(gPatch, heading);
    n = strlen(gPatch);
    i = gLocalHistory[selected].messageOffset;
    gPatchTruncated = length - i >= sizeof(gPatch) - n;
    for (; i < length && n + 1 < sizeof(gPatch); ++i)
        gPatch[n++] =
            body[i] == '\n'
                ? '\r'
                : (body[i] < 32 && body[i] != '\r' && body[i] != '\t' ? '?' : (char)body[i]);
    gPatch[n] = 0;
    free(body);
    gDiffTop = 0;
    FindReset();
    DiffScroll();
    ShowDiffControls();
    SetStatus("Commit message. Changed Files compares this commit with its first parent, or an empty tree for a root commit.");
    InvalRect(&gWindow->portRect);
}
static void LocalHistorySelect(int selected) { HistoryShowMessage(selected, 1); }
static void LocalHistoryMessage(void) { HistoryShowMessage(gLocalHistorySelection, 0); }
static int LocalHistoryHasNext(void) { return gLocalHistoryOffset+gUI.rows<gLocalHistoryCount || (size_t)gLocalHistoryPage < gHistoryCursorCount; }
static void LocalHistoryLoad(void) {
    GSRepository reader;
    unsigned char oid[20], *body, (*grown)[20];
    char type[7], *branch = NULL;
    size_t length;
    GHCommitInfo info;
    int i, result, more = 0;
    BCUIReset(); HistoryComparisonReset(); HistoryReader(&reader);
    result = GSHead(&reader, &branch, oid);
    free(branch);
    gLocalHistoryCount = 0;gLocalHistoryOffset=0;
    gLocalHistorySelection = -1;
    gPatch[0] = 0;
    if (result == GS_NOT_FOUND) {
        LocalHistoryReset();
        SetStatus("This branch has no commits yet.");
        return;
    }
    if (result) {
        LocalHistoryReset();
        LocalError("Read local history", result);
        return;
    }
    if (!gHistoryCursorCount || memcmp(gHistoryCursors[0], oid, 20)) {
        LocalHistoryReset();
        gHistoryCursors = (unsigned char (*)[20])malloc(20);
        if (!gHistoryCursors) { LocalError("Read local history", GB_MEMORY); return; }
        memcpy(gHistoryCursors[0], oid, 20); gHistoryCursorCount = 1;
    }
    if (gLocalHistoryPage < 1 || (size_t)gLocalHistoryPage > gHistoryCursorCount) gLocalHistoryPage = 1;
    memcpy(oid, gHistoryCursors[gLocalHistoryPage - 1], 20);
    gBusy = 1; gCancel = 0; LocalEditState();
    for (i = 0; i < GH_HISTORY_CAPACITY; ++i) {
        result = HistoryProgress(NULL);
        if (!result) result = GSGetObjectLimit(&reader, oid, type, &body, &length, 2UL * 1024 * 1024);
        if (result)
            break;
        result = strcmp(type, "commit") ? GS_FORMAT : GHCommitParse(body, length, &info);
        free(body);
        if (result)
            break;
        gLocalHistory[gLocalHistoryCount] = info;
        memcpy(gLocalHistoryOID[gLocalHistoryCount++], oid, 20);
        if (!info.parents)
            break;
        memcpy(oid, info.parent, 20);
        if (i + 1 == GH_HISTORY_CAPACITY) more = 1;
    }
    gBusy = 0; LocalEditState();
    if (result) {
        gLocalHistoryCount = 0;
        LocalHistoryReset();
        LocalError("Read local history", result);
        return;
    }
    if (more && (size_t)gLocalHistoryPage == gHistoryCursorCount && gHistoryCursorCount < 10000) {
        grown = (unsigned char (*)[20])realloc(gHistoryCursors, (gHistoryCursorCount + 1) * 20);
        if (!grown) { LocalHistorySelect(0); LocalError("Read next history page", GB_MEMORY); return; }
        gHistoryCursors = grown; memcpy(gHistoryCursors[gHistoryCursorCount++], oid, 20);
    }
    if (gLocalHistoryCount)
        LocalHistorySelect(0);
    else {
        DiffScroll();
        SetStatus("No commits on this page. Use the previous-page arrow.");
    }
    if (gLocalHistoryCount)
        SetStatus("Local first-parent history. Select a commit, then Changed Files to inspect its committed changes.");
    if (more && gLocalHistoryPage == 10000)
        SetStatus("History page limit reached. Older commits are outside this view.");
}
static void LocalHistoryPage(int direction) {
    int page=gLocalHistoryPage-1,offset=gLocalHistoryOffset;
    int more=(size_t)gLocalHistoryPage<gHistoryCursorCount && gLocalHistoryPage<10000;
    int moved=GHPageMove(direction,gUI.rows,gLocalHistoryCount,more,&page,&offset);
    if(!moved)return;
    if(moved==2){gLocalHistoryPage=page+1;LocalHistoryLoad();}
    gLocalHistoryOffset=GHVisibleOffset(offset,-1,gLocalHistoryCount,gUI.rows);
    if(gLocalHistoryCount)LocalHistorySelect(gLocalHistoryOffset);
}
static void LocalHistoryRows(void) {
    short y;
    int i;
    char display[256], hex[41];
    for (i = gLocalHistoryOffset; i < gLocalHistoryCount && i < gLocalHistoryOffset+gUI.rows; ++i) {
        y = (short)(148 + (i-gLocalHistoryOffset) * 28);
        if (i == gLocalHistorySelection)
            Box(10, y - 14, 230, y + 13, 225, 217, 240);
        LocalDisplayPath(gLocalHistory[i].summary, display);
        FitText(17, y, display, gGeneva, 9, 205, 0, 0, 0);
        GBOIDFormat(gLocalHistoryOID[i], hex);
        FitText(17, y + 11, hex, gMonaco, 9, 65, 96, 96, 96);
    }
    if (!gLocalHistoryCount)
        Text(18, 151, "No commits on this page", gGeneva, 9, 96, 96, 96);
}
static void HistoryDisplayName(const char *name, char display[256]) {
    size_t i;
    LocalDisplayPath(name, display);
    for (i = 0; display[i]; ++i)
        if ((unsigned char)display[i] < 32 || (unsigned char)display[i] == 127) display[i] = '?';
}
static void LocalHistoryHeader(void) {
    char display[256], label[64];
    int chosen = gLocalHistorySelection >= 0 && gLocalHistorySelection < gLocalHistoryCount;
    Text(255, 86, gHistoryFile >= 0 ? "Commit Changes" : "Local Commit", gChicago, 12, 255, 255, 255);
    if (!chosen) { Text(255, 113, "No commit selected", gGeneva, 9, 96, 96, 96); return; }
    HistoryDisplayName(gHistoryFile >= 0 ? gHistoryComparison.changes[gHistoryFile].path
                                       : gLocalHistory[gLocalHistorySelection].summary, display);
    FitText(255, 113, display, gChicago, 12, RightEdge(525), 0, 0, 0);
    Box(255,119,365,144,gHistoryFile<0?39:238,gHistoryFile<0?97:238,gHistoryFile<0?169:238);
    Bevel(255,119,365,144,gHistoryFile<0);
    Text(265,136,"Message",gChicago,12,gHistoryFile<0?255:48,gHistoryFile<0?255:48,gHistoryFile<0?255:48);
    Box(375,119,600,144,gHistoryFile>=0?39:238,gHistoryFile>=0?97:238,gHistoryFile>=0?169:238);
    Bevel(375,119,600,144,gHistoryFile>=0);
    if (gHistoryReady) snprintf(label,sizeof(label),"Changed Files (%lu)...",(unsigned long)gHistoryComparison.count);
    else strcpy(label,"Changed Files...");
    Text(385,136,label,gChicago,12,gHistoryFile>=0?255:48,gHistoryFile>=0?255:48,gHistoryFile>=0?255:48);
}
static void HistoryPreviewFile(size_t selected) {
    GSRepository reader;
    GDResult diff;
    char hex[41], parent[41], status[256];
    size_t n;
    int result;
    if (!gHistoryReady || selected >= gHistoryComparison.count || gBusy) return;
    HistoryReader(&reader); gBusy = 1; gCancel = 0; LocalEditState();
    GBOIDFormat(gHistoryComparison.after.commit, hex);
    GBOIDFormat(gHistoryComparison.commit.parent, parent);
    snprintf(gPatch,sizeof(gPatch),gHistoryComparison.commit.parents
        ? "Commit %.7s vs first parent %.7s%s\r"
        : "Root commit %.7s vs empty contents\r",hex,parent,
        gHistoryComparison.commit.parents>1?" (merge)":"");
    n = strlen(gPatch); gPatchTruncated = 0; gDiffTop = 0; FindReset();
    result = HCPreview(&reader,&gHistoryComparison,selected,'\r',gPatch+n,sizeof(gPatch)-n,
                       HistoryProgress,NULL,&diff);
    gBusy = 0; LocalEditState();
    if (result) {
        gHistoryFile = -1;
        strcpy(gPatch,result == -99 ? "Historical preview cancelled.\rChoose Changed Files to retry.\r"
                                   : "This historical preview could not be read.\rThe index and working files were not changed.\r");
        LocalError("Read historical comparison",result);
    } else {
        gHistoryFile = (int)selected; gPatchTruncated = diff.truncated;
        snprintf(status,sizeof(status),"Committed file %lu of %lu: +%lu -%lu lines. %s Read-only; working edits are separate.",
            (unsigned long)(selected+1),(unsigned long)gHistoryComparison.count,
            (unsigned long)diff.added,(unsigned long)diff.removed,
            gHistoryComparison.commit.parents>1?"Compared with first parent.":gHistoryComparison.commit.parents?"Compared with parent.":"Root commit.");
        SetStatus(status);
    }
    DiffScroll(); ShowDiffControls(); InvalRect(&gWindow->portRect);
}
static const char *HistoryFileStatus(const HCChange *change) {
    return change->flags&HC_ADDED?"Added":change->flags&HC_DELETED?"Deleted"
        :change->flags&HC_GITLINK?"Submodule":change->flags==HC_MODE?"Mode"
        :(change->flags&HC_MAC) && !(change->flags&(HC_DATA|HC_MODE))?"Macintosh":"Modified";
}
static int HistoryFileRow(void *context,size_t at,char label[256],char name[256],char info[256]) {
    const HCComparison *comparison=(const HCComparison *)context;const HCChange *change;
    if(at>=comparison->count)return 0;change=comparison->changes+at;
    HistoryDisplayName(change->path,name);snprintf(label,256,"%s: %.230s",HistoryFileStatus(change),name);
    snprintf(info,256,"%s. Commit comparison only.",HistoryFileStatus(change));return 1;
}
static char *HistoryFileDetails(void *context,size_t at) {
    const HCComparison *comparison=(const HCComparison *)context;const HCChange *change;char heading[320];
    if(at>=comparison->count)return NULL;change=comparison->changes+at;
    snprintf(heading,sizeof(heading),"Committed file: %s\r%s\rStaged and working edits are excluded.",HistoryFileStatus(change),
        change->flags&HC_ADDED?"Added in this comparison.":change->flags&HC_DELETED?"Deleted in this comparison.":
        (change->flags&HC_MAC)?"Finder/resource-fork records changed; data or mode changes may also be present.":
        change->flags&HC_GITLINK?"Submodule commit identity changed.":"Data or mode changed; no changed Macintosh fork record.");
    return ChoiceIdentityDetails(heading,change->path);
}
static void LocalHistoryChooseFile(void) {
    GSRepository reader;
    HCLimits limits;
    NativeChoices choices;
    size_t selected;
    char heading[256], hex[41];
    int result;
    if (!gLocal || gLocalBlocked || gBusy || gLocalHistorySelection < 0 ||
        gLocalHistorySelection >= gLocalHistoryCount) return;
    if (!gHistoryReady) {
        limits.entries=8192; limits.depth=64; limits.pathBytes=1024;
        limits.objectBytes=2UL*1024*1024; limits.encodedBytes=3UL*1024*1024;
        limits.readBytes=64UL*1024*1024; limits.reads=32768;
        HistoryReader(&reader); gBusy=1; gCancel=0; LocalEditState();
        SetStatus("Reading committed files and Macintosh fork records... Escape cancels.");
        result=HCFromCommit(&reader,gLocalHistoryOID[gLocalHistorySelection],&limits,
                            HistoryProgress,NULL,&gHistoryComparison);
        gBusy=0; LocalEditState();
        if (result) {
            SetStatus(result==-99?"Reading committed files cancelled. The commit message is kept.":"Committed files could not be read or exceed the comparison limits. The commit message is kept.");
            if (result!=-99 && !gDone) Message("Files in Commit",result==GB_SPACE
                ?"This commit exceeds this version's comparison limits. You can still read its message or inspect it in another Git client. No index, ref or working file was changed."
                :"A committed object could not be read or verified. Keep the repository intact and check it in another Git client. Its commit message is kept; no index, ref or working file was changed.");
            return;
        }
        gHistoryReady=1;
    }
    if (gDone) return;
    if (!gHistoryComparison.count) {
        SetStatus("This commit has no file changes in the selected parent comparison.");
        Message("Files in Commit", "This commit has no file changes compared with its first parent, or with empty contents for a root commit.");
        return;
    }
    SetStatus("Committed files are ready. Choose a file to preview, or Cancel to keep the displayed view.");
    GBOIDFormat(gHistoryComparison.after.commit,hex);
    snprintf(heading,sizeof(heading),"Commit %.7s. %s\rChoose a file to preview its committed changes.",hex,
        gHistoryComparison.commit.parents>1?"Compared with first parent of merge.":gHistoryComparison.commit.parents?"Compared with parent.":"Root compared with empty contents.");
    choices.context=&gHistoryComparison;choices.count=gHistoryComparison.count;
    choices.initial=gHistoryFile>=0?(size_t)gHistoryFile:0;choices.row=HistoryFileRow;choices.details=HistoryFileDetails;
    choices.title="Files in Commit";choices.description=heading;choices.action="Preview";choices.noun="Files";
    selected=PickNativeChoice(&choices);
    if(!gDone && selected!=(size_t)-1)HistoryPreviewFile(selected);
    else { SetStatus("File selection cancelled. The displayed commit or comparison is kept."); InvalRect(&gWindow->portRect); }
}
static void NewBranch(void) {
    char name[256] = "", ref[268], status[256];
    unsigned char tip[20];
    int result,created=0;
    if (!gLocal || !gWork.haveHead)
        return;
    if (!AskAction("New Branch",
             "Create a branch at the current commit and switch to it. Your staged changes and "
             "working files are preserved. Use an ASCII branch name.",
             "Create Branch",ASK_BRANCH,name))
        return;
    snprintf(ref, sizeof(ref), "refs/heads/%s", name);
    if (!GSValidRef(ref)) {
        SetStatus("Enter a valid Git branch name, such as feature/classic-mac.");
        return;
    }
    {
        const unsigned char *p = (const unsigned char *)name;
        while (*p && *p < 128)
            ++p;
        if (*p) {
            SetStatus("This branch dialog currently accepts ASCII names.");
            return;
        }
    }
    memcpy(tip, gWork.tip, 20);
    result = GSMacEnter(&gWork.database,0);
    if(!result) {
        result = GSUpdateRef(&gWork.repository, ref, NULL, tip);
        created=!result;
        if(!result)result=GSSelectSameTip(&gWork.repository,gWork.branch,ref,tip);
        {int closed=GSMacLeave(&gWork.database);if(!result)result=closed;}
    }
    if (result) {
        if (result == GC_RECOVERY) { LocalRefresh(); return; }
        if(created) {
            LocalRefresh();
            SetStatus("The branch was created, but its selection could not be verified. Refresh before continuing.");
        } else LocalError("Create branch", result);
        return;
    }
    LocalRefresh();
    snprintf(status, sizeof(status),
             "Created and switched to %.180s. Both forks and staged changes were preserved.", name);
    SetStatus(status);
}
static void SwitchBranch(void) { CheckoutSwitch(); }
static void BranchInfo(void) {
    char text[768];
    if (gLocal) { CheckoutSwitch(); return; }
    snprintf(text, sizeof(text), "GitHub repository: %s\rDefault branch: %s", gRemote, gBranch);
    Message("Current Branch", text);
}
static void Preferences(void) {
    DialogPtr d;
    short hit = 0, kind;
    Handle item;
    Rect r;
    int saved;
    for (;;) {
        if(gDone)break;
        d = GetNewDialog(138, NULL, (WindowPtr)-1);
        if (!d)
            return;
        saved=VaultHasSaved();
        if(!PreparePreferencesArt(d,saved)){DisposeDialog(d);SetStatus("Not enough memory to open Preferences.");break;}
        GetDialogItem(d, 3, &kind, &item, &r);
        HiliteControl((ControlHandle)item, gUser[0] ? 0 : 255);
        GetDialogItem(d, 4, &kind, &item, &r);
        HiliteControl((ControlHandle)item, gLocal ? 0 : 255);
        GetDialogItem(d,7,&kind,&item,&r);HiliteControl((ControlHandle)item,gCredentials.bound?0:255);
        GetDialogItem(d,8,&kind,&item,&r);HiliteControl((ControlHandle)item,saved!=0?0:255);
        GetDialogItem(d,9,&kind,&item,&r);HiliteControl((ControlHandle)item,saved>0?0:255);
        GetDialogItem(d,12,&kind,&item,&r);HiliteControl((ControlHandle)item,saved!=0?0:255);
        PrepareDialog(d, 1, 1);
        hit = 0;
        while ((hit < 1 || hit > 4) && (hit<7 || hit>9) && hit!=12)
            RunModalDialog(gDialogFilter, &hit);
        DisposeDialog(d);
        if (hit == 1)
            break;
        if (hit == 2)
            SignIn();
        if (hit == 3) {
            VaultSignOut();
        }
        if (hit == 4)
            LocalAuthor(1);
        if(hit==7)VaultSaveCredentials();
        if(hit==8)VaultUnlockCredentials();
        if(hit==9)VaultForgetSaved();
        if(hit==12)VaultChangePassphrase();
    }
    SetPort(gWindow);
    InvalRect(&gWindow->portRect);
}
static void GitHubAddress(short command) {
    char text[1400], branch[768];
    if(gLocal && command!=MC_REPORT_ISSUE){LocalGitHubAddress(command);return;}
    if (command == MC_REPORT_ISSUE)
        strcpy(text, "https://github.com/bbenchoff/GHClientWork/issues/new");
    else {
        if (!gRemote[0])
            return;
        if (GHURLEncode(gBranch, branch, sizeof(branch)))
            return;
        snprintf(text, sizeof(text), "https://github.com/%s%s%s", gRemote,
                 command == MC_NEW_ISSUE                                    ? "/issues/new"
                 : command == MC_BRANCH_ADDRESS                             ? "/tree/"
                 : command == MC_COMPARE_ADDRESS || command == MC_CREATE_PR ? "/compare/"
                                                                            : "",
                 command == MC_BRANCH_ADDRESS || command == MC_COMPARE_ADDRESS ||
                         command == MC_CREATE_PR
                     ? branch
                     : "");
    }
    snprintf(text + strlen(text), sizeof(text) - strlen(text),
             "\r\rOpen this address in your browser, or copy it to use on another computer.");
    Message("GitHub Address", text);
}
static int MenuAllowed(short command) {
    TEHandle edit;
    int selection = 0;
    if (!MenuImplemented(command) || gBusy)
        return 0;
    if (gLocalBlocked && command != MC_REFRESH && command != MC_CLOSE_REPOSITORY &&
        command != MC_REMOVE_REPOSITORY && command != MC_ADD_REPOSITORY &&
        command != MC_NEW_REPOSITORY && command != MC_REPOSITORY_LIST && command != MC_RECENT_REPOSITORIES && command != MC_QUIT && command != MC_GUIDE &&
        command != MC_ABOUT && command != MC_HELP_ABOUT && command != MC_REPOSITORY_SETTINGS &&
        command != MC_COLOR_HIGHLIGHTS && !(command==MC_REBASE && gRebasePending) && !((command==MC_MERGE || command==MC_SQUASH_MERGE || command==MC_UPDATE_BRANCH) && gMergePending))
        return 0;
    if (gLocal && gCommitField) {
        edit = gCommitField == 1 ? gSummaryEdit : gDescriptionEdit;
        selection = (*edit)->selStart != (*edit)->selEnd;
    }
    switch (command) {
    case MC_COLOR_HIGHLIGHTS:
        return DisplayHasColor();
    case MC_UNDO:
        return gLocal && gUndo.valid;
    case MC_REDO:
        return gLocal && gRedo.valid;
    case MC_CUT:
        return selection;
    case MC_COPY:
        return gLocal && gCommitField && !gTab ? selection : gPatch[0] != 0;
    case MC_PASTE:
    case MC_SELECT_ALL:
        return gLocal && gCommitField && !gTab;
    case MC_FIND:
        return gPatch[0] != 0;
    case MC_FIND_NEXT:
        return gPatch[0] && gFindText[0];
    case MC_CLOSE_REPOSITORY:
        return ((WindowPeek)gWindow)->visible;
    case MC_REMOVE_REPOSITORY:
        return gLocal;
    case MC_HISTORY:
    case MC_CHANGES:
    case MC_BRANCH_INFO:
    case MC_REFRESH:
        return gLocal || gRemote[0];
    case MC_GO_SUMMARY:
    case MC_FILTER_CHANGES:
    case MC_SHOW_FINDER:
    case MC_REPOSITORY_SETTINGS:
    case MC_REVIEW_PUSH:
        return gLocal;
    case MC_OPEN_EDITOR:
        return gLocal && !gTab && gLocalSelection >= 0 &&
               (size_t)gLocalSelection < gLocalRowCount &&
               gWork.files[gLocalRows[gLocalSelection]].exists;
    case MC_DISCARD_CHANGES:
        return DiscardAvailable();
    case MC_STASH_CHANGES:
        return StashAvailable();
    case MC_COMMIT:
        return gLocal && !gTab && gLocalStaged && (*gSummaryEdit)->teLength;
    case MC_MERGE:
    case MC_SQUASH_MERGE:
    case MC_UPDATE_BRANCH:
        return gLocal && (gWork.haveHead || gMergePending);
    case MC_NEW_BRANCH:
    case MC_FETCH_DEFAULT:
    case MC_PREVIEW_PR:
    case MC_COMPARE_BRANCH:
    case MC_TEST_RESTORE:
    case MC_TEST_PUSH_PACK:
    case MC_PUSH:
    case MC_FORCE_PUSH:
        return gLocal && gWork.haveHead;
    case MC_REBASE:
        return gLocal && (gWork.haveHead || gRebasePending);
    case MC_SWITCH_BRANCH:
    case MC_STASHED_CHANGES:
    case MC_SAVED_CHANGES:
    case MC_RENAME_BRANCH:
    case MC_DELETE_BRANCH:
    case MC_FETCH:
    case MC_PULL:
        return gLocal;
    case MC_CLONE:
        return !gLocalBlocked;
    case MC_REPOSITORY_ADDRESS:
    case MC_NEW_ISSUE:
        return gLocal || gRemote[0] != 0;
    case MC_BRANCH_ADDRESS:
    case MC_COMPARE_ADDRESS:
    case MC_CREATE_PR:
        return gLocal?gWork.haveHead:gRemote[0] != 0;
    case MC_ZOOM_IN:
        return gDiffSize < 14;
    case MC_ZOOM_OUT:
        return gDiffSize > 9;
    }
    return 1;
}
static void UpdateMenus(void) {
    short mid, item, command;
    MenuHandle menu;
    for (mid = 129; mid <= 134; ++mid) {
        menu = GetMenuHandle(mid);
        if (!menu)
            continue;
        for (item = 1; item <= CountMItems(menu); ++item) {
            command = MenuCommand(mid, item);
            if(command==MC_COLOR_HIGHLIGHTS)CheckItem(menu,item,!gMonochrome);
            if (command && MenuAllowed(command))
                EnableItem(menu, item);
            else
                DisableItem(menu, item);
        }
    }
    menu = GetMenuHandle(131);
    if (menu) {
        CheckItem(menu, 1, !gTab);
        CheckItem(menu, 2, gTab);
    }
}
static int CloseRepository(void) {
    if (SettingsRelease()) {
        SetStatus("The ignore editor could not close its files. Try Refresh, or quit GitHub Classic.");
        return 0;
    }
    if (gLocal)
        LocalClose();
    ClearRemote();
    EditReset();
    gChangeFilter[0] = 0;
    gTab = 0;
    if (gUser[0])
        ShowControl(gBrowse);
    else
        ShowControl(gSignIn);
    SetStatus("Repository closed. Its files remain on disk.");
    return 1;
}
static void Menu(long choice) {
    short id = (short)(choice >> 16), item = (short)choice;
    short command = MenuCommand(id, item), hit;
    DialogPtr d;
    if (id == 128 && item > 2) {
        Str255 name;
        GetMenuItemText(GetMenuHandle(128), item, name);
        OpenDeskAcc(name);
    } else if (MenuAllowed(command)) {
        if(command!=MC_CLOSE_REPOSITORY && command!=MC_REMOVE_REPOSITORY && command!=MC_QUIT)
            ShowWorkspace();
        switch (command) {
        case MC_COLOR_HIGHLIGHTS:
            gMonochrome=!gMonochrome;
            DiffScroll();
            break;
        case MC_CLONE:
            NetworkClone();
            break;
        case MC_DISCARD_CHANGES:
            DiscardChangesCommand();
            break;
        case MC_STASHED_CHANGES:
            StashedChangesCommand();
            break;
        case MC_STASH_CHANGES:
            StashChangesCommand();
            break;
        case MC_SAVED_CHANGES:
            SavedChangesCommand();
            break;
        case MC_ABOUT:
        case MC_HELP_ABOUT:
            d = GetNewDialog(128, NULL, (WindowPtr)-1);
            if (d) {
                PrepareAboutArt(d);
                PrepareDialog(d, 1, 1);
                RunModalDialog(gDialogFilter, &hit);
                DisposeDialog(d);
            }
            break;
        case MC_NEW_REPOSITORY:
            LocalOpenMode(1);
            break;
        case MC_ADD_REPOSITORY:
            LocalOpenMode(0);
            break;
        case MC_OPEN_REMOTE:
            OpenRemoteByName();
            break;
        case MC_PREFERENCES:
            Preferences();
            break;
        case MC_QUIT:
            gDone = 1;
            break;
        case MC_CLOSE_REPOSITORY:
            CloseWorkspace();
            break;
        case MC_REMOVE_REPOSITORY:
            RecentRemoveCurrent();
            break;
        case MC_UNDO:
            EditRestore(0);
            break;
        case MC_REDO:
            EditRestore(1);
            break;
        case MC_CUT:
        case MC_COPY:
        case MC_PASTE:
        case MC_SELECT_ALL:
            if (gLocal && gCommitField && !gTab) {
                if (command == MC_CUT || command == MC_PASTE)
                    EditCapture();
                LocalEditMenu(command == MC_CUT     ? 3
                              : command == MC_COPY  ? 4
                              : command == MC_PASTE ? 5
                                                    : 6);
            } else if (command == MC_COPY) {
                ZeroScrap();
                PutScrap((long)strlen(gPatch), 'TEXT', gPatch);
            }
            break;
        case MC_FIND:
            FindText(1);
            break;
        case MC_FIND_NEXT:
            FindText(0);
            break;
        case MC_CHANGES:
            gTab = 0;
            if (gLocal) {
                LocalRows();
                LocalEditState();
            }
            break;
        case MC_HISTORY:
            if (gCommitField)
                TEDeactivate(gCommitField == 1 ? gSummaryEdit : gDescriptionEdit);
            gCommitField = 0;
            gTab = 1;
            if (gLocal) {
                gLocalHistoryPage = 1;
                LocalHistoryLoad();
                LocalEditState();
            } else
                LoadHistory();
            break;
        case MC_REPOSITORY_LIST:
        case MC_RECENT_REPOSITORIES:
            RecentRepositories();
            break;
        case MC_GITHUB_REPOSITORIES:
            ChooseRepository();
            break;
        case MC_BRANCH_INFO:
            BranchInfo();
            break;
        case MC_GO_SUMMARY:
            gTab = 0;
            if (gCommitField)
                TEDeactivate(gCommitField == 1 ? gSummaryEdit : gDescriptionEdit);
            gCommitField = 1;
            TEActivate(gSummaryEdit);
            LocalRows();
            break;
        case MC_FILTER_CHANGES:
            if (AskAction("Filter Changed Files",
                    "Show paths containing this text. Leave empty to show all changes. Filtering "
                    "does not change staging.",
                    "Filter",ASK_FILTER,gChangeFilter)) {
                gTab = 0;
                LocalRows();
            }
            break;
        case MC_ZOOM_RESET:
        case MC_ZOOM_IN:
        case MC_ZOOM_OUT:
            gDiffSize = command == MC_ZOOM_RESET ? 9 : gDiffSize + (command == MC_ZOOM_IN ? 1 : -1);
            DiffScroll();
            break;
        case MC_REFRESH:
            if (gLocal)
                LocalRefresh();
            else {
                RCClear(&gRemoteCache);
                LoadHistory();
            }
            break;
        case MC_COMMIT:
            LocalCommit();
            break;
        case MC_FETCH:
            NetworkFetch();
            break;
        case MC_PULL:
            NetworkPull();
            break;
        case MC_PUSH:
            NetworkPush();
            break;
        case MC_FORCE_PUSH:
            NetworkForcePush();
            break;
        case MC_REVIEW_PUSH:
            NetworkReviewPush();
            break;
        case MC_SHOW_FINDER:
            FinderOpen(&gWork.folder);
            break;
        case MC_OPEN_EDITOR:
            FinderOpen(&gWork.files[gLocalRows[gLocalSelection]].file);
            break;
        case MC_REPOSITORY_SETTINGS:
            RepositorySettings();
            break;
        case MC_NEW_BRANCH:
            NewBranch();
            break;
        case MC_SWITCH_BRANCH:
            SwitchBranch();
            break;
        case MC_RENAME_BRANCH:
            BranchEditCommand(BE_RENAME);
            break;
        case MC_DELETE_BRANCH:
            BranchEditCommand(BE_DELETE);
            break;
        case MC_COMPARE_BRANCH:
            CompareBranch();
            break;
        case MC_MERGE:
            MergeCommand();
            break;
        case MC_SQUASH_MERGE:
            SquashCommand();
            break;
        case MC_REBASE:
            RebaseCommand();
            break;
        case MC_UPDATE_BRANCH:
            UpdateDefaultCommand();
            break;
        case MC_FETCH_DEFAULT:
            FetchDefaultCommand();
            break;
        case MC_PREVIEW_PR:
            PullPreviewCommand();
            break;
        case MC_REPOSITORY_ADDRESS:
        case MC_NEW_ISSUE:
        case MC_BRANCH_ADDRESS:
        case MC_COMPARE_ADDRESS:
        case MC_CREATE_PR:
        case MC_REPORT_ISSUE:
            GitHubAddress(command);
            break;
        case MC_GUIDE:
            Message("GitHub Classic Guide",
                    "File > New Repository creates a local repository. Add Local Repository opens "
                    "one. View > Local Repositories keeps the twenty most recently opened folders. "
                    "Remove from Recent List forgets an entry and keeps its files.\r\rChanges: check files to stage both forks and Finder attributes. Enter "
                    "a summary and commit.\r\rHistory: read local commits without signing in. "
                    "Branch > New Branch preserves your working files.\r\rPreferences manages "
                    "GitHub sign-in and encrypted saved login. Clone chooses its destination graphically. "
                    "Fetch updates remote tracking; Pull reviews the current branch update; Push sends committed changes. "
                    "Branch includes compare, merge, squash, rebase and saved conflict review. "
                    "Review the operation before approving; Cancel preserves the saved operation. "
                    "View > GitHub Repositories browses your account online. Local review does not require a network connection.");
            break;
        case MC_SHORTCUTS:
            Message(
                "Keyboard Shortcuts",
                "Command-N  New repository\rCommand-O  Add local repository\rCommand-,  "
                "Preferences\rCommand-W  Close repository\rCommand-Q  Quit\r\rCommand-Z / Y  Undo "
                "/ Redo\rCommand-X / C / V / A  Cut / Copy / Paste / Select all\rCommand-F  Find "
                "in comparison\r\rCommand-1 / 2  Changes / History\rCommand-T  Local repository "
                "list\rCommand-B  Current branch\rCommand-G  Go to summary\rCommand-L  Filter "
                "changed files\rCommand-0 / = / -  Comparison text size\rCommand-R  "
                "Refresh\rCommand-K  Commit staged changes\rCommand-D  New branch");
            break;
        case MC_TEST_TLS:
            TestConnection();
            break;
        case MC_TEST_STORE:
            TestLocalGit();
            break;
        case MC_TEST_MERGE:
            TestMergeCheckout();
            break;
        case MC_TEST_MAP:
            TestPathMapGit();
            break;
        case MC_TEST_PUSH_PACK:
            NetworkPushCheck();
            break;
        case MC_TEST_RESTORE:
            TestRestoreGit();
            break;
        case MC_TLS_DIAGNOSTICS: {
            FILE *file = fopen("TLS Probe.txt", "rb");
            char text[4096];
            size_t n;
            if (!file)
                Message("Connection Diagnostics",
                        "Run Help > Test GitHub Connection first. This public test records timings "
                        "and verification flags, without account credentials.");
            else {
                n = fread(text, 1, sizeof(text) - 1, file);
                fclose(file);
                text[n] = 0;
                Message("Public Connection Diagnostics", text);
            }
            break;
        }
        }
    }
    HiliteMenu(0);
    if (gWindow) {
        SetPort(gWindow);
        InvalRect(&gWindow->portRect);
    }
}
