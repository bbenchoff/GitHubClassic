#include "GitWorkMac.h"
#include "GitIgnore.h"
#include <Errors.h>
#include <TextUtils.h>
#include <stdlib.h>
#include <string.h>

/* HFS catalog comparison uses the classic RelString order. The actual
   writer still detects collisions through File Manager directory/file IDs. */
int GWMacNameEqual(void *context, const char *a, const char *b) {
    Str31 x, y;
    size_t n = strlen(a), m = strlen(b);
    (void)context;
    if (n > 31 || m > 31) return 0;
    x[0] = (unsigned char)n; memcpy(x+1, a, n);
    y[0] = (unsigned char)m; memcpy(y+1, b, m);
    return RelString(x, y, false, true) == 0;
}
int GWNativePath(const char *path, char **output) { return GPDirectNative(path, output); }
static int GWFork(short file, unsigned char **bytes, size_t *length, size_t limit) {
    long size, count, done = 0;
    unsigned char *p;
    OSErr error;
    *bytes = NULL;
    *length = 0;
    error = GetEOF(file, &size);
    if (error || size < 0) {
        return GS_IO;
    }
    if ((size_t)size > limit) return GB_SPACE;
    p = (unsigned char *)malloc(size ? (size_t)size : 1);
    if (!p) {
        return GB_MEMORY;
    }
    while (!error && done < size) {
        count = size - done;
        if (count > 32768)
            count = 32768;
        error = FSRead(file, &count, p + done);
        done += count;
        if (!error && !count)
            error = eofErr;
    }
    if (error) {
        free(p);
        return GS_IO;
    }
    *bytes = p;
    *length = (size_t)size;
    return 0;
}
static OSErr GWCatalog(const FSSpec *file, CInfoPBRec *pb) {
    memset(pb, 0, sizeof(*pb));
    pb->hFileInfo.ioNamePtr = (StringPtr)file->name;
    pb->hFileInfo.ioVRefNum = file->vRefNum;
    pb->hFileInfo.ioDirID = file->parID;
    return PBGetCatInfoSync(pb);
}
int GWReadFile(const FSSpec *file, unsigned char **data, size_t *dataLength, unsigned char info[32],
               unsigned char **resource, size_t *resourceLength) {
    return GWReadFileLimit(file, data, dataLength, info, resource, resourceLength, (size_t)-1);
}
int GWReadFileLimit(const FSSpec *file, unsigned char **data, size_t *dataLength, unsigned char info[32],
                    unsigned char **resource, size_t *resourceLength, size_t limit) {
    CInfoPBRec before, after;
    short dataRef,resourceRef;
    int result=0,haveData=0,haveResource=0;
    OSErr error,closed;
    *data = NULL;
    *resource = NULL;
    *dataLength = *resourceLength = 0;
    if (GWCatalog(file, &before) || (before.hFileInfo.ioFlAttrib & 16))
        return GS_IO;
    /* Hold both fork access paths through readback/catalog validation. Closing
       the data fork before opening the resource fork left an avoidable gap. */
    error=FSpOpenDF(file,fsRdPerm,&dataRef);
    if(!error){haveData=1;error=FSpOpenRF(file,fsRdPerm,&resourceRef);if(!error)haveResource=1;}
    if(error)result=GS_IO;
    if(!result)result=GWFork(dataRef,data,dataLength,limit);
    if(!result)result=GWFork(resourceRef,resource,resourceLength,limit);
    if (!result && GWCatalog(file, &after))
        result = GS_IO;
    if (!result && (before.hFileInfo.ioDirID != after.hFileInfo.ioDirID ||
                    before.hFileInfo.ioFlMdDat != after.hFileInfo.ioFlMdDat ||
                    before.hFileInfo.ioFlLgLen != after.hFileInfo.ioFlLgLen ||
                    before.hFileInfo.ioFlRLgLen != after.hFileInfo.ioFlRLgLen ||
                    memcmp(&before.hFileInfo.ioFlFndrInfo, &after.hFileInfo.ioFlFndrInfo, 16) ||
                    memcmp(&before.hFileInfo.ioFlXFndrInfo, &after.hFileInfo.ioFlXFndrInfo, 16)))
        result = GS_CONFLICT;
    if(haveResource){closed=FSClose(resourceRef);if(!result && closed)result=GS_IO;}
    if(haveData){closed=FSClose(dataRef);if(!result && closed)result=GS_IO;}
    if (result) {
        free(*data);
        free(*resource);
        *data = *resource = NULL;
        *dataLength = *resourceLength = 0;
        return result;
    }
    memcpy(info, &before.hFileInfo.ioFlFndrInfo, 16);
    memcpy(info + 16, &before.hFileInfo.ioFlXFndrInfo, 16);
    /* Desktop position, containing/put-away folder IDs and has-been-initialized
       are machine-local Finder bookkeeping, not portable file attributes. */
    info[8] &= (unsigned char)~1U;
    memset(info + 10, 0, 6);
    memset(info + 28, 0, 4);
    return 0;
}
void GWInit(GWWorkspace *w) { memset(w, 0, sizeof(*w)); }
static void GWFreeFiles(GWWorkspace *w) {
    size_t i;
    for (i = 0; i < w->count; ++i)
        free(w->files[i].path);
    free(w->files);
    w->files = NULL;
    w->count = 0;
}
void GWClose(GWWorkspace *w) {
    if(w->database.leaseHeld)GSMacLeave(&w->database);
    if(w->root.leaseHeld)GSMacLeave(&w->root);
    GWFreeFiles(w);
    GIFree(&w->index);
    GIFree(&w->head);
    GPFree(&w->mapping);
    free(w->branch);
    GWInit(w);
}
static int GWReserved(const char *path) {
    size_t n = strlen(GI_MAC_NAMESPACE);
    return !strncmp(path, GI_MAC_NAMESPACE, n) && (!path[n] || path[n] == '/');
}
static int GWAdd(GWWorkspace *w, const char *path, const FSSpec *spec) {
    GWFile *files, *f;
    size_t n = strlen(path);
    if (w->count >= (size_t)-1 / sizeof(*files))
        return GB_SPACE;
    files = (GWFile *)realloc(w->files, (w->count + 1) * sizeof(*files));
    if (!files)
        return GB_MEMORY;
    w->files = files;
    f = files + w->count;
    memset(f, 0, sizeof(*f));
    f->path = (char *)malloc(n + 1);
    if (!f->path)
        return GB_MEMORY;
    memcpy(f->path, path, n + 1);
    if (spec) {
        f->file = *spec;
        f->exists = 1;
    }
    ++w->count;
    return 0;
}
static int GWFileOrder(const void *a, const void *b) {
    return strcmp(((const GWFile *)a)->path, ((const GWFile *)b)->path);
}
static GWFile *GWFind(GWWorkspace *w, const char *path) {
    size_t lo = 0, hi = w->count, mid;
    int cmp;
    while (lo < hi) {
        mid = lo + (hi - lo) / 2;
        cmp = strcmp(w->files[mid].path, path);
        if (cmp < 0)
            lo = mid + 1;
        else
            hi = mid;
    }
    return lo < w->count && !strcmp(w->files[lo].path, path) ? w->files + lo : NULL;
}
typedef struct {
    long directory, next;
    char *prefix, *base;
    int excluded;
} GWScanFrame;
/* Index names are sorted by exact Git bytes. Find the first candidate at or
   after path + '/', without allocating a temporary prefix. */
static int GWTrackedBelow(const GIIndex *index, const char *path) {
    size_t lo = 0, hi = index->count, mid, n = strlen(path);
    int cmp;
    const char *p;
    while (lo < hi) {
        mid = lo + (hi - lo) / 2; p = index->entries[mid].path;
        cmp = strncmp(p, path, n);
        if (!cmp) cmp = (unsigned char)p[n] - '/';
        if (cmp < 0) lo = mid + 1; else hi = mid;
    }
    if (lo == index->count) return 0;
    p = index->entries[lo].path;
    return !strncmp(p, path, n) && p[n] == '/';
}
static int GWIgnoreSource(GWWorkspace *w, GOSet *rules, const GWScanFrame *frame) {
    const GPEntry *mapped;
    const GIEntry *indexed;
    const char *leaf;
    char *logical, *native, *resolved;
    unsigned char *data = NULL, *resource = NULL, info[32];
    size_t base = strlen(frame->base), prefix = strlen(frame->prefix), dn, rn;
    CInfoPBRec pb;
    Str255 name;
    FSSpec spec;
    long number;
    OSErr error;
    int result = 0;
    logical = (char *)malloc(base + 12);
    if (!logical) return GB_MEMORY;
    memcpy(logical, frame->base, base);
    if (base) logical[base++] = '/';
    memcpy(logical + base, ".gitignore", 11);
    mapped = GPFind(&w->mapping, logical); indexed = GIFind(&w->index, logical, 0);
    /* Foreign Git symlinks are literal native files, never rule sources. */
    if ((mapped && mapped->mode == 0120000) || (indexed && indexed->stat[6] == 0120000)) goto done;
    leaf = mapped ? strrchr(mapped->native, ':') : NULL;
    leaf = mapped ? (leaf ? leaf + 1 : mapped->native) : ".gitignore";
    /* Enumerate actual names: HFS lookup is case insensitive, Git identities
       and ignore patterns are not. Resolve aliases before reading a source. */
    for (number = 1; number <= 32767; ++number) {
        char actual[256];
        memset(&pb, 0, sizeof(pb)); pb.dirInfo.ioNamePtr = name;
        pb.dirInfo.ioVRefNum = w->root.volume; pb.dirInfo.ioDrDirID = frame->directory;
        pb.dirInfo.ioFDirIndex = (short)number; error = PBGetCatInfoSync(&pb);
        if (error == fnfErr) goto done;
        if (error) { w->root.lastError = error; result = GS_IO; goto done; }
        memcpy(actual, name + 1, name[0]); actual[name[0]] = 0;
        if (memchr(name + 1, 0, name[0])) { result = GI_UNSUPPORTED; goto done; }
        if (!GWMacNameEqual(NULL, actual, leaf)) continue;
        if (pb.dirInfo.ioFlAttrib & 16) goto done;
        native = (char *)malloc(prefix + name[0] + 1);
        if (!native) { result = GB_MEMORY; goto done; }
        memcpy(native, frame->prefix, prefix); memcpy(native + prefix, actual, (size_t)name[0] + 1);
        result = GPResolveWork(&w->mapping,native,GWMacNameEqual,NULL,&resolved);free(native);
        if (result) goto done;
        if (strcmp(resolved, logical)) { free(resolved); goto done; }
        free(resolved);
        memset(&spec, 0, sizeof(spec)); spec.vRefNum = w->root.volume; spec.parID = frame->directory;
        memcpy(spec.name, name, (size_t)name[0] + 1);
        result = GWReadFileLimit(&spec, &data, &dn, info, &resource, &rn, 65536UL);
        /* A Finder alias is also never followed or interpreted as rules. */
        if (!result && !(info[8] & 0x80)) result = GOAdd(rules, frame->base, 1, data, dn);
        goto done;
    }
    result = GI_UNSUPPORTED;
done:
    free(data); free(resource); free(logical); return result;
}
static int GWScan(GWWorkspace *w) {
    GWScanFrame *stack, *f;
    size_t depth = 0, count = 1, i, a, b;
    CInfoPBRec pb;
    Str255 name;
    char *path, *native;
    unsigned char *exclude = NULL;
    size_t excludeLength;
    GOSet rules;
    FSSpec spec;
    OSErr error;
    int result = 0, ignored;
    GOInit(&rules); w->ignored = 0;
    result = GSMacReadLimit(&w->database, "info/exclude", &exclude, &excludeLength, 65536UL);
    if (!result) result = GOAdd(&rules, "", 0, exclude, excludeLength);
    else if (result == GS_NOT_FOUND) result = 0;
    free(exclude);
    if (result) { GOFree(&rules); return result; }
    stack = (GWScanFrame *)calloc(1, sizeof(*stack));
    if (!stack) { GOFree(&rules); return GB_MEMORY; }
    stack[0].directory = w->root.directory;
    stack[0].prefix = (char *)calloc(1, 1);
    stack[0].base = (char *)calloc(1, 1);
    if (!stack[0].prefix || !stack[0].base) {
        free(stack[0].prefix); free(stack[0].base); free(stack); GOFree(&rules);
        return GB_MEMORY;
    }
    for (;;) {
        f = stack + depth;
        if (!f->next) {
            /* An excluded directory is entered only to inspect indexed paths.
               Its rule files cannot affect untracked children or revive it. */
            result = f->excluded ? 0 : GWIgnoreSource(w, &rules, f);
            if (result) break;
            f->next = 1;
        }
        if (f->next > 32767) {
            result = GI_UNSUPPORTED;
            break;
        }
        memset(&pb, 0, sizeof(pb));
        pb.dirInfo.ioNamePtr = name;
        pb.dirInfo.ioVRefNum = w->root.volume;
        pb.dirInfo.ioDrDirID = f->directory;
        pb.dirInfo.ioFDirIndex = (short)f->next++;
        error = PBGetCatInfoSync(&pb);
        if (error == fnfErr) {
            free(f->prefix);
            f->prefix = NULL;
            free(f->base); f->base = NULL;
            if (!depth)
                break;
            --depth;
            continue;
        }
        if (error) {
            w->root.lastError = error;
            result = GS_IO;
            break;
        }
        if (memchr(name+1, 0, name[0])) { result = GI_UNSUPPORTED; break; }
        if (!depth) {
            char rootName[256];
            memcpy(rootName, name+1, name[0]); rootName[name[0]] = 0;
            if (GWMacNameEqual(NULL, rootName, ".git")) continue;
        }
        a = strlen(f->prefix); b = name[0];
        if (a > (size_t)-1-b-2) { result = GB_SPACE; break; }
        native = (char *)malloc(a+b+2);
        if (!native) { result = GB_MEMORY; break; }
        memcpy(native, f->prefix, a); memcpy(native+a, name+1, b); native[a+b] = 0;
        result = GPResolveWork(&w->mapping,native,GWMacNameEqual,NULL,&path);
        if (result) { free(native); break; }
        if (pb.dirInfo.ioFlAttrib & 16) {
            result = GOIgnored(&rules, path, 1, &ignored);
            if (result) { free(path); free(native); break; }
            if (ignored && !GWTrackedBelow(&w->index, path)) {
                ++w->ignored; free(path); free(native); continue;
            }
            native[a+b] = ':'; native[a+b+1] = 0;
            if (depth + 1 == count) {
                GWScanFrame *grown;
                if (count == (size_t)-1 / sizeof(*stack)) {
                    free(native); free(path);
                    result = GB_SPACE;
                    break;
                }
                grown = (GWScanFrame *)realloc(stack, (count + 1) * sizeof(*stack));
                if (!grown) {
                    free(native); free(path);
                    result = GB_MEMORY;
                    break;
                }
                stack = grown;
                memset(stack + count, 0, sizeof(*stack));
                ++count;
            }
            f = stack + (++depth);
            f->directory = pb.dirInfo.ioDrDirID;
            f->next = 0;
            f->prefix = native;
            f->base = path;
            f->excluded = ignored;
        } else {
            if (!GIFind(&w->index, path, 0)) {
                result = GOIgnored(&rules, path, 0, &ignored);
                if (result) { free(path); free(native); break; }
                if (ignored) { ++w->ignored; free(path); free(native); continue; }
            }
            memset(&spec, 0, sizeof(spec));
            spec.vRefNum = w->root.volume;
            spec.parID = f->directory;
            memcpy(spec.name, name, (size_t)name[0] + 1);
            result = GWAdd(w, path, &spec);
            free(path); free(native);
            if (result)
                break;
        }
    }
    for (i = 0; i < count; ++i) { free(stack[i].prefix); free(stack[i].base); }
    free(stack); GOFree(&rules);
    return result;
}
static int GWEqual(const GIEntry *a, const GIEntry *b) {
    return (!a && !b) || (a && b && a->stat[6] == b->stat[6] && !memcmp(a->oid, b->oid, 20));
}
static int GWRefreshRaw(GWWorkspace *w) {
    size_t i, j, dataLength, resourceLength;
    unsigned char *data, *resource, info[32];
    char metaPath[96];
    const GIEntry *staged, *head, *stagedMeta, *headMeta;
    GWFile *file;
    GIIndex *sets[2];
    int result, forks, sameMetadata;
    result = GPLoad(&w->repository, GWMacNameEqual, NULL, &w->mapping);
    if (result) return result;
    result = GILoad(&w->repository, &w->index);
    if (result)
        return result;
    result = GIReadHead(&w->repository, &w->head, w->tip, &w->haveHead);
    if (result)
        return result;
    free(w->branch);
    w->branch = NULL;
    result = GSHead(&w->repository, &w->branch, w->tip);
    if (result && result != GS_NOT_FOUND)
        return result;
    GWFreeFiles(w);
    result = GWScan(w);
    if (result)
        return result;
    if(w->count>1)qsort(w->files, w->count, sizeof(*w->files), GWFileOrder);
    sets[0] = &w->index;
    sets[1] = &w->head;
    for (j = 0; j < 2; ++j)
        for (i = 0; i < sets[j]->count; ++i) {
            const char *path = sets[j]->entries[i].path;
            if (GWReserved(path) || GWFind(w, path))
                continue;
            result = GWAdd(w, path, NULL);
            if (result)
                return result;
            qsort(w->files, w->count, sizeof(*w->files), GWFileOrder);
        }
    for (i = 0; i < w->count; ++i) {
        file = w->files + i;
        result = GIMacMetadataPath(file->path, metaPath);
        if (result)
            return result;
        staged = GIFind(&w->index, file->path, 0);
        head = GIFind(&w->head, file->path, 0);
        stagedMeta = GIFind(&w->index, metaPath, 0);
        headMeta = GIFind(&w->head, metaPath, 0);
        file->staged = !GWEqual(staged, head) || !GWEqual(stagedMeta, headMeta);
        file->untracked = !staged && !head;
        file->deleted = !file->exists;
        if (file->exists) {
            result = GWReadFile(&file->file, &data, &dataLength, info, &resource, &resourceLength);
            if (result)
                return result;
            result = GPWorkPolicy(GPFind(&w->mapping, file->path), staged, info, resourceLength,
                                  &file->mode, &forks);
            file->hasMetadata = forks;
            if (!result) result = GBObjectID("blob", data, dataLength, file->dataOID);
            free(data);
            memset(file->metadataOID, 0, 20);
            if (!result && forks)
                result = GPMetadataOID(&w->repository, &w->index, file->path, info, resource,
                                       resourceLength, file->metadataOID, &sameMetadata);
            free(resource);
            if (result) return result;
            file->unstaged = !staged || staged->stat[6] != file->mode ||
                             memcmp(staged->oid, file->dataOID, 20) ||
                             (!!stagedMeta != !!forks) ||
                             (forks && stagedMeta && memcmp(stagedMeta->oid, file->metadataOID, 20));
        } else
            file->unstaged = staged != NULL || stagedMeta != NULL;
    }
    return 0;
}
int GWRefresh(GWWorkspace *w) {
    int result,closed,acquired;
    if(!w)return GB_BAD;
    acquired=!w->database.leaseHeld;
    result=acquired?GSMacEnter(&w->database,0):0;
    if(result)return result;
    result=GWRefreshRaw(w);
    if(acquired){closed=GSMacLeave(&w->database);if(!result)result=closed;}
    return result;
}
int GWOpen(GWWorkspace *w, const FSSpec *folder, int create) {
    static const unsigned char databaseName[]={4,'.','g','i','t'};
    GWWorkspace next;
    GSRepository rootRepository;
    FSSpec database;
    OSErr error;
    int result;
    GWInit(&next);
    next.folder = *folder;
    result = GSMacAttach(&rootRepository, &next.root, folder, create);
    if (result)
        return result;
    error = FSMakeFSSpec(next.root.volume,next.root.directory,databaseName,&database);
    if (error && error != fnfErr)
        return GS_IO;
    result = GSMacAttach(&next.repository, &next.database, &database, create);
    if (!result)
        result = create ? GSInit(&next.repository, "refs/heads/main") : GSOpen(&next.repository);
    if (!result)
        result = GWRefresh(&next);
    if (result) {
        GWClose(&next);
        return result;
    }
    GWClose(w);
    *w = next;
    w->repository.context = &w->database;
    return 0;
}
static int GWStageRaw(GWWorkspace *w, size_t i) {
    unsigned char *data, *resource, info[32];
    size_t dataLength, resourceLength;
    int result;
    if (i >= w->count)
        return GB_BAD;
    if (w->files[i].exists) {
        result =
            GWReadFile(&w->files[i].file, &data, &dataLength, info, &resource, &resourceLength);
        if (result)
            return result;
        result = GPStageWork(&w->repository, &w->index, GPFind(&w->mapping, w->files[i].path),
                             w->files[i].path, data, dataLength, info, resource, resourceLength);
        free(data);
        free(resource);
    } else
        result = GIRemoveMac(&w->index, w->files[i].path);
    if (!result)
        result = GISave(&w->repository, &w->index);
    if (result) {
        GILoad(&w->repository, &w->index);
        return result;
    }
    return GWRefresh(w);
}
static int GWUnstageRaw(GWWorkspace *w, size_t i) {
    int result;
    if (i >= w->count)
        return GB_BAD;
    result = GIUnstageMac(&w->index, &w->head, w->files[i].path);
    if (!result)
        result = GISave(&w->repository, &w->index);
    if (result) {
        GILoad(&w->repository, &w->index);
        return result;
    }
    return GWRefresh(w);
}
static int GWCommitRaw(GWWorkspace *w, const char *author, const char *committer, const char *seconds,
             const char *zone, const char *message, unsigned char oid[20]) {
    unsigned char tree[20], headTree[20];
    int result;
    /* Recheck the on-disk index before committing a cached UI selection. */
    GIIndex current;
    unsigned char *bytes;
    size_t n;
    GIInit(&current);
    result = w->repository.read(w->repository.context, "index", &bytes, &n);
    if (result)
        return result;
    if (!w->index.original || n != w->index.originalLength || memcmp(bytes, w->index.original, n)) {
        free(bytes);
        return GS_CONFLICT;
    }
    free(bytes);
    result = GIWriteTree(&w->repository, &w->index, tree);
    if (!result)
        result = GIWriteTree(&w->repository, &w->head, headTree);
    if (!result && !memcmp(tree, headTree, 20))
        return GS_CONFLICT;
    if (!result)
        result = GSCommit(&w->repository, w->branch, tree, w->haveHead ? w->tip : NULL, author,
                          committer, seconds, zone, message, oid);
    if (!result)
        result = GWRefresh(w);
    return result;
}
int GWStageSet(GWWorkspace *w, const size_t *rows, size_t count, int stage,
                int (*progress)(void *), void *context) {
    unsigned char *data = NULL, *resource = NULL, info[32];
    size_t at, index, dn, rn;
    int result, closed;
    if (!w || (!rows && count)) return GB_BAD;
    for (at = 0; at < count; ++at) if (rows[at] >= w->count) return GB_BAD;
    result = GSMacEnter(&w->database, 0); if (result) return result;
    for (at = 0; !result && at < count; ++at) {
        index = rows[at];
        if (progress && (result = progress(context)) != 0) break;
        if (!stage) result = GIUnstageMac(&w->index, &w->head, w->files[index].path);
        else if (!w->files[index].exists) result = GIRemoveMac(&w->index, w->files[index].path);
        else {
            result = GWReadFile(&w->files[index].file, &data, &dn, info, &resource, &rn);
            if (!result) result = GPStageWork(&w->repository, &w->index,
                GPFind(&w->mapping, w->files[index].path), w->files[index].path, data, dn, info, resource, rn);
            free(data); free(resource); data = resource = NULL;
        }
    }
    if (!result && progress) result = progress(context);
    if (!result) result = GISave(&w->repository, &w->index);
    if (result) GILoad(&w->repository, &w->index);
    closed = GSMacLeave(&w->database); if (!result) result = closed;
    if (!result) result = GWRefresh(w);
    return result;
}

int GWStage(GWWorkspace *w,size_t i) {
    int result,closed;
    if(!w)return GB_BAD;
    result=GSMacEnter(&w->database,0);if(result)return result;
    result=GWStageRaw(w,i);closed=GSMacLeave(&w->database);return result?result:closed;
}
int GWUnstage(GWWorkspace *w,size_t i) {
    int result,closed;
    if(!w)return GB_BAD;
    result=GSMacEnter(&w->database,0);if(result)return result;
    result=GWUnstageRaw(w,i);closed=GSMacLeave(&w->database);return result?result:closed;
}
int GWCommit(GWWorkspace *w,const char *author,const char *committer,const char *seconds,
              const char *zone,const char *message,unsigned char oid[20]) {
    int result,closed;
    if(!w)return GB_BAD;
    result=GSMacEnter(&w->database,0);if(result)return result;
    result=GWCommitRaw(w,author,committer,seconds,zone,message,oid);
    closed=GSMacLeave(&w->database);return result?result:closed;
}
