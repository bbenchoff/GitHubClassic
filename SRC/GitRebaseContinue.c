/* Included after GitRebaseUpdate.c; shares bounded reads and checkout values. */
#include "GitRebaseContinue.h"
#include "GitHistory.h"
void RLCInit(RLCPlan *p){memset(p,0,sizeof(*p));}
void RLCFree(RLCPlan *p){RLFree(&p->plan);RLCInit(p);}
static int RLCReceiptRoom(RZState *s) {
    RRItem *items;unsigned char (*proofs)[20];
    if(!s->count || s->count>4096 || s->completed>=s->count)return GB_BAD;
    items=(RRItem *)calloc(s->count,sizeof(*items));proofs=(unsigned char (*)[20])calloc(s->count,20);
    if(!items || !proofs){free(items);free(proofs);return GB_MEMORY;}
    if(s->completed){memcpy(items,s->receipts,s->completed*sizeof(*items));memcpy(proofs,s->proofs,s->completed*20);}
    free(s->receipts);free(s->proofs);s->receipts=items;s->proofs=proofs;return 0;
}
static void RLCRecord(RZState *s,const RPResult *receipt,const unsigned char *proof) {
    RRItem *item=s->receipts+s->completed;memcpy(item->candidate,s->commits[s->completed],20);memcpy(item->tip,receipt->commit,20);
    item->kind=receipt->kind;item->droppedSignatures=receipt->droppedSignatures;
    if(proof)memcpy(s->proofs[s->completed],proof,20);memcpy(s->tip,receipt->commit,20);++s->completed;
}
static int RLCFinalSnapshot(GSRepository *r,const unsigned char tip[20],const TMLimits *limits,GDProgress fn,void *ctx,GRSnapshot *out) {
    unsigned char *raw=NULL;size_t n=0;char type[7];GHCommitInfo info;GIReadLimits traversal;int result;
    memset(&traversal,0,sizeof(traversal));traversal.entries=limits->entries;traversal.depth=limits->depth;traversal.pathBytes=limits->pathBytes;traversal.progress=fn;traversal.context=ctx;
    result=GSGetObject(r,tip,type,&raw,&n);if(!result)result=strcmp(type,"commit")?GS_FORMAT:GHCommitParse(raw,n,&info);
    if(!result)result=GRFromTreeBounded(r,info.tree,out,&traversal);if(!result){out->haveCommit=1;memcpy(out->commit,tip,20);}free(raw);return result;
}
static int RLCPaths(WXKeys *paths,const GRSnapshot *head,const GRSnapshot *target,const MSLimits *limits) {
    size_t a=0,b=0;int order,result=0;
    while(!result && (a<head->count || b<target->count)) {
        order=a==head->count?1:b==target->count?-1:strcmp(head->files[a].path,target->files[b].path);
        if(order<0)result=WXPathAdd(paths,limits,head->files[a++].path);
        else if(order>0)result=WXPathAdd(paths,limits,target->files[b++].path);
        else {if(!WXFileSame(head,head->files+a,target,target->files+b))result=WXPathAdd(paths,limits,head->files[a].path);++a;++b;}
    }
    return result;
}
int RLContinue(GSRepository *source,const void *expected,size_t length,const RLLimits *limits,const unsigned char binding[32],
    const GQWork *work,size_t count,GPEqual eq,void *eqCtx,GDProgress fn,void *ctx,RLCPlan *out,GQError *why) {
    RLSession *old;RLCPlan *next;RZState state;RVVerified verified;RKState parsed;MSWorkspace drafts;GRSnapshot target;GIIndex original,composed;
    RLIO io;RLView view;GSRepository r,virtualRepo;MSBytes incoming;WXKeys paths,keys;GQProtection protection;RSStep step;RPResult receipt;
    const GCMetadata *m,*map,*index;unsigned char *wire=NULL,*bytes=NULL,proof[20];size_t wn=0,n=0,i;GBWord generation=0;char incomingKey[64],branchKey[64];int result;
    if(!source || !source->replace || !expected || !length || !limits || !binding || !out || !eq || (count && !work))return GB_BAD;
    if(why)memset(why,0,sizeof(*why));old=(RLSession *)calloc(1,sizeof(*old));next=(RLCPlan *)calloc(1,sizeof(*next));
    if(!old || !next){free(old);free(next);return GB_MEMORY;}RZInit(&state);RVInit(&verified);RKInit(&parsed);MSWorkspaceInit(&drafts);GRInit(&target);GIInit(&original);GIInit(&composed);RSInit(&step);
    memset(&view,0,sizeof(view));memset(&incoming,0,sizeof(incoming));memset(&paths,0,sizeof(paths));memset(&keys,0,sizeof(keys));memset(&protection,0,sizeof(protection));
    result=RLIOStart(source,limits,fn,ctx,&io,&r);if(!result)result=RLOpen(&r,limits,binding,eq,eqCtx,fn,ctx,old);
    if(!result && (length!=old->state.originalLength || memcmp(expected,old->state.original,length)))result=GS_CONFLICT;
    if(!result && old->drafts.index.unresolved)result=GI_UNMERGED;
    if(!result && !WXIndexSame(&old->index,&old->workIndex))result=GS_CONFLICT;
    if(!result)result=RLLive(&r,&old->state,&generation);
    if(!result)result=GSRefKey(old->state.replay.ontoRef,incomingKey);if(!result)result=WXTake(&r,incomingKey,&incoming);if(!result)result=WXRefShape(&incoming,old->state.replay.ontoRef);
    if(!result)result=RZParse(old->state.replay.original,old->state.replay.originalLength,&limits->state,eq,eqCtx,&state);
    if(!result)result=RLCReceiptRoom(&state);
    /* The read-only opener already proved these exact saved records and their
       objects against this current conflict. Publish that canonical proof. */
    if(!result)result=RZChoicesEncode(&state.choices,&limits->state,&wire,&wn);
    if(!result)result=GSPutObject(&r,"blob",wire,wn,proof);free(wire);wire=NULL;wn=0;
    if(!result)result=RXPublish(&r,&old->replay.conflict,old->replay.choices.items,old->replay.choices.count,
        state.committer,state.seconds,state.zone,fn,ctx,&receipt);
    if(!result){RLCRecord(&state,&receipt,proof);MSChoicesFree(&state.choices);free(state.original);state.original=NULL;state.originalLength=0;}
    while(!result && state.completed<state.count) {
        result=RSPrepare(&r,state.commits[state.completed],state.tip,state.newline,&limits->replay.step,fn,ctx,&step);
        if(!result && step.kind==RS_CONFLICT)break;
        if(!result)result=RPPublish(&r,&step,state.committer,state.seconds,state.zone,fn,ctx,&receipt);
        if(!result)RLCRecord(&state,&receipt,NULL);RSFree(&step);
    }
    if(!result){next->completed=state.completed;memcpy(next->tip,state.tip,20);for(i=0;i<state.completed;++i)next->droppedSignatures|=state.receipts[i].droppedSignatures;next->finished=state.completed==state.count;}
    if(!result && !next->finished && generation==0xffffffffU)result=GB_SPACE;
    if(!result)result=RKParse(old->state.original,old->state.originalLength,&limits->state,eq,eqCtx,&next->plan.state);
    if(!result && !next->finished) {
        result=RZStepID(&step,state.branch,state.ontoRef,state.planID);if(!result){memcpy(state.choices.planID,state.planID,20);state.revision=generation;
            RZFree(&next->plan.state.replay);next->plan.state.replay=state;RZInit(&state);}
        if(!result)result=RVVerify(&r,&next->plan.state.replay,&limits->state,&limits->replay,eq,eqCtx,fn,ctx,&verified);
        if(!result)result=RLPreview(&r,&next->plan.state.replay,&verified,fn,ctx,&drafts,next->plan.tree,next->plan.state.workspace,&target);
    } else if(!result) {
        result=RLCFinalSnapshot(&r,next->tip,&limits->replay.step,fn,ctx,&target);if(!result)memcpy(next->plan.tree,target.tree,20);
    }
    if(!result){paths.paths=next->plan.state.affected;paths.count=next->plan.state.affectedCount;next->plan.state.affected=NULL;next->plan.state.affectedCount=0;}
    if(!result && !next->finished)result=RLAffected(&paths,&old->replay.original,&verified.conflict,&next->plan.state.replay.choices,&target,&limits->state.records);
    if(!result && next->finished)result=RLCPaths(&paths,&old->replay.original,&target,&limits->state.records);
    if(!result)result=WXKeysMake((const char *const *)paths.paths,paths.count,&keys);
    protection.paths=(const char *const *)paths.paths;protection.count=paths.count;protection.changed=1;
    if(!result)result=RLViewStart(&r,&old->state,&view,&virtualRepo);
    if(!result)result=GQToCommitProtected(&virtualRepo,old->state.replay.branch,old->state.workspace,next->finished?next->tip:next->plan.state.workspace,
        work,count,&protection,eq,eqCtx,&next->plan.checkout,why);
    if(!result)result=GIParse(old->state.replay.before[2].bytes,old->state.replay.before[2].length,&original);
    if(!result)result=WXCompose(&old->replay.original.index,&original,next->finished?&target.index:&drafts.preview.index,&keys,&composed);
    if(!result && !WXIndexSame(&composed,&next->plan.checkout.index))result=GS_CONFLICT;
    index=WXMeta(&next->plan.checkout.transaction,"index");map=WXMeta(&next->plan.checkout.transaction,"ghclient-map");if(!result && (!index || !map))result=GS_FORMAT;
    if(!result && !next->finished) {
        result=WXCompose(&old->replay.original.index,&original,&drafts.index.index,&keys,&composed);
        if(!result)result=GIEncode(&composed,&bytes,&n);if(!result)result=WXBytesSet(&next->plan.state.index,bytes,n,1);free(bytes);bytes=NULL;
        if(!result)result=WXBytesSet(&next->plan.state.workIndex,index->after,index->afterLength,index->afterPresent);
        if(!result)result=WXBytesSet(&next->plan.state.mapping,map->after,map->afterLength,map->afterPresent);
        if(!result){next->plan.state.affected=paths.paths;next->plan.state.affectedCount=paths.count;memset(&paths,0,sizeof(paths));result=RKEncode(&next->plan.state,&limits->state,eq,eqCtx,&wire,&wn);}
        if(!result)result=RKParse(wire,wn,&limits->state,eq,eqCtx,&parsed);if(!result){RKFree(&next->plan.state);next->plan.state=parsed;RKInit(&parsed);}
    }
    if(!result)result=GSRefKey(old->state.replay.branch,branchKey);
    if(!result)result=WXMetaSet(&next->plan.checkout.transaction,"HEAD",old->state.replay.before[0].bytes,old->state.replay.before[0].length,1,
        old->state.replay.before[0].bytes,old->state.replay.before[0].length,1);
    m=!result?WXMeta(&next->plan.checkout.transaction,branchKey):NULL;
    if(!result && !m)result=GS_FORMAT;
    if(!result)result=WXMetaSet(&next->plan.checkout.transaction,branchKey,old->state.replay.before[1].bytes,old->state.replay.before[1].length,1,
        next->finished?m->after:old->state.replay.before[1].bytes,next->finished?m->afterLength:old->state.replay.before[1].length,1);
    index=!result?WXMeta(&next->plan.checkout.transaction,"index"):NULL;
    if(!result)result=WXMetaSet(&next->plan.checkout.transaction,"index",old->state.index.bytes,old->state.index.length,1,
        next->finished?index->after:next->plan.state.index.bytes,next->finished?index->afterLength:next->plan.state.index.length,1);
    if(!result)result=WXMetaSet(&next->plan.checkout.transaction,incomingKey,incoming.bytes,incoming.length,incoming.present,incoming.bytes,incoming.length,incoming.present);
    if(!result)result=WXMetaSet(&next->plan.checkout.transaction,"ghclient-rebase",old->state.original,old->state.originalLength,1,wire,wn,!next->finished);
    next->plan.checkout.transaction.generation=generation;next->plan.unresolved=next->finished?0:drafts.index.unresolved;next->plan.exitAction=next->finished?1:0;
    if(!result && next->finished){RKFree(&next->plan.state);next->plan.state=old->state;RKInit(&old->state);}
    /* Final checkout retains the old checkpoint for both Start's exact CAS
       witness and the final before-state recheck. */
    if(!result)result=GCEncode(&next->plan.checkout.transaction,eq,eqCtx,&bytes,&n);if(!result && n>limits->journalBytes)result=GB_SPACE;
    if(!result)result=RLLive(&r,next->finished?&next->plan.state:&old->state,&generation);
    if(!result)result=WXMatch(&r,incomingKey,&incoming);if(!result)result=RLTick(&io);
    if(!result){RLCFree(out);*out=*next;RLCInit(next);}
    free(bytes);free(wire);free(view.ref.bytes);free(incoming.bytes);WXKeysFree(&paths);WXKeysFree(&keys);GIFree(&original);GIFree(&composed);GRFree(&target);RKFree(&parsed);MSWorkspaceFree(&drafts);RVFree(&verified);RZFree(&state);RSFree(&step);RLSessionFree(old);RLCFree(next);free(old);free(next);return result;
}
int RLContinueStart(GSRepository *r,GCBackend *b,GTControl *c,const unsigned char binding[32],GPEqual eq,void *ctx,const RLCPlan *p) {
    const GCMetadata *m;if(!p || (p->finished!=0 && p->finished!=1))return GB_BAD;
    if(!p->finished){if(p->completed!=p->plan.state.replay.completed || memcmp(p->tip,p->plan.state.replay.tip,20))return GS_CONFLICT;
        return RLUpdateStart(r,b,c,binding,eq,ctx,&p->plan);}
    if(!binding || memcmp(binding,p->plan.state.replay.binding,32) || !p->plan.state.original || !p->plan.state.replay.revision ||
        p->plan.state.replay.revision>=p->plan.checkout.transaction.generation || p->plan.unresolved || p->plan.exitAction!=1 || p->completed!=p->plan.state.replay.count)return GS_CONFLICT;
    m=WXMeta(&p->plan.checkout.transaction,"ghclient-rebase");
    if(!m || !m->beforePresent || m->afterPresent || m->beforeLength!=p->plan.state.originalLength || memcmp(m->before,p->plan.state.original,m->beforeLength))return GS_CONFLICT;
    return GTStartAtGeneration(r,b,c,binding,eq,ctx,p->plan.checkout.transaction.generation,&p->plan.checkout.transaction);
}
