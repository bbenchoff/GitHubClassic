#include "GitRebasePublish.h"
#include "GitHistory.h"
#include <stdlib.h>
#include <string.h>

static int RPWrite(void *context,const char *key,const void *old,size_t on,const void *next,size_t nn) {
    GOReader *state=(GOReader *)context;
    if(strncmp(key,"objects/",8) || old || on || !next || !nn)return GB_BAD;
    return state->source->replace(state->source->context,key,NULL,0,next,nn);
}
static int RPCommitTree(GSRepository *source,const unsigned char id[20],const unsigned char tree[20]) {
    unsigned char *raw=NULL;size_t n=0;char type[7];GHCommitInfo info;int result;
    result=GSGetObject(source,id,type,&raw,&n);
    if(!result)result=strcmp(type,"commit")?GS_FORMAT:GHCommitParse(raw,n,&info);
    if(!result && memcmp(info.tree,tree,20))result=GB_CHECKSUM;free(raw);return result;
}
static int RPIndexMatches(const GIIndex *a,const GIIndex *b) {
    size_t i;const GIEntry *left,*right;if(a->count!=b->count)return 0;
    for(i=0;i<a->count;++i) {
        left=a->entries+i;right=b->entries+i;
        if(strcmp(left->path,right->path) || left->stat[6]!=right->stat[6] || memcmp(left->oid,right->oid,20) ||
            ((left->flags|right->flags)&0x3000))return 0;
    }
    return 1;
}
int RPPublish(GSRepository *source,const RSStep *step,const char *committer,const char *seconds,const char *zone,
    GDProgress progress,void *context,RPResult *destination) {
    GOReader state;GSRepository writer;RCCommit body;RPResult next;GRSnapshot verified;GIReadLimits traversal;
    GHCommitInfo info;unsigned char originalID[20];char hex[41];int result;
    if(!source || !source->read || !source->replace || !step || !destination)return GB_BAD;
    if(step->kind==RS_CONFLICT)return GI_UNMERGED;
    if(step->kind!=RS_APPLY && step->kind!=RS_KEEP_EMPTY && step->kind!=RS_DROP_EMPTY)return GB_BAD;
    if(!step->original || !step->originalLength || step->originalLength>step->merge.limits.read.objectBytes || step->merge.conflicts || step->draft.unresolved)return GB_BAD;
    result=GBObjectID("commit",step->original,step->originalLength,originalID);
    if(!result && memcmp(originalID,step->candidate,20))result=GB_CHECKSUM;
    if(!result)result=GHCommitParse(step->original,step->originalLength,&info);
    if(!result && (info.parents!=1 || memcmp(info.parent,step->parent,20) || memcmp(info.tree,step->trees[2],20)))result=GB_CHECKSUM;
    if(result)return result;
    result=GOReadStart(source,&step->merge.limits.read,progress,context,&state,&writer);if(result)return result;
    writer.replace=RPWrite;RCInit(&body);GRInit(&verified);memset(&next,0,sizeof(next));next.kind=step->kind;
    memcpy(next.tree,step->trees[1],20);memcpy(next.commit,step->onto,20);
    /* Validate reconstruction before any write; the tree field has fixed width
       and can be replaced after publishing the verified clean draft tree. */
    if(step->kind!=RS_DROP_EMPTY)result=RCRewrite(step->original,step->originalLength,next.tree,step->onto,
        committer,seconds,zone,step->merge.limits.read.objectBytes,&body);
    if(!result)result=RPCommitTree(&writer,step->candidate,step->trees[2]);
    if(!result)result=RPCommitTree(&writer,step->parent,step->trees[0]);
    if(!result)result=RPCommitTree(&writer,step->onto,step->trees[1]);
    if(!result && step->kind==RS_APPLY)result=TMStoreObjects(&writer,&step->draft,progress,context);
    if(!result && step->kind==RS_APPLY)result=GIWriteTree(&writer,&step->draft.index,next.tree);
    memset(&traversal,0,sizeof(traversal));traversal.entries=step->merge.limits.entries;traversal.depth=step->merge.limits.depth;
    traversal.pathBytes=step->merge.limits.pathBytes;traversal.progress=progress;traversal.context=context;
    if(!result)result=GRFromTreeBounded(&writer,next.tree,&verified,&traversal);
    if(!result && !RPIndexMatches(&verified.index,step->kind==RS_APPLY?&step->draft.index:&step->merge.snapshots[1].index))result=GB_CHECKSUM;
    if(!result && step->kind!=RS_DROP_EMPTY) {
        GBOIDFormat(next.tree,hex);memcpy(body.body+5,hex,40);next.droppedSignatures=body.dropped;
        if(progress)result=progress(context);
        if(!result)result=GSPutObject(&writer,"commit",body.body,body.length,next.commit);
    }
    if(!result && progress)result=progress(context);
    if(!result)*destination=next;
    RCFree(&body);GRFree(&verified);return result;
}
