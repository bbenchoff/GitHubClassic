#include "GitBytes.h"
#include <string.h>
#include <stdlib.h>

static GBWord GBRotate(GBWord x, int n) { return (x << n) | (x >> (32 - n)); }
static GBWord GBRead32(const unsigned char *p) {
    return ((GBWord)p[0] << 24) | ((GBWord)p[1] << 16) | ((GBWord)p[2] << 8) | p[3];
}
static void GBWrite32(unsigned char *p, GBWord x) {
    p[0] = (unsigned char)(x >> 24);
    p[1] = (unsigned char)(x >> 16);
    p[2] = (unsigned char)(x >> 8);
    p[3] = (unsigned char)x;
}
static void GBSHA1Block(GBSHA1 *s, const unsigned char *p) {
    GBWord w[80], a, b, c, d, e, t, f, k;
    int i;
    for (i = 0; i < 16; ++i)
        w[i] = GBRead32(p + i * 4);
    for (i = 16; i < 80; ++i)
        w[i] = GBRotate(w[i - 3] ^ w[i - 8] ^ w[i - 14] ^ w[i - 16], 1);
    a = s->h[0];
    b = s->h[1];
    c = s->h[2];
    d = s->h[3];
    e = s->h[4];
    for (i = 0; i < 80; ++i) {
        if (i < 20) {
            f = (b & c) | ((~b) & d);
            k = 0x5a827999U;
        } else if (i < 40) {
            f = b ^ c ^ d;
            k = 0x6ed9eba1U;
        } else if (i < 60) {
            f = (b & c) | (b & d) | (c & d);
            k = 0x8f1bbcdcU;
        } else {
            f = b ^ c ^ d;
            k = 0xca62c1d6U;
        }
        t = GBRotate(a, 5) + f + e + k + w[i];
        e = d;
        d = c;
        c = GBRotate(b, 30);
        b = a;
        a = t;
    }
    s->h[0] += a;
    s->h[1] += b;
    s->h[2] += c;
    s->h[3] += d;
    s->h[4] += e;
}
void GBSHA1Start(GBSHA1 *s) {
    memset(s, 0, sizeof(*s));
    s->h[0] = 0x67452301U;
    s->h[1] = 0xefcdab89U;
    s->h[2] = 0x98badcfeU;
    s->h[3] = 0x10325476U;
    s->h[4] = 0xc3d2e1f0U;
}
void GBSHA1Update(GBSHA1 *s, const void *data, size_t length) {
    const unsigned char *p = (const unsigned char *)data;
    size_t n;
    GBWord old = s->low;
    s->low += (GBWord)length;
    s->high += (GBWord)((length >> 16) >> 16) + (s->low < old);
    while (length) {
        n = 64 - s->used;
        if (n > length)
            n = length;
        memcpy(s->block + s->used, p, n);
        s->used += n;
        p += n;
        length -= n;
        if (s->used == 64) {
            GBSHA1Block(s, s->block);
            s->used = 0;
        }
    }
}
void GBSHA1Finish(GBSHA1 *s, unsigned char digest[20]) {
    unsigned char tail[72];
    size_t n;
    int i;
    memset(tail, 0, sizeof(tail));
    tail[0] = 128;
    n = s->used < 56 ? 56 - s->used : 120 - s->used;
    GBWrite32(tail + n, (s->high << 3) | (s->low >> 29));
    GBWrite32(tail + n + 4, s->low << 3);
    GBSHA1Update(s, tail, n + 8);
    for (i = 0; i < 5; ++i)
        GBWrite32(digest + i * 4, s->h[i]);
    memset(s, 0, sizeof(*s));
}
static int GBHex(int c) {
    if (c >= '0' && c <= '9')
        return c - '0';
    if (c >= 'a' && c <= 'f')
        return c - 'a' + 10;
    if (c >= 'A' && c <= 'F')
        return c - 'A' + 10;
    return -1;
}
int GBOIDParse(const char *s, unsigned char oid[20]) {
    int i, a, b;
    if (!s || !oid || strlen(s) != 40)
        return GB_BAD;
    for (i = 0; i < 20; ++i) {
        a = GBHex(s[i * 2]);
        b = GBHex(s[i * 2 + 1]);
        if (a < 0 || b < 0)
            return GB_BAD;
        oid[i] = (unsigned char)(a * 16 + b);
    }
    return 0;
}
void GBOIDFormat(const unsigned char oid[20], char text[41]) {
    const char *hex = "0123456789abcdef";
    int i;
    for (i = 0; i < 20; ++i) {
        text[2 * i] = hex[oid[i] >> 4];
        text[2 * i + 1] = hex[oid[i] & 15];
    }
    text[40] = 0;
}
static size_t GBObjectHeader(const char *type, size_t size, char out[40]) {
    char reversed[24];
    size_t n = 0, i, used;
    if (!type || (strcmp(type, "blob") && strcmp(type, "tree") && strcmp(type, "commit") &&
                  strcmp(type, "tag")))
        return 0;
    used = strlen(type);
    memcpy(out, type, used);
    out[used++] = ' ';
    do {
        reversed[n++] = (char)('0' + size % 10);
        size /= 10;
    } while (size);
    for (i = n; i > 0; --i)
        out[used++] = reversed[i - 1];
    out[used++] = 0;
    return used;
}
int GBObjectID(const char *type, const void *data, size_t length, unsigned char oid[20]) {
    char header[40];
    size_t n = GBObjectHeader(type, length, header);
    GBSHA1 hash;
    if (!n || !oid || (!data && length))
        return GB_BAD;
    GBSHA1Start(&hash);
    GBSHA1Update(&hash, header, n);
    GBSHA1Update(&hash, data, length);
    GBSHA1Finish(&hash, oid);
    return 0;
}
/* The table is sorted twice so duplicate/overlap checks stay O(n log n). */
typedef struct {
    GBWord id;
    size_t offset, length;
} GBForkEntry;
static int GBForkIDOrder(const void *a, const void *b) {
    GBWord x = ((const GBForkEntry *)a)->id, y = ((const GBForkEntry *)b)->id;
    return x < y ? -1 : x > y;
}
static int GBForkOffsetOrder(const void *a, const void *b) {
    size_t x = ((const GBForkEntry *)a)->offset, y = ((const GBForkEntry *)b)->offset;
    return x < y ? -1 : x > y;
}
int GBForkDecode(const void *input, size_t length, unsigned char info[32],
                 const unsigned char **resource, size_t *resourceLength) {
    const unsigned char *p = (const unsigned char *)input;
    GBForkEntry *table = NULL;
    size_t entries, i, end = 0, infoOffset = 0, resourceOffset = 0, resourceSize = 0;
    int haveInfo = 0, haveResource = 0, result = GB_BAD;
    if (!info || !resource || !resourceLength)
        return GB_BAD;
    *resource = NULL;
    *resourceLength = 0;
    memset(info, 0, 32);
    if (!p || length < 26 || GBRead32(p) != 0x00051607U || GBRead32(p + 4) != 0x00020000U)
        return GB_BAD;
    entries = p[24] * 256U + p[25];
    if (!entries || entries > (length - 26) / 12)
        return GB_BAD;
    table = (GBForkEntry *)malloc(entries * sizeof(*table));
    if (!table)
        return GB_MEMORY;
    for (i = 0; i < entries; ++i) {
        table[i].id = GBRead32(p + 26 + i * 12);
        table[i].offset = GBRead32(p + 30 + i * 12);
        table[i].length = GBRead32(p + 34 + i * 12);
        if (table[i].offset < 26 + entries * 12 || table[i].offset > length ||
            table[i].length > length - table[i].offset)
            goto done;
        if (table[i].id == 9) {
            if (table[i].length != 32)
                goto done;
            infoOffset = table[i].offset;
            haveInfo = 1;
        }
        if (table[i].id == 2) {
            resourceOffset = table[i].offset;
            resourceSize = table[i].length;
            haveResource = 1;
        }
    }
    qsort(table, entries, sizeof(*table), GBForkIDOrder);
    for (i = 1; i < entries; ++i)
        if (table[i - 1].id == table[i].id)
            goto done;
    qsort(table, entries, sizeof(*table), GBForkOffsetOrder);
    for (i = 0; i < entries; ++i)
        if (table[i].length) {
            if (table[i].offset < end)
                goto done;
            end = table[i].offset + table[i].length;
        }
    if (!haveInfo || !haveResource)
        goto done;
    memcpy(info, p + infoOffset, 32);
    *resource = p + resourceOffset;
    *resourceLength = resourceSize;
    result = GB_OK;
done:
    free(table);
    return result;
}
GBWord GBAdler32(const void *data, size_t length) {
    const unsigned char *p = (const unsigned char *)data;
    GBWord a = 1, b = 0;
    size_t n;
    while (length) {
        n = length > 4096 ? 4096 : length;
        length -= n;
        while (n--) {
            a += *p++;
            b += a;
        }
        a %= 65521U;
        b %= 65521U;
    }
    return (b << 16) | a;
}
typedef struct {
    const unsigned char *data;
    size_t length, pos;
    GBWord bits;
    int count, error;
} GBBits;
static unsigned GBTake(GBBits *s, int n) {
    unsigned result;
    while (s->count < n) {
        if (s->pos == s->length) {
            s->error = 1;
            return 0;
        }
        s->bits |= (GBWord)s->data[s->pos++] << s->count;
        s->count += 8;
    }
    result = (unsigned)(s->bits & (((GBWord)1 << n) - 1));
    s->bits >>= n;
    s->count -= n;
    return result;
}
typedef struct {
    unsigned short counts[16], symbols[288];
    int total, max;
} GBHuffman;
static int GBHuffBuild(GBHuffman *h, const unsigned char *lengths, int count, int allowEmpty) {
    int offsets[16], i, len, left = 1;
    memset(h, 0, sizeof(*h));
    for (i = 0; i < count; ++i) {
        if (lengths[i] > 15)
            return GB_BAD;
        ++h->counts[lengths[i]];
    }
    h->total = count - h->counts[0];
    if (!h->total)
        return allowEmpty ? 0 : GB_BAD;
    offsets[0] = offsets[1] = 0;
    for (len = 1; len <= 15; ++len) {
        left = (left << 1) - h->counts[len];
        if (left < 0)
            return GB_BAD;
        if (h->counts[len])
            h->max = len;
        if (len < 15)
            offsets[len + 1] = offsets[len] + h->counts[len];
    }
    if (left && !(h->max == 1 && h->total == 1))
        return GB_BAD;
    for (i = 0; i < count; ++i)
        if (lengths[i])
            h->symbols[offsets[lengths[i]]++] = (unsigned short)i;
    return 0;
}
static int GBHuffRead(GBBits *bits, const GBHuffman *h) {
    unsigned code = 0, first = 0, index = 0, count;
    int length;
    for (length = 1; length <= h->max; ++length) {
        code |= GBTake(bits, 1);
        if (bits->error)
            return -1;
        count = h->counts[length];
        if (code >= first && code - first < count)
            return h->symbols[index + code - first];
        index += count;
        first = (first + count) << 1;
        code <<= 1;
    }
    return -1;
}
static int GBDynamic(GBBits *bits, GBHuffman *literal, GBHuffman *distance) {
    static const unsigned char order[19] = {16, 17, 18, 0, 8,  7, 9,  6, 10, 5,
                                            11, 4,  12, 3, 13, 2, 14, 1, 15};
    unsigned char lengths[320], clens[19];
    GBHuffman codes;
    int nl, nd, nc, i, symbol, repeats, previous = 0;
    nl = (int)GBTake(bits, 5) + 257;
    nd = (int)GBTake(bits, 5) + 1;
    nc = (int)GBTake(bits, 4) + 4;
    if (bits->error || nl > 286)
        return GB_BAD;
    memset(clens, 0, sizeof(clens));
    for (i = 0; i < nc; ++i)
        clens[order[i]] = (unsigned char)GBTake(bits, 3);
    if (bits->error || GBHuffBuild(&codes, clens, 19, 0) || codes.total == 1)
        return GB_BAD;
    i = 0;
    while (i < nl + nd) {
        symbol = GBHuffRead(bits, &codes);
        if (symbol < 0)
            return GB_BAD;
        if (symbol < 16) {
            previous = symbol;
            lengths[i++] = (unsigned char)symbol;
            continue;
        }
        if (symbol == 16) {
            if (!i)
                return GB_BAD;
            repeats = (int)GBTake(bits, 2) + 3;
        } else if (symbol == 17) {
            previous = 0;
            repeats = (int)GBTake(bits, 3) + 3;
        } else {
            previous = 0;
            repeats = (int)GBTake(bits, 7) + 11;
        }
        if (bits->error || repeats > nl + nd - i)
            return GB_BAD;
        while (repeats--)
            lengths[i++] = (unsigned char)previous;
    }
    if (!lengths[256])
        return GB_BAD;
    if (GBHuffBuild(literal, lengths, nl, 0) || GBHuffBuild(distance, lengths + nl, nd, 1))
        return GB_BAD;
    return 0;
}
int GBInflate(const void *input, size_t length, void *output, size_t cap, size_t *written,
              size_t *used) {
    static const unsigned short lbase[29] = {3,  4,  5,  6,   7,   8,   9,   10,  11, 13,
                                             15, 17, 19, 23,  27,  31,  35,  43,  51, 59,
                                             67, 83, 99, 115, 131, 163, 195, 227, 258};
    static const unsigned char lextra[29] = {0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 2, 2, 2,
                                             2, 3, 3, 3, 3, 4, 4, 4, 4, 5, 5, 5, 5, 0};
    static const unsigned short dbase[30] = {
        1,   2,   3,   4,   5,   7,    9,    13,   17,   25,   33,   49,   65,    97,    129,
        193, 257, 385, 513, 769, 1025, 1537, 2049, 3073, 4097, 6145, 8193, 12289, 16385, 24577};
    static const unsigned char dextra[30] = {0, 0, 0, 0, 1, 1, 2, 2,  3,  3,  4,  4,  5,  5,  6,
                                             6, 7, 7, 8, 8, 9, 9, 10, 10, 11, 11, 12, 12, 13, 13};
    GBBits bits;
    GBHuffman literal, distance;
    unsigned char lens[288], dist[32];
    const unsigned char *in = (const unsigned char *)input;
    unsigned char *out = (unsigned char *)output;
    size_t produced = 0, window, run, back, i;
    int final = 0, type, symbol, dsym;
    unsigned n, complement;
    if (!written || !used)
        return GB_BAD;
    *written = *used = 0;
    if (!in || length < 6 || (!out && cap) || (in[0] & 15) != 8 || (in[0] >> 4) > 7 ||
        ((in[0] * 256U + in[1]) % 31) || (in[1] & 32))
        return GB_BAD;
    window = (size_t)1 << ((in[0] >> 4) + 8);
    memset(&bits, 0, sizeof(bits));
    bits.data = in;
    bits.length = length;
    bits.pos = 2;
    while (!final) {
        final = (int)GBTake(&bits, 1);
        type = (int)GBTake(&bits, 2);
        if (bits.error)
            return GB_BAD;
        if (type == 0) {
            bits.bits = 0;
            bits.count = 0;
            n = GBTake(&bits, 16);
            complement = GBTake(&bits, 16);
            if (bits.error || ((n ^ complement) & 65535U) != 65535U || n > length - bits.pos)
                return GB_BAD;
            if (n > cap - produced) {
                if (cap > produced)
                    memcpy(out + produced, in + bits.pos, cap - produced);
                return GB_SPACE;
            }
            if (n)
                memcpy(out + produced, in + bits.pos, n);
            produced += n;
            bits.pos += n;
        } else {
            if (type == 1) {
                for (i = 0; i < 288; ++i)
                    lens[i] = (unsigned char)(i < 144 ? 8 : i < 256 ? 9 : i < 280 ? 7 : 8);
                memset(dist, 5, sizeof(dist));
                if (GBHuffBuild(&literal, lens, 288, 0) || GBHuffBuild(&distance, dist, 32, 0))
                    return GB_BAD;
            } else if (type == 2) {
                if (GBDynamic(&bits, &literal, &distance))
                    return GB_BAD;
            } else
                return GB_BAD;
            for (;;) {
                symbol = GBHuffRead(&bits, &literal);
                if (symbol < 0)
                    return GB_BAD;
                if (symbol < 256) {
                    if (produced == cap)
                        return GB_SPACE;
                    out[produced++] = (unsigned char)symbol;
                    continue;
                }
                if (symbol == 256)
                    break;
                if (symbol > 285)
                    return GB_BAD;
                symbol -= 257;
                run = lbase[symbol] + GBTake(&bits, lextra[symbol]);
                dsym = GBHuffRead(&bits, &distance);
                if (dsym < 0 || dsym > 29)
                    return GB_BAD;
                back = dbase[dsym] + GBTake(&bits, dextra[dsym]);
                if (bits.error || back > produced || back > window)
                    return GB_BAD;
                if (run > cap - produced)
                    return GB_SPACE;
                while (run--) {
                    out[produced] = out[produced - back];
                    ++produced;
                }
            }
        }
    }
    if (length - bits.pos < 4)
        return GB_BAD;
    if (GBRead32(in + bits.pos) != GBAdler32(out, produced))
        return GB_CHECKSUM;
    *written = produced;
    *used = bits.pos + 4;
    return 0;
}
int GBDeflateStore(const void *input, size_t length, void *output, size_t cap, size_t *written) {
    const unsigned char *in = (const unsigned char *)input;
    unsigned char *out = (unsigned char *)output;
    size_t blocks, need, pos = 2, left = length, n;
    if (!written)
        return GB_BAD;
    *written = 0;
    if ((!in && length) || !out)
        return GB_BAD;
    blocks = length / 65535 + (length % 65535 != 0);
    if (!blocks)
        blocks = 1;
    if (blocks > ((size_t)-1 - 6) / 5 || length > (size_t)-1 - (blocks * 5 + 6))
        return GB_SPACE;
    need = length + blocks * 5 + 6;
    if (need > cap)
        return GB_SPACE;
    out[0] = 0x78;
    out[1] = 0x01;
    do {
        n = left > 65535 ? 65535 : left;
        out[pos++] = (unsigned char)(left <= 65535);
        out[pos++] = (unsigned char)n;
        out[pos++] = (unsigned char)(n >> 8);
        out[pos++] = (unsigned char)(~n);
        out[pos++] = (unsigned char)((~n) >> 8);
        if (n)
            memcpy(out + pos, in + length - left, n);
        pos += n;
        left -= n;
    } while (left);
    GBWrite32(out + pos, GBAdler32(in, length));
    *written = pos + 4;
    return 0;
}
int GBObjectEncode(const char *type, const void *data, size_t length, unsigned char **encoded,
                   size_t *encodedLength, unsigned char oid[20]) {
    char header[40];
    size_t n, total, cap;
    unsigned char *raw, *z;
    int result;
    if (!encoded || !encodedLength || !oid)
        return GB_BAD;
    *encoded = NULL;
    *encodedLength = 0;
    n = GBObjectHeader(type, length, header);
    if (!n || (!data && length) || length > (size_t)-1 - n)
        return GB_BAD;
    total = length + n;
    cap = total / 65535 + (total % 65535 != 0);
    if (cap > ((size_t)-1 - 6) / 5 || total > (size_t)-1 - (cap * 5 + 6))
        return GB_SPACE;
    cap = total + cap * 5 + 6;
    raw = (unsigned char *)malloc(total);
    z = (unsigned char *)malloc(cap);
    if (!raw || !z) {
        free(raw);
        free(z);
        return GB_MEMORY;
    }
    memcpy(raw, header, n);
    if (length)
        memcpy(raw + n, data, length);
    result = GBObjectID(type, data, length, oid);
    if (!result)
        result = GBDeflateStore(raw, total, z, cap, encodedLength);
    free(raw);
    if (result) {
        free(z);
        return result;
    }
    *encoded = z;
    return 0;
}
int GBObjectDecode(const void *input, size_t length, void *output, size_t cap, char type[7],
                   size_t *bodyLength, const unsigned char *expected) {
    unsigned char *out = (unsigned char *)output, digest[20];
    size_t n, used, i = 0, value = 0, start;
    int result;
    GBSHA1 hash;
    if (!out || !type || !bodyLength)
        return GB_BAD;
    *bodyLength = 0;
    type[0] = 0;
    result = GBInflate(input, length, out, cap, &n, &used);
    if (result)
        return result;
    if (used != length)
        return GB_BAD;
    while (i < n && out[i] != ' ' && i < 6) {
        type[i] = (char)out[i];
        ++i;
    }
    type[i] = 0;
    if (i == n || out[i] != ' ')
        return GB_BAD;
    if (strcmp(type, "blob") && strcmp(type, "tree") && strcmp(type, "commit") &&
        strcmp(type, "tag"))
        return GB_BAD;
    start = ++i;
    while (i < n && out[i]) {
        if (out[i] < '0' || out[i] > '9' || value > ((size_t)-1 - (out[i] - '0')) / 10)
            return GB_BAD;
        value = value * 10 + out[i++] - '0';
    }
    if (i == start || i == n || (i - start > 1 && out[start] == '0') || value != n - i - 1)
        return GB_BAD;
    GBSHA1Start(&hash);
    GBSHA1Update(&hash, out, n);
    GBSHA1Finish(&hash, digest);
    if (expected && memcmp(expected, digest, 20))
        return GB_CHECKSUM;
    memmove(out, out + i + 1, value);
    *bodyLength = value;
    return 0;
}
static int GBVarint(const unsigned char *p, size_t length, size_t *pos, size_t *value) {
    size_t result = 0, part;
    int shift = 0;
    unsigned char c;
    do {
        if (*pos == length || shift >= (int)(sizeof(size_t) * 8))
            return GB_BAD;
        c = p[(*pos)++];
        part = c & 127;
        if (part > ((size_t)-1 >> shift))
            return GB_BAD;
        result |= part << shift;
        shift += 7;
    } while (c & 128);
    *value = result;
    return 0;
}
int GBApplyDelta(const void *base, size_t baseLength, const void *delta, size_t deltaLength,
                 void *output, size_t cap, size_t *written) {
    const unsigned char *b = (const unsigned char *)base, *d = (const unsigned char *)delta;
    unsigned char *out = (unsigned char *)output;
    size_t pos = 0, sourceSize, targetSize, produced = 0, offset, n;
    unsigned op;
    int i;
    if (!written)
        return GB_BAD;
    *written = 0;
    if (!d || (!b && baseLength) || (!out && cap))
        return GB_BAD;
    if (GBVarint(d, deltaLength, &pos, &sourceSize) ||
        GBVarint(d, deltaLength, &pos, &targetSize) || sourceSize != baseLength)
        return GB_BAD;
    if (targetSize > cap)
        return GB_SPACE;
    while (pos < deltaLength) {
        op = d[pos++];
        if (!op)
            return GB_BAD;
        if (op & 128) {
            offset = n = 0;
            for (i = 0; i < 4; ++i)
                if (op & (1U << i)) {
                    if (pos == deltaLength)
                        return GB_BAD;
                    offset |= (size_t)d[pos++] << (i * 8);
                }
            for (i = 0; i < 3; ++i)
                if (op & (16U << i)) {
                    if (pos == deltaLength)
                        return GB_BAD;
                    n |= (size_t)d[pos++] << (i * 8);
                }
            if (!n)
                n = 65536;
            if (offset > baseLength || n > baseLength - offset || n > targetSize - produced)
                return GB_BAD;
            memcpy(out + produced, b + offset, n);
        } else {
            n = op;
            if (n > deltaLength - pos || n > targetSize - produced)
                return GB_BAD;
            memcpy(out + produced, d + pos, n);
            pos += n;
        }
        produced += n;
    }
    if (produced != targetSize)
        return GB_BAD;
    *written = produced;
    return 0;
}
int GBPacketRead(const void *input, size_t length, GBPacket *packet) {
    const unsigned char *p = (const unsigned char *)input;
    unsigned n = 0;
    int i, h;
    if (!packet || (!p && length))
        return GB_BAD;
    memset(packet, 0, sizeof(*packet));
    if (length < 4)
        return GB_MORE;
    for (i = 0; i < 4; ++i) {
        h = GBHex(p[i]);
        if (h < 0)
            return GB_BAD;
        n = n * 16 + h;
    }
    if (n < 3) {
        packet->kind = (int)n + 1;
        packet->wireLength = 4;
        return 0;
    }
    if (n == 3 || n > 65520)
        return GB_BAD;
    if (length < n)
        return GB_MORE;
    packet->data = p + 4;
    packet->length = n - 4;
    packet->wireLength = n;
    return 0;
}
int GBPacketWrite(int kind, const void *data, size_t length, void *output, size_t cap,
                  size_t *written) {
    unsigned char *out = (unsigned char *)output;
    unsigned n;
    const char *hex = "0123456789abcdef";
    int i;
    if (!written)
        return GB_BAD;
    *written = 0;
    if (!out || kind < 0 || kind > 3 || (kind && length) || (!data && length))
        return GB_BAD;
    if (length > 65516 || cap < length + 4)
        return GB_SPACE;
    n = kind ? (unsigned)(kind - 1) : (unsigned)(length + 4);
    for (i = 3; i >= 0; --i) {
        out[i] = (unsigned char)hex[n & 15];
        n >>= 4;
    }
    if (length)
        memcpy(out + 4, data, length);
    *written = length + 4;
    return 0;
}
int GBForkEncode(const unsigned char info[32], const void *resource, size_t length,
                 unsigned char **output, size_t *outputLength) {
    unsigned char *out;
    size_t total;
    if (!output || !outputLength)
        return GB_BAD;
    *output = NULL;
    *outputLength = 0;
    if (!info || (!resource && length) || length > 0xffffffffU || length > (size_t)-1 - 82)
        return GB_BAD;
    total = length + 82;
    out = (unsigned char *)calloc(1, total);
    if (!out)
        return GB_MEMORY;
    GBWrite32(out, 0x00051607U);
    GBWrite32(out + 4, 0x00020000U);
    out[25] = 2;
    GBWrite32(out + 26, 9);
    GBWrite32(out + 30, 50);
    GBWrite32(out + 34, 32);
    GBWrite32(out + 38, 2);
    GBWrite32(out + 42, 82);
    GBWrite32(out + 46, (GBWord)length);
    memcpy(out + 50, info, 32);
    if (length)
        memcpy(out + 82, resource, length);
    *output = out;
    *outputLength = total;
    return 0;
}
