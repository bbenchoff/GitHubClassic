#include "GitRebasePlan.h"
#include <stdlib.h>
#include <string.h>

void RBInit(RBPlan *plan){memset(plan,0,sizeof(*plan));}
void RBFree(RBPlan *plan){BCFree(&plan->graph);free(plan->commits);RBInit(plan);}
static int RBTick(int (*progress)(void *),void *context){return progress?progress(context):0;}
static int RBChain(RBPlan *plan,const RBLimits *limits,int (*progress)(void *),void *context) {
    size_t at,i,head=(size_t)-1;BCNode *node;int result;
    for(i=0;i<plan->graph.count;++i)if(!memcmp(plan->graph.nodes[i].oid,plan->graph.left,20)){head=i;break;}
    if(head==(size_t)-1)return GS_FORMAT;at=head;
    for(i=0;i<plan->graph.onlyLeft;++i) {
        result=RBTick(progress,context);if(result)return result;
        if(at>=plan->graph.count)return GS_FORMAT;node=plan->graph.nodes+at;
        if(node->reach!=BC_LEFT)return GS_FORMAT;
        if(node->parentCount!=1){plan->kind=RB_MERGE_HISTORY;return 0;}
        if(node->parentFirst>=plan->graph.parentCount)return GS_FORMAT;at=plan->graph.parents[node->parentFirst];
    }
    if(at>=plan->graph.count || !plan->graph.nodes[at].base)return GS_FORMAT;
    if(plan->graph.onlyLeft>limits->steps || plan->graph.onlyLeft>(size_t)-1/20)return GB_SPACE;
    plan->commits=(unsigned char (*)[20])malloc(plan->graph.onlyLeft*20);if(!plan->commits)return GB_MEMORY;
    at=head;plan->count=plan->graph.onlyLeft;
    for(i=plan->count;i>0;--i) {
        result=RBTick(progress,context);if(result)return result;node=plan->graph.nodes+at;
        memcpy(plan->commits[i-1],node->oid,20);at=plan->graph.parents[node->parentFirst];
    }
    plan->kind=RB_REPLAY;return 0;
}
int RBPrepare(GSRepository *source,const unsigned char head[20],const unsigned char onto[20],
    const RBLimits *limits,int (*progress)(void *),void *context,RBPlan *destination) {
    RBPlan *next;int result;
    if(!source || !source->read || !head || !onto || !limits || !destination)return GB_BAD;
    next=(RBPlan *)calloc(1,sizeof(*next));if(!next)return GB_MEMORY;
    result=BCBuild(source,head,onto,&limits->graph,progress,context,&next->graph);
    if(!result) {
        if(!next->graph.bases)next->kind=RB_UNRELATED;
        else if(next->graph.bases>1)next->kind=RB_MULTIPLE_BASES;
        else if(!next->graph.onlyRight)next->kind=RB_UPTODATE;
        else if(!next->graph.onlyLeft)next->kind=RB_FAST_FORWARD;
        else result=RBChain(next,limits,progress,context);
    }
    if(!result)result=RBTick(progress,context);
    if(!result){RBFree(destination);*destination=*next;RBInit(next);}
    RBFree(next);free(next);return result;
}
