/* Native known-answer checks for paths the inherited demo did not exercise. */
#include "gcm.h"
#include "ecdh.h"
#include "ecdsa.h"
#include "sha512.h"
static int CryptoCheck(void) {
    mbedtls_gcm_context gcm;
    mbedtls_ecp_group group;
    mbedtls_mpi scalar, secret, signatureR, signatureS;
    unsigned char zero[16], cipher[16], tag[16], out[64];
    int error;
    static const unsigned char expectedCipher[16] = {0x03, 0x88, 0xda, 0xce, 0x60, 0xb6,
                                                     0xa3, 0x92, 0xf3, 0x28, 0xc2, 0xb9,
                                                     0x71, 0xb2, 0xfe, 0x78};
    static const unsigned char expectedTag[16] = {0xab, 0x6e, 0x47, 0xd4, 0x2c, 0xec, 0x13, 0xbd,
                                                  0xf5, 0x3a, 0x67, 0xb2, 0x12, 0x57, 0xbd, 0xdf};
    static const unsigned char expected384[48] = {
        0xcb, 0x00, 0x75, 0x3f, 0x45, 0xa3, 0x5e, 0x8b, 0xb5, 0xa0, 0x3d, 0x69,
        0x9a, 0xc6, 0x50, 0x07, 0x27, 0x2c, 0x32, 0xab, 0x0e, 0xde, 0xd1, 0x63,
        0x1a, 0x8b, 0x60, 0x5a, 0x43, 0xff, 0x5b, 0xed, 0x80, 0x86, 0x07, 0x2b,
        0xa1, 0xe7, 0xcc, 0x23, 0x58, 0xba, 0xec, 0xa1, 0x34, 0xc8, 0x25, 0xa7};
    memset(zero, 0, sizeof(zero));
    mbedtls_gcm_init(&gcm);
    error = mbedtls_gcm_setkey(&gcm, MBEDTLS_CIPHER_ID_AES, zero, 128);
    if (!error)
        error = mbedtls_gcm_crypt_and_tag(&gcm, MBEDTLS_GCM_ENCRYPT, 16, zero, 12, NULL, 0, zero,
                                          cipher, 16, tag);
    mbedtls_gcm_free(&gcm);
    if (error || memcmp(cipher, expectedCipher, 16) || memcmp(tag, expectedTag, 16))
        return -30101;
    error = mbedtls_sha512_ret((const unsigned char *)"abc", 3, out, 1);
    if (error || memcmp(out, expected384, 48))
        return -30102;
    mbedtls_ecp_group_init(&group);
    mbedtls_mpi_init(&scalar);
    mbedtls_mpi_init(&secret);
    error = mbedtls_ecp_group_load(&group, MBEDTLS_ECP_DP_SECP256R1);
    if (!error)
        error = mbedtls_mpi_lset(&scalar, 2);
    if (!error)
        error = mbedtls_ecdh_compute_shared(&group, &secret, &group.G, &scalar, NULL, NULL);
    if (!error)
        error = mbedtls_mpi_write_binary(&secret, out, 32);
    mbedtls_ecp_group_free(&group);
    mbedtls_mpi_free(&scalar);
    mbedtls_mpi_free(&secret);
    {
        static const unsigned char expected[32] = {0x7c, 0xf2, 0x7b, 0x18, 0x8d, 0x03, 0x4f, 0x7e,
                                                   0x8a, 0x52, 0x38, 0x03, 0x04, 0xb5, 0x1a, 0xc3,
                                                   0xc0, 0x89, 0x69, 0xe2, 0x77, 0xf2, 0x1b, 0x35,
                                                   0xa6, 0x0b, 0x48, 0xfc, 0x47, 0x66, 0x99, 0x78};
        if (error || memcmp(out, expected, 32))
            return -30103;
    }
    /* P-384 exercises certificate-signature arithmetic as well as ECDH. These
       public fixtures were independently checked with OpenSSL. */
    mbedtls_ecp_group_init(&group);
    mbedtls_mpi_init(&scalar);
    mbedtls_mpi_init(&secret);
    mbedtls_mpi_init(&signatureR);
    mbedtls_mpi_init(&signatureS);
    error = mbedtls_ecp_group_load(&group, MBEDTLS_ECP_DP_SECP384R1);
    if (!error)
        error = mbedtls_mpi_lset(&scalar, 2);
    if (!error)
        error = mbedtls_ecdh_compute_shared(&group, &secret, &group.G, &scalar, NULL, NULL);
    if (!error)
        error = mbedtls_mpi_write_binary(&secret, out, 48);
    {
        static const unsigned char expected[48] = {
            0x08, 0xd9, 0x99, 0x05, 0x7b, 0xa3, 0xd2, 0xd9, 0x69, 0x26, 0x00, 0x45,
            0xc5, 0x5b, 0x97, 0xf0, 0x89, 0x02, 0x59, 0x59, 0xa6, 0xf4, 0x34, 0xd6,
            0x51, 0xd2, 0x07, 0xd1, 0x9f, 0xb9, 0x6e, 0x9e, 0x4f, 0xe0, 0xe8, 0x6e,
            0xbe, 0x0e, 0x64, 0xf8, 0x5b, 0x96, 0xa9, 0xc7, 0x52, 0x95, 0xdf, 0x61};
        if (error || memcmp(out, expected, 48))
            error = -30104;
    }
    if (!error)
        error = mbedtls_mpi_read_string(&signatureR, 16,
                                        "08d999057ba3d2d969260045c55b97f089025959a6f434d651d207d19f"
                                        "b96e9e4fe0e86ebe0e64f85b96a9c75295df61");
    if (!error)
        error = mbedtls_mpi_read_string(&signatureS, 16,
                                        "69ed072260a398b28f631ed7b010f3fbd81746025ae9831cb62eb415f1"
                                        "dc6545e83377cd2ffb188dda28cb3443af0284");
    if (!error)
        error = mbedtls_ecdsa_verify(&group, expected384, 48, &group.G, &signatureR, &signatureS);
    if (error && error != -30104)
        error = -30105;
    if (!error) {
        memcpy(out, expected384, 48);
        out[0] ^= 1;
        if (!mbedtls_ecdsa_verify(&group, out, 48, &group.G, &signatureR, &signatureS))
            error = -30106;
    }
    mbedtls_ecp_group_free(&group);
    mbedtls_mpi_free(&scalar);
    mbedtls_mpi_free(&secret);
    mbedtls_mpi_free(&signatureR);
    mbedtls_mpi_free(&signatureS);
    return error;
}
