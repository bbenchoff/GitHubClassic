#include "GHVault.h"
#include "md.h"
#include "sha256.h"
#include "gcm.h"
#include <stdlib.h>
#include <string.h>

void GVClear(void *pointer,size_t size) {
    volatile unsigned char *p=(volatile unsigned char *)pointer;
    while(size--)*p++=0;
}
static void GVPut(unsigned char *p,unsigned long n) {
    p[0]=(unsigned char)(n>>24);p[1]=(unsigned char)(n>>16);
    p[2]=(unsigned char)(n>>8);p[3]=(unsigned char)n;
}
static unsigned long GVWord(const unsigned char *p) {
    return ((unsigned long)p[0]<<24)|((unsigned long)p[1]<<16)|((unsigned long)p[2]<<8)|p[3];
}
/* Retain each complete one-block HMAC pad state for this derivation only.
   Cloning avoids hashing the same pads for every PBKDF2 iteration. */
static int GVPreparedHMAC(mbedtls_sha256_context *work,const mbedtls_sha256_context *inner,
                         const mbedtls_sha256_context *outer,const unsigned char *input,size_t length,unsigned char output[32]) {
    unsigned char digest[32];int error;
    memset(digest,0,sizeof(digest));mbedtls_sha256_clone(work,inner);
    error=mbedtls_sha256_update_ret(work,input,length);
    if(!error)error=mbedtls_sha256_finish_ret(work,digest);
    if(!error){mbedtls_sha256_clone(work,outer);error=mbedtls_sha256_update_ret(work,digest,32);}
    if(!error)error=mbedtls_sha256_finish_ret(work,output);
    GVClear(digest,sizeof(digest));return error;
}
int GVDerive(const unsigned char *pass,size_t passLength,const unsigned char salt[16],
             unsigned long rounds,GVProgress progress,void *context,unsigned char key[32]) {
    mbedtls_sha256_context inner,outer,work;
    unsigned char pad[64],shortKey[32],input[20],u[32],next[32],result[32];
    const unsigned char *normalized=pass;size_t length=passLength,i;unsigned long round;int error=0;
    if(!pass || !passLength || passLength>1024 || !salt || !key || !rounds || rounds>GV_MAX_ROUNDS)return GV_BAD;
    mbedtls_sha256_init(&inner);mbedtls_sha256_init(&outer);mbedtls_sha256_init(&work);
    memset(pad,0,sizeof(pad));memset(shortKey,0,sizeof(shortKey));memset(input,0,sizeof(input));
    memset(u,0,sizeof(u));memset(next,0,sizeof(next));memset(result,0,sizeof(result));
    /* HMAC hashes counted passwords longer than its64-byte block first. */
    if(passLength>64){error=mbedtls_sha256_ret(pass,passLength,shortKey,0);normalized=shortKey;length=32;}
    if(!error){memset(pad,0x36,sizeof(pad));for(i=0;i<length;++i)pad[i]^=normalized[i];error=mbedtls_sha256_starts_ret(&inner,0);}
    if(!error)error=mbedtls_sha256_update_ret(&inner,pad,64);
    if(!error){for(i=0;i<64;++i)pad[i]^=0x36^0x5c;error=mbedtls_sha256_starts_ret(&outer,0);}
    if(!error)error=mbedtls_sha256_update_ret(&outer,pad,64);
    GVClear(pad,sizeof(pad));GVClear(shortKey,sizeof(shortKey));
    memcpy(input,salt,16);GVPut(input+16,1);
    if(!error)error=GVPreparedHMAC(&work,&inner,&outer,input,sizeof(input),u);
    if(!error)memcpy(result,u,32);
    for(round=1;!error && round<rounds;++round) {
        if((round&255)==1 && progress && progress(context)){error=GV_CANCEL;break;}
        error=GVPreparedHMAC(&work,&inner,&outer,u,32,next);
        if(!error){for(i=0;i<32;++i)result[i]^=next[i];memcpy(u,next,32);}
    }
    if(!error && progress && progress(context))error=GV_CANCEL;
    if(!error)memcpy(key,result,32);
    mbedtls_sha256_free(&inner);mbedtls_sha256_free(&outer);mbedtls_sha256_free(&work);
    GVClear(pad,sizeof(pad));GVClear(shortKey,sizeof(shortKey));GVClear(input,sizeof(input));
    GVClear(u,sizeof(u));GVClear(next,sizeof(next));GVClear(result,sizeof(result));
    return error?error==GV_CANCEL?GV_CANCEL:GV_BAD:0;
}
int GVCheck(void) {
    static const unsigned char expectedKey[32]={0x75,0x91,0xef,0x2f,0xae,0x53,0x1d,0x9c,0xe3,0x29,0x00,0x46,0xdb,0x41,0x92,0xb0,0x3c,0x8b,0x24,0x35,0xdd,0x70,0x2a,0x06,0xa6,0xe8,0xfc,0x41,0xa0,0xfb,0xbf,0x2a};
    static const unsigned char expected[33]={0x1a,0x7c,0x15,0x76,0x9e,0x44,0xac,0x17,0x02,0x47,0xba,0xd6,0xdb,0x2d,0x9a,0x46,0x4a,0xd9,0x1e,0x9c,0xe3,0x53,0xd7,0xa0,0xd1,0x07,0xe3,0xd5,0x6b,0x52,0x88,0xdd,0x66};
    unsigned char random[GV_RANDOM],key[32],cipher[17],tag[16],plain[17];mbedtls_gcm_context gcm;int result,bad;size_t i;
    for(i=0;i<sizeof(random);++i)random[i]=(unsigned char)i;
    memset(key,0,sizeof(key));memset(cipher,0,sizeof(cipher));memset(tag,0,sizeof(tag));memset(plain,0,sizeof(plain));mbedtls_gcm_init(&gcm);
    result=GVDerive((const unsigned char *)"GHClient vault known answer",sizeof("GHClient vault known answer")-1,random,1000,NULL,NULL,key);
    if(!result && memcmp(key,expectedKey,32))result=GV_AUTH;
    if(!result)result=mbedtls_gcm_setkey(&gcm,MBEDTLS_CIPHER_ID_AES,key,256);
    if(!result)result=mbedtls_gcm_crypt_and_tag(&gcm,MBEDTLS_GCM_ENCRYPT,17,random+16,12,(const unsigned char *)"GHVault self check",18,(const unsigned char *)"classic Macintosh",cipher,16,tag);
    if(!result && (memcmp(cipher,expected,17) || memcmp(tag,expected+17,16)))result=GV_AUTH;
    if(!result)result=mbedtls_gcm_auth_decrypt(&gcm,17,random+16,12,(const unsigned char *)"GHVault self check",18,tag,16,cipher,plain);
    if(!result && memcmp(plain,"classic Macintosh",17))result=GV_AUTH;
    if(!result){tag[0]^=1;bad=mbedtls_gcm_auth_decrypt(&gcm,17,random+16,12,(const unsigned char *)"GHVault self check",18,tag,16,cipher,plain);if(bad!=MBEDTLS_ERR_GCM_AUTH_FAILED)result=GV_AUTH;for(i=0;i<sizeof(plain);++i)if(plain[i])result=GV_AUTH;}
    mbedtls_gcm_free(&gcm);GVClear(random,sizeof(random));GVClear(key,sizeof(key));GVClear(cipher,sizeof(cipher));GVClear(tag,sizeof(tag));GVClear(plain,sizeof(plain));return result?GV_AUTH:0;
}
int GVSealRemember(const void *plain,size_t length,const unsigned char *pass,size_t passLength,
           const unsigned char random[GV_RANDOM],unsigned long rounds,
           GVProgress progress,void *context,unsigned char **out,size_t *outLength,unsigned char remembered[32]) {
    unsigned char key[32],*bytes;mbedtls_gcm_context gcm;int error;
    if(!plain || !length || length>GV_MAX_PLAIN || !random || !out || !outLength ||
       rounds<GV_MIN_ROUNDS || rounds>GV_MAX_ROUNDS)return GV_BAD;
    bytes=(unsigned char *)malloc(length+GV_HEADER+GV_TAG);if(!bytes)return GV_MEMORY;
    memcpy(bytes,"GHVA0001",8);GVPut(bytes+8,1);GVPut(bytes+12,rounds);
    memcpy(bytes+16,random,GV_RANDOM);GVPut(bytes+44,(unsigned long)length);
    memset(key,0,sizeof(key));mbedtls_gcm_init(&gcm);
    error=GVDerive(pass,passLength,bytes+16,rounds,progress,context,key);
    if(!error)error=mbedtls_gcm_setkey(&gcm,MBEDTLS_CIPHER_ID_AES,key,256);
    if(!error)error=mbedtls_gcm_crypt_and_tag(&gcm,MBEDTLS_GCM_ENCRYPT,length,
        bytes+32,12,bytes,GV_HEADER,(const unsigned char *)plain,bytes+GV_HEADER,GV_TAG,bytes+GV_HEADER+length);
    mbedtls_gcm_free(&gcm);
    if(!error && remembered)memcpy(remembered,key,32);
    GVClear(key,sizeof(key));
    if(error){GVClear(bytes,length+GV_HEADER+GV_TAG);free(bytes);return error==GV_CANCEL?error:GV_BAD;}
    *out=bytes;*outLength=length+GV_HEADER+GV_TAG;return 0;
}
int GVSeal(const void *plain,size_t length,const unsigned char *pass,size_t passLength,
           const unsigned char random[GV_RANDOM],unsigned long rounds,
           GVProgress progress,void *context,unsigned char **out,size_t *outLength) {
    return GVSealRemember(plain,length,pass,passLength,random,rounds,progress,context,out,outLength,NULL);
}
static int GVShape(const void *encoded,size_t length) {
    const unsigned char *bytes=(const unsigned char *)encoded;unsigned long rounds,n;
    if(!bytes || length<GV_HEADER+GV_TAG || length>GV_MAX_PLAIN+GV_HEADER+GV_TAG ||
       memcmp(bytes,"GHVA0001",8) || GVWord(bytes+8)!=1)return GV_BAD;
    rounds=GVWord(bytes+12);n=GVWord(bytes+44);
    return rounds<GV_MIN_ROUNDS || rounds>GV_MAX_ROUNDS || !n || n!=length-GV_HEADER-GV_TAG?GV_BAD:0;
}
int GVKeyID(const void *encoded,size_t length,unsigned char identity[32]) {
    unsigned char digest[32];int error;
    if(!identity || GVShape(encoded,length))return GV_BAD;
    error=mbedtls_md(mbedtls_md_info_from_type(MBEDTLS_MD_SHA256),(const unsigned char *)encoded,length,digest);
    if(!error)memcpy(identity,digest,32);
    GVClear(digest,sizeof(digest));return error?GV_BAD:0;
}
int GVOpenWithKey(const void *encoded,size_t length,const unsigned char key[32],
           unsigned char **out,size_t *outLength) {
    const unsigned char *bytes=(const unsigned char *)encoded;unsigned char *plain;
    unsigned long n;mbedtls_gcm_context gcm;int error;
    if(!out || !outLength || !key || GVShape(encoded,length))return GV_BAD;
    n=GVWord(bytes+44);
    plain=(unsigned char *)malloc((size_t)n);if(!plain)return GV_MEMORY;
    mbedtls_gcm_init(&gcm);
    error=mbedtls_gcm_setkey(&gcm,MBEDTLS_CIPHER_ID_AES,key,256);
    if(!error)error=mbedtls_gcm_auth_decrypt(&gcm,(size_t)n,bytes+32,12,bytes,GV_HEADER,
        bytes+GV_HEADER+n,GV_TAG,bytes+GV_HEADER,plain);
    mbedtls_gcm_free(&gcm);
    if(error){GVClear(plain,(size_t)n);free(plain);return GV_AUTH;}
    *out=plain;*outLength=(size_t)n;return 0;
}
int GVResealWithKey(const void *old,size_t oldLength,const unsigned char key[32],
           const void *plain,size_t length,const unsigned char nonce[12],unsigned char **out,size_t *outLength) {
    unsigned char *verified=NULL,*bytes;size_t vn=0;int error;mbedtls_gcm_context gcm;
    if(!out || !outLength || !key || !plain || !length || length>GV_MAX_PLAIN ||
       !nonce || GVShape(old,oldLength) || !memcmp((const unsigned char *)old+32,nonce,12))return GV_BAD;
    error=GVOpenWithKey(old,oldLength,key,&verified,&vn);if(error)return error;
    GVClear(verified,vn);free(verified);
    bytes=(unsigned char *)malloc(GV_HEADER+length+GV_TAG);if(!bytes)return GV_MEMORY;
    memcpy(bytes,old,GV_HEADER);memcpy(bytes+32,nonce,12);GVPut(bytes+44,(unsigned long)length);
    mbedtls_gcm_init(&gcm);error=mbedtls_gcm_setkey(&gcm,MBEDTLS_CIPHER_ID_AES,key,256);
    if(!error)error=mbedtls_gcm_crypt_and_tag(&gcm,MBEDTLS_GCM_ENCRYPT,length,bytes+32,12,
        bytes,GV_HEADER,(const unsigned char *)plain,bytes+GV_HEADER,GV_TAG,bytes+GV_HEADER+length);
    mbedtls_gcm_free(&gcm);
    if(error){GVClear(bytes,GV_HEADER+length+GV_TAG);free(bytes);return GV_BAD;}
    *out=bytes;*outLength=GV_HEADER+length+GV_TAG;return 0;
}
int GVOpenRemember(const void *encoded,size_t length,const unsigned char *pass,size_t passLength,
           GVProgress progress,void *context,unsigned char **out,size_t *outLength,unsigned char remembered[32]) {
    const unsigned char *bytes=(const unsigned char *)encoded;unsigned char key[32];int error;
    if(!out || !outLength || GVShape(encoded,length))return GV_BAD;
    memset(key,0,sizeof(key));
    error=GVDerive(pass,passLength,bytes+16,GVWord(bytes+12),progress,context,key);
    if(!error)error=GVOpenWithKey(encoded,length,key,out,outLength);
    if(!error && remembered)memcpy(remembered,key,32);
    GVClear(key,sizeof(key));return error;
}
int GVOpen(const void *encoded,size_t length,const unsigned char *pass,size_t passLength,
           GVProgress progress,void *context,unsigned char **out,size_t *outLength) {
    return GVOpenRemember(encoded,length,pass,passLength,progress,context,out,outLength,NULL);
}
