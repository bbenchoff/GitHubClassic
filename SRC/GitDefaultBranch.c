#include "GitDefaultBranch.h"
#include "GHCore.h"
#include <stdlib.h>
#include <string.h>

static void GUDWord(unsigned char *p,GBWord v) {
    p[0]=(unsigned char)(v>>24);p[1]=(unsigned char)(v>>16);p[2]=(unsigned char)(v>>8);p[3]=(unsigned char)v;
}
static GBWord GUDGet(const unsigned char *p) {
    return ((GBWord)p[0]<<24)|((GBWord)p[1]<<16)|((GBWord)p[2]<<8)|p[3];
}
static void GUDHash(const void *p,size_t n,unsigned char out[20]) {
    GBSHA1 h;GBSHA1Start(&h);GBSHA1Update(&h,p,n);GBSHA1Finish(&h,out);
}
void GUDefaultInit(GUDefault *d) {memset(d,0,sizeof(*d));}
static int GUDValid(const GUDefault *d) {
    return d && memchr(d->repository,0,sizeof(d->repository)) && memchr(d->branch,0,sizeof(d->branch)) &&
        GHValidRepository(d->repository) && (d->known==0?!d->branch[0]:d->known==1 && GSValidRef(d->branch));
}
int GUDefaultEncode(const GUDefault *d,unsigned char **out,size_t *length) {
    size_t rn,bn,n;unsigned char *p;
    if(!out || !length)return GB_BAD;
    *out=NULL;*length=0;if(!GUDValid(d))return GB_BAD;
    rn=strlen(d->repository);bn=strlen(d->branch);n=40+rn+bn;p=(unsigned char *)malloc(n);if(!p)return GB_MEMORY;
    memcpy(p,"GHDEFLT1",8);GUDWord(p+8,(GBWord)rn);GUDWord(p+12,(GBWord)bn);GUDWord(p+16,(GBWord)d->known);
    memcpy(p+20,d->repository,rn);if(bn)memcpy(p+20+rn,d->branch,bn);GUDHash(p,n-20,p+n-20);
    *out=p;*length=n;return 0;
}
int GUDefaultParse(const void *input,size_t n,GUDefault *out) {
    const unsigned char *p=(const unsigned char *)input;GUDefault next;unsigned char hash[20];size_t rn,bn;
    if(!input || !out)return GB_BAD;
    if(n<40 || n>1318 || memcmp(p,"GHDEFLT1",8))return GS_FORMAT;
    rn=GUDGet(p+8);bn=GUDGet(p+12);
    if(!rn || rn>254 || bn>1024 || GUDGet(p+16)>1 || n!=40+rn+bn || memchr(p+20,0,rn+bn))return GS_FORMAT;
    GUDHash(p,n-20,hash);if(memcmp(hash,p+n-20,20))return GB_CHECKSUM;
    GUDefaultInit(&next);next.known=(int)GUDGet(p+16);memcpy(next.repository,p+20,rn);if(bn)memcpy(next.branch,p+20+rn,bn);
    if(!GUDValid(&next))return GS_FORMAT;
    *out=next;return 0;
}
int GUDefaultRead(GSRepository *r,const char *repository,GUDefault *out,int *exists) {
    unsigned char *raw=NULL;size_t n=0;GUDefault next;int result;
    if(!exists)return GB_BAD;
    *exists=0;
    if(!r || !r->read || !r->replace || !repository || strlen(repository)>254 || !GHValidRepository(repository) || !out)return GB_BAD;
    result=r->read(r->context,"ghclient-default",&raw,&n);
    if(result==GS_NOT_FOUND){free(raw);return 0;}
    if(!result)result=GUDefaultParse(raw,n,&next);free(raw);
    if(!result && strcmp(repository,next.repository))result=GS_CONFLICT;
    if(!result){*out=next;*exists=1;}return result;
}
int GUDefaultSet(GSRepository *r,const GUDefault *expected,const GUDefault *next) {
    unsigned char *before=NULL,*after=NULL,*current=NULL;size_t bn=0,an=0,cn=0;GUDefault parsed;int result=0,missing=0;
    if(!r || !r->read || !r->replace || !GUDValid(next) || (expected && !GUDValid(expected)))return GB_BAD;
    if(expected)result=GUDefaultEncode(expected,&before,&bn);
    if(!result)result=GUDefaultEncode(next,&after,&an);
    if(!result){result=r->read(r->context,"ghclient-default",&current,&cn);if(result==GS_NOT_FOUND){missing=1;result=0;}}
    if(!result && !missing)result=GUDefaultParse(current,cn,&parsed);
    if(!result && (missing?expected!=NULL:!expected || bn!=cn || memcmp(before,current,cn)))result=GS_CONFLICT;
    if(!result && (missing || an!=cn || memcmp(after,current,cn)))result=r->replace(r->context,"ghclient-default",before,bn,after,an);
    free(before);free(after);free(current);return result;
}
int GUDefaultSelect(GSRepository *r,const char *repository,const char *legacy,const char *const *locals,size_t count,GUDefaultChoice *out) {
    GUDefaultChoice *next;GUUpstream route;unsigned char tip[20];size_t i,tracked=(size_t)-1,named=(size_t)-1,selected;int result,exists,source;
    if(!out || !legacy || strlen(legacy)>1024 || !GSValidRef(legacy) || count>4096 || (count && !locals))return GB_BAD;
    for(i=0;i<count;++i)if(!locals[i] || strlen(locals[i])>1024 || !GSValidRef(locals[i]) || (i && strcmp(locals[i-1],locals[i])>=0))return GB_BAD;
    next=(GUDefaultChoice *)calloc(1,sizeof(*next));if(!next)return GB_MEMORY;
    result=GUDefaultRead(r,repository,&next->observed,&exists);if(result)goto done;
    if(!exists || !next->observed.known){result=GS_NOT_FOUND;goto done;}
    for(i=0;i<count;++i) {
        result=GUUpstreamResolve(r,repository,locals[i],legacy,&route,&source);if(result)goto done;
        result=GSReadRef(r,locals[i],tip);if(result==GS_NOT_FOUND){result=0;continue;}if(result)goto done;
        if(!strcmp(locals[i],next->observed.branch))named=i;
        if(route.tracked && !strcmp(route.remoteBranch,next->observed.branch) && (tracked==(size_t)-1 || !strcmp(locals[i],next->observed.branch)))tracked=i;
    }
    selected=tracked!=(size_t)-1?tracked:named;
    if(selected!=(size_t)-1) {
        strcpy(next->reference,locals[selected]);next->source=tracked!=(size_t)-1?GU_DEFAULT_TRACKED_LOCAL:GU_DEFAULT_NAMED_LOCAL;
        result=GUUpstreamResolve(r,repository,locals[selected],legacy,&next->route,&next->upstreamSource);
    } else {
        strcpy(next->reference,"refs/remotes/origin/");strcat(next->reference,next->observed.branch+11);next->source=GU_DEFAULT_REMOTE;
    }
    if(!result)result=GSReadRef(r,next->reference,next->tip);
    if(!result)*out=*next;
done:free(next);return result;
}
