#include "GitSmart.h"
#include <stdlib.h>
#include <string.h>

void GNInit(GNAdvertisement *a) { memset(a, 0, sizeof(*a)); }
void GNFree(GNAdvertisement *a) {
    size_t i;
    for (i = 0; i < a->count; ++i) free(a->refs[i].name);
    free(a->refs); free(a->head); GNInit(a);
}
static char *GNCopy(const unsigned char *s, size_t n) {
    char *copy;
    if (n == (size_t)-1) return NULL;
    copy = (char *)malloc(n + 1);
    if (copy) { memcpy(copy, s, n); copy[n] = 0; }
    return copy;
}
static int GNName(const unsigned char *p, size_t n) {
    size_t i, start = 0, count;
    if (n < 6 || n > 1024 || memcmp(p, "refs/", 5)) return 0;
    for (i = 0; i <= n; ++i) {
        if (i == n || p[i] == '/') {
            count = i - start;
            if (!count || p[start] == '.' || p[i - 1] == '.' ||
                (count >= 5 && !memcmp(p + i - 5, ".lock", 5))) return 0;
            start = i + 1;
        } else if (p[i] <= 32 || p[i] == 127 || strchr("~^:?*[\\", p[i]) ||
                   (p[i] == '.' && i + 1 < n && p[i + 1] == '.') ||
                   (p[i] == '@' && i + 1 < n && p[i + 1] == '{')) return 0;
    }
    return 1;
}
static int GNCaps(GNAdvertisement *a, const unsigned char *p, size_t n) {
    size_t at = 0, end, i;
    int seenFormat = 0;
    for (i = 0; i < n; ++i) if (p[i] <= 32 && p[i] != ' ') return GB_BAD;
    while (at < n) {
        end = at;
        while (end < n && p[end] != ' ') {
            if (p[end] >= 127) return GB_BAD;
            ++end;
        }
        if (end == at) return GB_BAD;
        if (end - at == 13 && !memcmp(p + at, "side-band-64k", 13)) a->sideBand = 2;
        else if (end - at == 9 && !memcmp(p + at, "side-band", 9) && !a->sideBand) a->sideBand = 1;
        else if (end - at == 9 && !memcmp(p + at, "ofs-delta", 9)) a->ofsDelta = 1;
        else if (end - at == 13 && !memcmp(p + at, "report-status", 13)) a->reportStatus = 1;
        else if (end - at >= 14 && !memcmp(p + at, "object-format=", 14)) {
            if (seenFormat) return GB_BAD;
            if (end - at != 18 || memcmp(p + at + 14, "sha1", 4)) return GN_UNSUPPORTED;
            seenFormat = 1;
        } else if (end - at >= 12 && !memcmp(p + at, "symref=HEAD:", 12)) {
            if (a->head || !GNName(p + at + 12, end - at - 12)) return GB_BAD;
            a->head = GNCopy(p + at + 12, end - at - 12);
            if (!a->head) return GB_MEMORY;
        }
        at = end + 1;
    }
    return 0;
}
static int GNCompare(const void *a, const void *b) {
    return strcmp(((const GNRef *)a)->name, ((const GNRef *)b)->name);
}
const GNRef *GNFind(const GNAdvertisement *a, const char *name) {
    size_t lo = 0, hi, mid;
    int cmp;
    if (!a || !name) return NULL;
    hi = a->count;
    while (lo < hi) {
        mid = lo + (hi - lo) / 2; cmp = strcmp(a->refs[mid].name, name);
        if (!cmp) return a->refs + mid;
        if (cmp < 0) lo = mid + 1;
        else hi = mid;
    }
    return NULL;
}
static int GNDiscoverService(const void *input, size_t length, size_t maxRefs,
                              GNAdvertisement *out, const char *service) {
    const unsigned char *p = (const unsigned char *)input, *zero;
    GNAdvertisement a;
    GBPacket packet;
    size_t at = 0, n, nameLength, i, capacity = 0, next;
    char hex[41];
    unsigned char id[20], zeros[20];
    GNRef *grown;
    const GNRef *head, *target;
    int error, first = 1, empty = 0;
    if (!p || !out) return GB_BAD;
    GNInit(&a); memset(zeros, 0, sizeof(zeros));
    error = GBPacketRead(p, length, &packet);
    if (error || packet.kind) return GB_BAD;
    n = packet.length;
    if (n && packet.data[n - 1] == '\n') --n;
    if (n != strlen(service) || memcmp(packet.data, service, n)) return GB_BAD;
    at += packet.wireLength;
    error = GBPacketRead(p + at, length - at, &packet);
    if (error || packet.kind != 1) return GB_BAD;
    at += packet.wireLength;
    for (;;) {
        error = GBPacketRead(p + at, length - at, &packet);
        if (error) { error = GB_BAD; goto done; }
        at += packet.wireLength;
        error = GB_BAD;
        if (packet.kind == 1) break;
        if (packet.kind || empty) goto done;
        n = packet.length;
        if (n && packet.data[n - 1] == '\n') --n;
        if (first == 1 && n == 9 && !memcmp(packet.data, "version 1", 9)) {
            /* Only one optional version line, before capability-bearing refs. */
            first = 2; continue;
        }
        if (n < 42 || packet.data[40] != ' ') goto done;
        memcpy(hex, packet.data, 40); hex[40] = 0;
        if (GBOIDParse(hex, id)) goto done;
        zero = (const unsigned char *)memchr(packet.data + 41, 0, n - 41);
        nameLength = zero ? (size_t)(zero - packet.data) - 41 : n - 41;
        if (first) {
            if (!zero) goto done;
            error = GNCaps(&a, zero + 1, n - (size_t)(zero + 1 - packet.data));
            if (error) goto done;
        } else if (zero) goto done;
        error = GB_BAD;
        if (!memcmp(id, zeros, 20)) {
            if (!first || nameLength != 15 || memcmp(packet.data + 41, "capabilities^{}", 15)) goto done;
            first = 0; empty = 1; continue;
        }
        if (!(nameLength == 4 && !memcmp(packet.data + 41, "HEAD", 4))) {
            i = nameLength;
            if (i >= 3 && !memcmp(packet.data + 41 + i - 3, "^{}", 3)) i -= 3;
            if (!GNName(packet.data + 41, i)) goto done;
        }
        if (a.count >= maxRefs || a.count >= (size_t)-1 / sizeof(GNRef)) { error = GB_SPACE; goto done; }
        if (a.count == capacity) {
            next = capacity ? capacity * 2 : 16;
            if (next < capacity || next > maxRefs) next = maxRefs;
            if (next > (size_t)-1 / sizeof(GNRef)) { error = GB_SPACE; goto done; }
            grown = (GNRef *)realloc(a.refs, next * sizeof(GNRef));
            if (!grown) { error = GB_MEMORY; goto done; }
            a.refs = grown; capacity = next;
        }
        a.refs[a.count].name = GNCopy(packet.data + 41, nameLength);
        if (!a.refs[a.count].name) { error = GB_MEMORY; goto done; }
        memcpy(a.refs[a.count].oid, id, 20); ++a.count; first = 0;
    }
    if (at != length || first) goto done;
    if (a.count > 1) qsort(a.refs, a.count, sizeof(GNRef), GNCompare);
    for (i = 1; i < a.count; ++i) if (!strcmp(a.refs[i - 1].name, a.refs[i].name)) goto done;
    head = GNFind(&a, "HEAD"); target = a.head ? GNFind(&a, a.head) : NULL;
    if (head && target && memcmp(head->oid, target->oid, 20)) goto done;
    GNFree(out); *out = a; GNInit(&a); error = 0;
done:
    GNFree(&a); return error;
}
int GNDiscover(const void *input, size_t length, size_t maxRefs, GNAdvertisement *out) {
    return GNDiscoverService(input, length, maxRefs, out, "# service=git-upload-pack");
}
int GNReceiveDiscover(const void *input, size_t length, size_t maxRefs, GNAdvertisement *out) {
    return GNDiscoverService(input, length, maxRefs, out, "# service=git-receive-pack");
}
int GNFetchRequest(const GNAdvertisement *a, const char *name, const unsigned char *haves,
                    size_t haveCount, unsigned char **body, size_t *length) {
    const GNRef *ref;
    unsigned char *request;
    char line[128], hex[41];
    size_t capacity, used = 0, n, i;
    int error;
    if (!body || !length) return GB_BAD;
    *body = NULL; *length = 0;
    if (!a || !name || (haveCount && !haves) || haveCount > 65536) return GB_BAD;
    ref = GNFind(a, name);
    if (!ref || strstr(name, "^{}")) return GB_BAD;
    capacity = 256 + haveCount * 50;
    request = (unsigned char *)malloc(capacity);
    if (!request) return GB_MEMORY;
    GBOIDFormat(ref->oid, hex);
    strcpy(line, "want "); strcat(line, hex);
    if (a->sideBand) strcat(line, a->sideBand == 2 ? " side-band-64k" : " side-band");
    if (a->ofsDelta) strcat(line, " ofs-delta");
    strcat(line, "\n");
    error = GBPacketWrite(0, line, strlen(line), request, capacity, &n);
    if (error) goto done;
    used += n;
    error = GBPacketWrite(1, NULL, 0, request + used, capacity - used, &n);
    if (error) goto done;
    used += n;
    for (i = 0; i < haveCount; ++i) {
        GBOIDFormat(haves + i * 20, hex); strcpy(line, "have "); strcat(line, hex); strcat(line, "\n");
        error = GBPacketWrite(0, line, strlen(line), request + used, capacity - used, &n);
        if (error) goto done;
        used += n;
    }
    error = GBPacketWrite(0, "done\n", 5, request + used, capacity - used, &n);
    if (!error) { used += n; *body = request; *length = used; request = NULL; }
done:
    free(request); return error;
}
int GNFetchResponse(unsigned char *p, size_t length, int sideBand, size_t *packLength) {
    GBPacket packet;
    size_t at, out = 0, n;
    unsigned char id[20];
    char hex[41];
    int error, channel;
    if (!packLength) return GB_BAD;
    *packLength = 0;
    if (!p || sideBand < 0 || sideBand > 2) return GB_BAD;
    error = GBPacketRead(p, length, &packet);
    if (error || packet.kind) return GB_BAD;
    n = packet.length;
    if (n && packet.data[n - 1] == '\n') --n;
    if (n >= 4 && !memcmp(packet.data, "ERR ", 4)) return GN_REMOTE_ERROR;
    if (!(n == 3 && !memcmp(packet.data, "NAK", 3))) {
        if (n != 44 || memcmp(packet.data, "ACK ", 4)) return GB_BAD;
        memcpy(hex, packet.data + 4, 40); hex[40] = 0;
        if (GBOIDParse(hex, id)) return GB_BAD;
    }
    at = packet.wireLength;
    if (!sideBand) {
        if (length - at < 32 || memcmp(p + at, "PACK", 4)) return GB_BAD;
        out = length - at; memmove(p, p + at, out);
    } else for (;;) {
        error = GBPacketRead(p + at, length - at, &packet);
        if (error) return GB_BAD;
        at += packet.wireLength;
        if (packet.kind == 1) {
            if (at != length) return GB_BAD;
            break;
        }
        if (packet.kind || packet.length < 1 || (sideBand == 1 && packet.wireLength > 1000)) return GB_BAD;
        channel = packet.data[0];
        if (channel == 3) return GN_REMOTE_ERROR;
        if (channel != 1 && channel != 2) return GB_BAD;
        if (channel == 1) {
            memmove(p + out, packet.data + 1, packet.length - 1);
            out += packet.length - 1;
        }
    }
    if (out < 32 || memcmp(p, "PACK", 4)) return GB_BAD;
    *packLength = out; return 0;
}
int GNPushCommand(const GNAdvertisement *a, const char *name, const unsigned char oldTip[20],
                    const unsigned char newTip[20], unsigned char **body, size_t *length) {
    const GNRef *ref;
    unsigned char zeros[20], *command = NULL;
    char oldHex[41], newHex[41], line[1200];
    size_t n, at, wire;
    int error;
    if (!body || !length) return GB_BAD;
    *body = NULL; *length = 0; memset(zeros, 0, sizeof(zeros));
    if (!a || !name || !oldTip || !newTip || !GNName((const unsigned char *)name, strlen(name)) ||
        strncmp(name, "refs/heads/", 11) || !memcmp(newTip, zeros, 20) || !memcmp(oldTip, newTip, 20)) return GB_BAD;
    if (!a->reportStatus) return GN_UNSUPPORTED;
    ref = GNFind(a, name);
    if ((ref && memcmp(ref->oid, oldTip, 20)) || (!ref && memcmp(oldTip, zeros, 20))) return GN_STALE;
    GBOIDFormat(oldTip, oldHex); GBOIDFormat(newTip, newHex);
    memcpy(line, oldHex, 40); line[40] = ' '; memcpy(line + 41, newHex, 40); line[81] = ' ';
    n = strlen(name); memcpy(line + 82, name, n); at = 82 + n; line[at++] = 0;
    memcpy(line + at, "report-status", 13); at += 13;
    if (a->sideBand) {
        const char *band = a->sideBand == 2 ? " side-band-64k" : " side-band";
        n = strlen(band); memcpy(line + at, band, n); at += n;
    }
    line[at++] = '\n';
    command = (unsigned char *)malloc(at + 8);
    if (!command) return GB_MEMORY;
    error = GBPacketWrite(0, line, at, command, at + 8, &wire);
    if (!error) {
        memcpy(command + wire, "0000", 4); *body = command; *length = wire + 4; command = NULL;
    }
    free(command); return error;
}
static int GNReportText(const unsigned char *p, size_t n) {
    size_t i;
    if (!n) return 0;
    for (i = 0; i < n; ++i) if (p[i] < 32 || p[i] == 127) return 0;
    return 1;
}
int GNPushResponse(unsigned char *p, size_t length, int sideBand, const char *name, GNPushStatus *out) {
    GNPushStatus result;
    GBPacket packet;
    size_t at = 0, used = 0, n, rn;
    const unsigned char *reason = NULL;
    int error, channel, unpacked;
    if (!out) return GB_BAD;
    memset(out, 0, sizeof(*out)); memset(&result, 0, sizeof(result));
    if (!p || !name || !GNName((const unsigned char *)name, strlen(name)) || sideBand < 0 || sideBand > 2) return GB_BAD;
    rn = strlen(name);
    if (sideBand) {
        for (;;) {
            error = GBPacketRead(p + at, length - at, &packet);
            if (error) return GB_BAD;
            at += packet.wireLength;
            if (packet.kind == 1) { if (at != length) return GB_BAD; break; }
            if (packet.kind || !packet.length || (sideBand == 1 && packet.wireLength > 1000)) return GB_BAD;
            channel = packet.data[0];
            if (channel == 3) return GN_REMOTE_ERROR;
            if (channel != 1 && channel != 2) return GB_BAD;
            if (channel == 1) {
                memmove(p + used, packet.data + 1, packet.length - 1); used += packet.length - 1;
            }
        }
        length = used;
    }
    at = 0;
    error = GBPacketRead(p, length, &packet);
    if (error || packet.kind) return GB_BAD;
    n = packet.length; if (n && packet.data[n - 1] == '\n') --n;
    if (n >= 4 && !memcmp(packet.data, "ERR ", 4)) return GN_REMOTE_ERROR;
    if (n < 8 || memcmp(packet.data, "unpack ", 7) || !GNReportText(packet.data + 7, n - 7)) return GB_BAD;
    unpacked = n == 9 && !memcmp(packet.data + 7, "ok", 2);
    if (!unpacked) {
        size_t count = n - 7; if (count > 255) count = 255;
        memcpy(result.reason, packet.data + 7, count); result.reason[count] = 0;
    }
    at += packet.wireLength;
    error = GBPacketRead(p + at, length - at, &packet);
    if (error || packet.kind) return GB_BAD;
    n = packet.length; if (n && packet.data[n - 1] == '\n') --n;
    if (n == rn + 3 && !memcmp(packet.data, "ok ", 3) && !memcmp(packet.data + 3, name, rn)) {
        if (!unpacked) return GB_BAD;
        result.accepted = 1;
    } else if (n > rn + 4 && !memcmp(packet.data, "ng ", 3) &&
               !memcmp(packet.data + 3, name, rn) && packet.data[rn + 3] == ' ') {
        reason = packet.data + rn + 4;
        if (!GNReportText(reason, n - rn - 4)) return GB_BAD;
        if (unpacked) {
            size_t count = n - rn - 4; if (count > 255) count = 255;
            memcpy(result.reason, reason, count); result.reason[count] = 0;
        }
    } else return GB_BAD;
    at += packet.wireLength;
    error = GBPacketRead(p + at, length - at, &packet);
    if (error || packet.kind != 1 || at + packet.wireLength != length) return GB_BAD;
    result.unpacked = unpacked; *out = result;
    return result.accepted ? 0 : GN_REMOTE_ERROR;
}
