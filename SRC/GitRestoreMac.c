#include "GitRestoreMac.h"
#include "GitWorkMac.h"
#include <Errors.h>
#include <Script.h>
#include <stdlib.h>
#include <string.h>

typedef struct {
    long directory;
    char *logical, *physical;
} GRDirectory;
static int GRMacFailure(OSErr error, OSErr *lastError) {
    *lastError = error;
    return error == dupFNErr ? GS_CONFLICT : GS_IO;
}
static char *GRPrefix(const char *p, size_t n) {
    char *copy = (char *)malloc(n + 1);
    if (copy) { memcpy(copy, p, n); copy[n] = 0; }
    return copy;
}
static OSErr GRMacCatalog(const FSSpec *spec, CInfoPBRec *pb) {
    memset(pb, 0, sizeof(*pb));
    pb->dirInfo.ioVRefNum = spec->vRefNum;
    pb->dirInfo.ioDrDirID = spec->parID;
    pb->dirInfo.ioNamePtr = (StringPtr)spec->name;
    return PBGetCatInfoSync(pb);
}
static int GRMacPathValid(const char *logical, const char *physical) {
    const char *p, *start;
    size_t a = 0, b = 0, n;
    if (!physical || !*physical) return 0;
    for (p = logical; *p; ++p) if (*p == '/') ++a;
    for (p = start = physical;; ++p) {
        if (*p && *p != ':') continue;
        n = (size_t)(p - start);
        if (!n || n > 31 || (n == 1 && *start == '.') ||
            (n == 2 && !memcmp(start, "..", 2)) ||
            (n == 4 && start[0] == '.' && (start[1] == 'g' || start[1] == 'G') &&
             (start[2] == 'i' || start[2] == 'I') && (start[3] == 't' || start[3] == 'T')))
            return 0;
        if (!*p) break;
        ++b; start = p + 1;
    }
    return a == b;
}
static int GRMacFile(short volume, long root, const char *logical, const char *physical,
                      GRDirectory **directories, size_t *count, FSSpec *file, OSErr *last) {
    const char *p = physical, *start = p, *git = logical;
    size_t i, physicalLength, logicalLength, n;
    long parent = root, directory;
    GRDirectory *grown, *found;
    CInfoPBRec pb;
    Str31 name;
    OSErr error;
    int known;
    for (;;) {
        while (*p && *p != ':') ++p;
        n = (size_t)(p - start); name[0] = (unsigned char)n; memcpy(name + 1, start, n);
        error = FSMakeFSSpec(volume, parent, name, file);
        if (!*p) {
            if (!error) return GS_CONFLICT;
            return error == fnfErr ? 0 : GRMacFailure(error, last);
        }
        while (*git && *git != '/') ++git;
        if (!*git) return GS_FORMAT;
        physicalLength = (size_t)(p - physical);
        logicalLength = (size_t)(git - logical);
        found = NULL;
        for (i = 0; i < *count; ++i)
            if (strlen((*directories)[i].logical) == logicalLength &&
                !memcmp((*directories)[i].logical, logical, logicalLength)) {
                found = *directories + i;
                if (strlen(found->physical) != physicalLength ||
                    memcmp(found->physical, physical, physicalLength)) return GS_CONFLICT;
                break;
            }
        if (error == fnfErr) {
            if (found) return GS_CONFLICT;
            error = DirCreate(volume, parent, name, &directory);
            if (error) return GRMacFailure(error, last);
            if (*count == (size_t)-1 / sizeof(**directories)) return GB_SPACE;
            grown = (GRDirectory *)realloc(*directories, (*count + 1) * sizeof(**directories));
            if (!grown) return GB_MEMORY;
            *directories = grown; found = grown + *count;
            memset(found, 0, sizeof(*found)); ++*count;
            found->directory = directory;
            found->logical = GRPrefix(logical, logicalLength);
            found->physical = GRPrefix(physical, physicalLength);
            if (!found->logical || !found->physical) return GB_MEMORY;
        } else {
            if (error) return GRMacFailure(error, last);
            error = GRMacCatalog(file, &pb);
            if (error) return GRMacFailure(error, last);
            if (!(pb.dirInfo.ioFlAttrib & 16)) return GS_CONFLICT;
            directory = pb.dirInfo.ioDrDirID;
            /* An existing directory must be one we created under exactly the
               same logical AND native prefix, never a case-colliding alias. */
            known = 0;
            for (i = 0; i < *count; ++i)
                if ((*directories)[i].directory == directory) {
                    if (strlen((*directories)[i].physical) != physicalLength ||
                        memcmp((*directories)[i].physical, physical, physicalLength) ||
                        strlen((*directories)[i].logical) != logicalLength ||
                        memcmp((*directories)[i].logical, logical, logicalLength))
                        return GS_CONFLICT;
                    known = 1; break;
                }
            if (!known || !found || found->directory != directory) return GS_CONFLICT;
        }
        parent = directory; start = ++p; ++git;
    }
}
static OSErr GRMacFork(const FSSpec *file, int resource, const unsigned char *bytes, size_t n) {
    short ref;
    long count;
    size_t done = 0;
    OSErr error, closed;
    if (n > 0x7fffffffUL) return paramErr;
    error = resource ? FSpOpenRF(file, fsWrPerm, &ref) : FSpOpenDF(file, fsWrPerm, &ref);
    if (error) return error;
    while (!error && done < n) {
        count = (long)(n - done > 32768 ? 32768 : n - done);
        error = FSWrite(ref, &count, bytes + done);
        if (count > 0) done += (size_t)count;
        else if (!error) error = ioErr;
    }
    if (!error) error = SetEOF(ref, (long)n);
    closed = FSClose(ref);
    return error ? error : closed;
}
static void GRMacMeaningful(unsigned char info[32]) {
    info[8] &= (unsigned char)~1U;
    memset(info + 10, 0, 6); memset(info + 28, 0, 4);
}
int GRMacPrepare(GSRepository *r, const GRSnapshot *snapshot, const FSSpec *destination,
                 const char *const *paths, OSErr *lastError) {
    CInfoPBRec pb;
    Str255 name;
    FSSpec *files = NULL;
    GRDirectory *directories = NULL;
    GRContents contents;
    unsigned char info[32], verifyInfo[32], *data = NULL, *resource = NULL;
    size_t count = 0, i, dataLength, resourceLength;
    short volume;
    long root;
    OSErr error;
    int result = 0;
    if (!r || !snapshot || !destination || !paths || !lastError) return GB_BAD;
    *lastError = noErr; GRContentsInit(&contents);
    for (i = 0; i < snapshot->count; ++i)
        if (snapshot->files[i].mode == 0160000) return GI_UNSUPPORTED;
        else if (!GRMacPathValid(snapshot->files[i].path, paths[i])) return GI_UNSUPPORTED;
    error = GRMacCatalog(destination, &pb);
    if (error) return GRMacFailure(error, lastError);
    if (!(pb.dirInfo.ioFlAttrib & 16) || pb.dirInfo.ioDrDirID == fsRtDirID) return GS_CONFLICT;
    volume = destination->vRefNum; root = pb.dirInfo.ioDrDirID;
    memset(&pb, 0, sizeof(pb)); name[0] = 0;
    pb.dirInfo.ioNamePtr = name; pb.dirInfo.ioVRefNum = volume;
    pb.dirInfo.ioDrDirID = root; pb.dirInfo.ioFDirIndex = 1;
    error = PBGetCatInfoSync(&pb);
    if (error != fnfErr) return error ? GRMacFailure(error, lastError) : GS_CONFLICT;
    if (snapshot->count > (size_t)-1 / sizeof(*files)) return GB_SPACE;
    files = (FSSpec *)calloc(snapshot->count ? snapshot->count : 1, sizeof(*files));
    if (!files) return GB_MEMORY;
    /* Prepare all exclusive empty files before any blob write. Failure leaves
       only an invalid private tree; the caller must not publish it. */
    for (i = 0; i < snapshot->count; ++i) {
        result = GRMacFile(volume, root, snapshot->files[i].path, paths[i], &directories,
                           &count, files + i, lastError);
        if (result) goto done;
        error = FSpCreate(files + i, 0x3f3f3f3fUL, 0x3f3f3f3fUL, smSystemScript);
        if (error) { result = GRMacFailure(error, lastError); goto done; }
    }
    for (i = 0; i < snapshot->count; ++i) {
        result = GRReadFile(r, snapshot, i, &contents);
        if (result) goto done;
        memset(info, 0, 32); memcpy(info, "????????", 8);
        if (contents.hasFinderInfo) memcpy(info, contents.finderInfo, 32);
        GRMacMeaningful(info);
        error = GRMacFork(files + i, 0, contents.data, contents.dataLength);
        if (!error) error = GRMacFork(files + i, 1, contents.resource, contents.resourceLength);
        if (!error) error = GRMacCatalog(files + i, &pb);
        if (!error) {
            memcpy(&pb.hFileInfo.ioFlFndrInfo, info, 16);
            memcpy(&pb.hFileInfo.ioFlXFndrInfo, info + 16, 16);
            /* GetCatInfo returns the file ID in ioDirID; SetCatInfo needs
               the containing directory ID again when locating it by name. */
            pb.hFileInfo.ioDirID = files[i].parID;
            error = PBSetCatInfoSync(&pb);
        }
        if (error) { result = GRMacFailure(error, lastError); goto done; }
        result = GWReadFile(files + i, &data, &dataLength, verifyInfo, &resource, &resourceLength);
        if (!result && (dataLength != contents.dataLength || resourceLength != contents.resourceLength ||
                        (dataLength && memcmp(data, contents.data, dataLength)) ||
                        (resourceLength && memcmp(resource, contents.resource, resourceLength)) ||
                        memcmp(verifyInfo, info, 32))) result = GS_FORMAT;
        free(data); free(resource); data = resource = NULL;
        GRContentsFree(&contents);
        if (result) goto done;
    }
    error = FlushVol(NULL, volume);
    if (error) result = GRMacFailure(error, lastError);
done:
    GRContentsFree(&contents); free(data); free(resource); free(files);
    for (i = 0; i < count; ++i) { free(directories[i].logical); free(directories[i].physical); }
    free(directories);
    return result;
}
