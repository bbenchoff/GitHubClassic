#include "GitStore.h"
#include <stdlib.h>
#include <string.h>

static const char gsFormat[] = "GHClient repository 1\nobjects sha1-zlib 2/12/26\nrefs sha1-name\n";
static int GSReady(GSRepository *r) { return r && r->read && r->replace; }
static int GSRead(GSRepository *r, const char *p, unsigned char **d, size_t *n) {
    if (!GSReady(r))
        return GB_BAD;
    *d = NULL;
    *n = 0;
    return r->read(r->context, p, d, n);
}
static int GSExact(GSRepository *r, const char *path, const void *bytes, size_t length) {
    unsigned char *existing;
    size_t n;
    int result;
    result = r->replace(r->context, path, NULL, 0, bytes, length);
    if (result != GS_CONFLICT)
        return result;
    result = GSRead(r, path, &existing, &n);
    if (!result) {
        if (n != length || memcmp(existing, bytes, n))
            result = GS_FORMAT;
        free(existing);
    }
    return result;
}
static int GSRefSuffix(const char *name, const char *prefix) {
    const unsigned char *p = (const unsigned char *)name, *component;
    size_t n;
    size_t prefixLength = strlen(prefix);
    if (!name || strncmp(name, prefix, prefixLength) || !name[prefixLength])
        return 0;
    p += prefixLength;
    component = p;
    for (;; ++p) {
        if (!*p || *p == '/') {
            n = (size_t)(p - component);
            if (!n || component[0] == '.' || component[n - 1] == '.' ||
                (n >= 5 && !memcmp(component + n - 5, ".lock", 5)))
                return 0;
            if (!*p)
                break;
            component = p + 1;
        } else {
            if (*p <= 32 || *p == 127 || strchr("~^:?*[\\", *p) || (*p == '.' && p[1] == '.') ||
                (*p == '@' && p[1] == '{'))
                return 0;
        }
    }
    return 1;
}
int GSValidRef(const char *name) { return GSRefSuffix(name, "refs/heads/"); }
int GSValidTrackingRef(const char *name) {
    return GSRefSuffix(name, "refs/remotes/") && strchr(name + 13, '/') != NULL;
}
int GSOpen(GSRepository *r) {
    unsigned char *data;
    size_t n;
    int result;
    result = GSRead(r, "format", &data, &n);
    if (result)
        return result;
    result = n == sizeof(gsFormat) - 1 && !memcmp(data, gsFormat, n) ? GB_OK : GS_FORMAT;
    free(data);
    return result;
}
int GSInit(GSRepository *r, const char *branch) {
    char *head;
    size_t n;
    int result;
    if (!GSReady(r) || !GSValidRef(branch))
        return GB_BAD;
    n = strlen(branch);
    if (n > (size_t)-1 - 7)
        return GB_SPACE;
    head = (char *)malloc(n + 7);
    if (!head)
        return GB_MEMORY;
    memcpy(head, "ref: ", 5);
    memcpy(head + 5, branch, n);
    head[n + 5] = '\n';
    head[n + 6] = 0;
    /* Idempotent only for the exact same format and symbolic HEAD. */
    result = GSExact(r, "format", gsFormat, sizeof(gsFormat) - 1);
    if (!result)
        result = GSExact(r, "HEAD", head, n + 6);
    free(head);
    return result;
}
int GSObjectPath(const unsigned char oid[20], char path[64]) {
    char hex[41];
    if (!oid || !path)
        return GB_BAD;
    GBOIDFormat(oid, hex);
    memcpy(path, "objects/", 8);
    memcpy(path + 8, hex, 2);
    path[10] = '/';
    memcpy(path + 11, hex + 2, 12);
    path[23] = '/';
    memcpy(path + 24, hex + 14, 26);
    path[50] = 0;
    return 0;
}
int GSPutObject(GSRepository *r, const char *type, const void *body, size_t length,
                unsigned char oid[20]) {
    unsigned char *encoded, *existing, *decoded;
    size_t n, existingLength, bodyLength;
    char path[64], gotType[7];
    int result;
    if (!GSReady(r))
        return GB_BAD;
    result = GBObjectEncode(type, body, length, &encoded, &n, oid);
    if (result)
        return result;
    GSObjectPath(oid, path);
    result = r->replace(r->context, path, NULL, 0, encoded, n);
    free(encoded);
    if (result != GS_CONFLICT)
        return result;
    /* The same object may already exist with different compression. Validate it. */
    result = GSRead(r, path, &existing, &existingLength);
    if (result)
        return result;
    if (length > (size_t)-1 - 64) {
        free(existing);
        return GB_SPACE;
    }
    decoded = (unsigned char *)malloc(length + 64);
    if (!decoded) {
        free(existing);
        return GB_MEMORY;
    }
    result =
        GBObjectDecode(existing, existingLength, decoded, length + 64, gotType, &bodyLength, oid);
    if (!result && (bodyLength != length || strcmp(type, gotType) ||
                    (length && memcmp(body, decoded, length))))
        result = GS_FORMAT;
    free(decoded);
    free(existing);
    return result;
}
static int GSObjectSize(const unsigned char *bytes, size_t length, size_t *size,
                        size_t *bodySize) {
    /* Inflate needs a bounded output allocation. Read the object header through
       bounded trial buffers, doubling until its NUL is available. A future
       streaming inflater will avoid this whole-buffer path. */
    size_t capacity = 64, n, used, i, value, start;
    unsigned char *trial;
    int result;
    for (;;) {
        trial = (unsigned char *)calloc(1, capacity);
        if (!trial)
            return GB_MEMORY;
        result = GBInflate(bytes, length, trial, capacity, &n, &used);
        if (result != 0 && result != GB_SPACE) {
            free(trial);
            return result;
        }
        i = 0;
        while (i < 6 && i < capacity && trial[i] != ' ')
            ++i;
        if (i == capacity || trial[i] != ' ') {
            free(trial);
            return GB_BAD;
        }
        start = ++i;
        value = 0;
        while (i < capacity && trial[i]) {
            if (trial[i] < '0' || trial[i] > '9' || value > ((size_t)-1 - (trial[i] - '0')) / 10) {
                free(trial);
                return GB_BAD;
            }
            value = value * 10 + trial[i++] - '0';
        }
        if (i < capacity) {
            if (i == start || (i - start > 1 && trial[start] == '0') ||
                value > (size_t)-1 - i - 1) {
                free(trial);
                return GB_BAD;
            }
            *size = value + i + 1;
            *bodySize = value;
            free(trial);
            return 0;
        }
        free(trial);
        if (capacity > 1024)
            return GB_BAD;
        capacity *= 2;
    }
}
int GSGetObjectLimit(GSRepository *r, const unsigned char oid[20], char type[7],
                      unsigned char **body, size_t *length, size_t maxBodyBytes) {
    char path[64];
    unsigned char *encoded, *raw;
    size_t n, capacity, bodySize;
    int result;
    if (!body || !length || !type || !oid)
        return GB_BAD;
    *body = NULL;
    *length = 0;
    type[0] = 0;
    GSObjectPath(oid, path);
    result = GSRead(r, path, &encoded, &n);
    if (result == GS_NOT_FOUND) {
        unsigned char emptyTree[20];
        /* Git can resolve its canonical empty tree without a loose object.
           Only absence permits this identity-derived constant: an I/O error or
           an existing malformed/checksum-failing object must still be refused. */
        if (!GBObjectID("tree", NULL, 0, emptyTree) && !memcmp(oid, emptyTree, 20)) {
            raw = (unsigned char *)malloc(1);
            if (!raw) return GB_MEMORY;
            raw[0] = 0; *body = raw; strcpy(type, "tree"); return 0;
        }
    }
    if (result)
        return result;
    result = GSObjectSize(encoded, n, &capacity, &bodySize);
    if (result) {
        free(encoded);
        return result;
    }
    if (bodySize > maxBodyBytes) {
        free(encoded);
        return GB_SPACE;
    }
    raw = (unsigned char *)malloc(capacity);
    if (!raw) {
        free(encoded);
        return GB_MEMORY;
    }
    result = GBObjectDecode(encoded, n, raw, capacity, type, length, oid);
    free(encoded);
    if (result) {
        type[0] = 0;
        *length = 0;
        free(raw);
        return result;
    }
    *body = raw;
    return 0;
}
int GSGetObject(GSRepository *r, const unsigned char oid[20], char type[7], unsigned char **body,
                size_t *length) {
    return GSGetObjectLimit(r, oid, type, body, length, (size_t)-1);
}
int GSRefKey(const char *name, char path[64]) {
    unsigned char digest[20];
    char hex[41];
    GBSHA1 hash;
    if (!path || (!GSValidRef(name) && !GSValidTrackingRef(name) && (!name || strcmp(name,"refs/stash"))))
        return GB_BAD;
    GBSHA1Start(&hash);
    GBSHA1Update(&hash, name, strlen(name));
    GBSHA1Finish(&hash, digest);
    GBOIDFormat(digest, hex);
    memcpy(path, "refs/", 5);
    memcpy(path + 5, hex, 2);
    path[7] = '/';
    memcpy(path + 8, hex + 2, 12);
    path[20] = '/';
    memcpy(path + 21, hex + 14, 26);
    path[47] = 0;
    return 0;
}
static unsigned char *GSRefBytes(const char *name, const unsigned char oid[20], size_t *length) {
    unsigned char *p;
    size_t n = strlen(name);
    char hex[41];
    if (n > (size_t)-1 - 42)
        return NULL;
    p = (unsigned char *)malloc(n + 42);
    if (!p)
        return NULL;
    GBOIDFormat(oid, hex);
    memcpy(p, name, n);
    p[n] = 0;
    memcpy(p + n + 1, hex, 40);
    p[n + 41] = '\n';
    *length = n + 42;
    return p;
}
int GSReadRef(GSRepository *r, const char *name, unsigned char oid[20]) {
    char path[64], hex[41];
    unsigned char *bytes;
    size_t n, nameLength;
    int result;
    if (!oid)
        return GB_BAD;
    result = GSRefKey(name, path);
    if (result)
        return result;
    result = GSRead(r, path, &bytes, &n);
    if (result)
        return result;
    nameLength = strlen(name);
    if (nameLength > (size_t)-1 - 42 || n != nameLength + 42 ||
        memcmp(bytes, name, nameLength + 1) || bytes[n - 1] != '\n')
        result = GS_FORMAT;
    else {
        memcpy(hex, bytes + nameLength + 1, 40);
        hex[40] = 0;
        result = GBOIDParse(hex, oid);
    }
    free(bytes);
    return result;
}
int GSUpdateRef(GSRepository *r, const char *name, const unsigned char *expected,
                const unsigned char oid[20]) {
    char path[64], type[7];
    unsigned char *old = NULL, *next, *object;
    size_t oldLength = 0, nextLength, objectLength;
    int result;
    if (!GSReady(r) || !oid)
        return GB_BAD;
    result = GSRefKey(name, path);
    if (result)
        return result;
    result = GSGetObject(r, oid, type, &object, &objectLength);
    if (result)
        return result;
    free(object);
    if (strcmp(type, "commit"))
        return GS_FORMAT;
    if (expected) {
        old = GSRefBytes(name, expected, &oldLength);
        if (!old)
            return GB_MEMORY;
    }
    next = GSRefBytes(name, oid, &nextLength);
    if (!next) {
        free(old);
        return GB_MEMORY;
    }
    result = r->replace(r->context, path, old, oldLength, next, nextLength);
    free(old);
    free(next);
    return result;
}
int GSHead(GSRepository *r, char **branch, unsigned char oid[20]) {
    unsigned char *head;
    size_t n;
    int result;
    char *name;
    if (!branch || !oid)
        return GB_BAD;
    *branch = NULL;
    result = GSRead(r, "HEAD", &head, &n);
    if (result)
        return result;
    if (n < 7 || memcmp(head, "ref: ", 5) || head[n - 1] != '\n' || memchr(head, 0, n)) {
        free(head);
        return GS_FORMAT;
    }
    name = (char *)malloc(n - 5);
    if (!name) {
        free(head);
        return GB_MEMORY;
    }
    memcpy(name, head + 5, n - 6);
    name[n - 6] = 0;
    free(head);
    if (!GSValidRef(name)) {
        free(name);
        return GS_FORMAT;
    }
    result = GSReadRef(r, name, oid);
    if (result && result != GS_NOT_FOUND) {
        free(name);
        return result;
    }
    *branch = name;
    return result;
}
int GSSelectSameTip(GSRepository *r, const char *expectedBranch, const char *nextBranch,
                    const unsigned char expectedTip[20]) {
    unsigned char tip[20], *old, *next;
    size_t a, b;
    int result;
    if (!GSReady(r) || !GSValidRef(expectedBranch) || !GSValidRef(nextBranch) || !expectedTip)
        return GB_BAD;
    result = GSReadRef(r, expectedBranch, tip);
    if (result)
        return result;
    if (memcmp(tip, expectedTip, 20))
        return GS_CONFLICT;
    result = GSReadRef(r, nextBranch, tip);
    if (result)
        return result;
    if (memcmp(tip, expectedTip, 20))
        return GS_CONFLICT;
    a = strlen(expectedBranch);
    b = strlen(nextBranch);
    if (a > (size_t)-1 - 7 || b > (size_t)-1 - 7)
        return GB_SPACE;
    old = (unsigned char *)malloc(a + 7);
    next = (unsigned char *)malloc(b + 7);
    if (!old || !next) {
        free(old);
        free(next);
        return GB_MEMORY;
    }
    memcpy(old, "ref: ", 5);
    memcpy(old + 5, expectedBranch, a);
    old[a + 5] = '\n';
    memcpy(next, "ref: ", 5);
    memcpy(next + 5, nextBranch, b);
    next[b + 5] = '\n';
    result = r->replace(r->context, "HEAD", old, a + 6, next, b + 6);
    free(old);
    free(next);
    return result;
}
static int GSTreeOrder(const void *a, const void *b) {
    const GSTreeEntry *x = *(const GSTreeEntry *const *)a, *y = *(const GSTreeEntry *const *)b;
    size_t i = 0;
    unsigned char xc, yc;
    while (x->name[i] && y->name[i] && x->name[i] == y->name[i])
        ++i;
    xc = (unsigned char)x->name[i];
    yc = (unsigned char)y->name[i];
    if (!xc && x->mode == 040000)
        xc = '/';
    if (!yc && y->mode == 040000)
        yc = '/';
    return xc < yc ? -1 : xc > yc;
}
static int GSNameOrder(const void *a, const void *b) {
    return strcmp((*(const GSTreeEntry *const *)a)->name, (*(const GSTreeEntry *const *)b)->name);
}
int GSWriteTree(GSRepository *r, const GSTreeEntry *entries, size_t count, unsigned char oid[20]) {
    const GSTreeEntry **sorted;
    unsigned char *data;
    size_t i, n, total = 0, pos = 0;
    const char *mode;
    int result;
    if (!GSReady(r) || !oid || (!entries && count) || count > (size_t)-1 / sizeof(*sorted))
        return GB_BAD;
    sorted = (const GSTreeEntry **)malloc(count ? count * sizeof(*sorted) : 1);
    if (!sorted)
        return GB_MEMORY;
    for (i = 0; i < count; ++i) {
        sorted[i] = entries + i;
        if (!entries[i].name || !entries[i].name[0] || strchr(entries[i].name, '/') ||
            !strcmp(entries[i].name, ".") || !strcmp(entries[i].name, "..")) {
            free(sorted);
            return GB_BAD;
        }
        if (entries[i].mode != 0100644 && entries[i].mode != 0100755 &&
            entries[i].mode != 0120000 && entries[i].mode != 040000 && entries[i].mode != 0160000) {
            free(sorted);
            return GB_BAD;
        }
        n = strlen(entries[i].name);
        if (n > (size_t)-1 - 28 || total > (size_t)-1 - n - 28) {
            free(sorted);
            return GB_SPACE;
        }
        total += n + 28;
    }
    qsort(sorted, count, sizeof(*sorted), GSNameOrder);
    for (i = 1; i < count; ++i)
        if (!strcmp(sorted[i - 1]->name, sorted[i]->name)) {
            free(sorted);
            return GB_BAD;
        }
    qsort(sorted, count, sizeof(*sorted), GSTreeOrder);
    data = (unsigned char *)malloc(total ? total : 1);
    if (!data) {
        free(sorted);
        return GB_MEMORY;
    }
    for (i = 0; i < count; ++i) {
        mode = sorted[i]->mode == 040000    ? "40000"
               : sorted[i]->mode == 0100644 ? "100644"
               : sorted[i]->mode == 0100755 ? "100755"
               : sorted[i]->mode == 0120000 ? "120000"
                                            : "160000";
        n = strlen(mode);
        memcpy(data + pos, mode, n);
        pos += n;
        data[pos++] = ' ';
        n = strlen(sorted[i]->name) + 1;
        memcpy(data + pos, sorted[i]->name, n);
        pos += n;
        memcpy(data + pos, sorted[i]->oid, 20);
        pos += 20;
    }
    result = GSPutObject(r, "tree", data, pos, oid);
    free(data);
    free(sorted);
    return result;
}
int GSValidIdentity(const char *s) {
    const char *left, *right;
    size_t n;
    if (!s || !(n = strlen(s)) || strchr(s, '\n') || strchr(s, '\r'))
        return 0;
    left = strchr(s, '<');
    right = strchr(s, '>');
    return left && left > s + 1 && left[-1] == ' ' && right == s + n - 1 && right > left + 1 &&
           !strchr(left + 1, '<');
}
static int GSTime(const char *seconds, const char *zone) {
    const char *p;
    int hour, minute;
    if (!seconds || !seconds[0] || !zone || strlen(zone) != 5 || (zone[0] != '+' && zone[0] != '-'))
        return 0;
    p = seconds;
    if (*p == '-')
        ++p;
    if (!*p)
        return 0;
    while (*p)
        if (*p < '0' || *p++ > '9')
            return 0;
    for (p = zone + 1; *p; ++p)
        if (*p < '0' || *p > '9')
            return 0;
    hour = (zone[1] - '0') * 10 + zone[2] - '0';
    minute = (zone[3] - '0') * 10 + zone[4] - '0';
    return hour <= 23 && minute <= 59;
}
int GSWriteCommitObject(GSRepository *r, const unsigned char tree[20],
                        const unsigned char *parents, size_t parentCount,
                        const char *author, const char *committer, const char *seconds,
                        const char *zone, const char *message, unsigned char oid[20]) {
    char treeHex[41], parentHex[41], type[7];
    unsigned char *body, *object, written[20];
    size_t length, pos = 0, n, i, j, objectLength, extra;
    int result;
    const char *parts[15];
    int count = 0;
    if (!GSReady(r) || !tree || !oid || (parentCount && !parents) || !GSValidIdentity(author) ||
        !GSValidIdentity(committer) || !GSTime(seconds, zone) || !message || !*message)
        return GB_BAD;
    if (parentCount > GS_COMMIT_PARENTS)
        return GB_SPACE;
    for (i = 0; i < parentCount; ++i)
        for (j = 0; j < i; ++j)
            if (!memcmp(parents + i * 20, parents + j * 20, 20))
                return GB_BAD;
    GBOIDFormat(tree, treeHex);
    parts[count++] = "tree ";
    parts[count++] = treeHex;
    parts[count++] = "\n";
    parts[count++] = "author ";
    parts[count++] = author;
    parts[count++] = " ";
    parts[count++] = seconds;
    parts[count++] = " ";
    parts[count++] = zone;
    parts[count++] = "\ncommitter ";
    parts[count++] = committer;
    parts[count++] = " ";
    parts[count++] = seconds;
    parts[count++] = " ";
    parts[count++] = zone;
    length = parentCount * 48;
    for (i = 0; i < (size_t)count; ++i) {
        n = strlen(parts[i]);
        if (n > GS_COMMIT_BYTES || length > GS_COMMIT_BYTES - n)
            return GB_SPACE;
        length += n;
    }
    n = strlen(message);
    extra = 2 + (message[n - 1] != '\n');
    if (n > GS_COMMIT_BYTES - extra || length > GS_COMMIT_BYTES - n - extra)
        return GB_SPACE;
    length += n + extra;
    result = GSGetObjectLimit(r, tree, type, &object, &objectLength, GS_COMMIT_BYTES);
    if (result)
        return result;
    free(object);
    if (strcmp(type, "tree"))
        return GS_FORMAT;
    for (i = 0; i < parentCount; ++i) {
        result = GSGetObjectLimit(r, parents + i * 20, type, &object, &objectLength,
                                  GS_COMMIT_BYTES);
        if (result)
            return result;
        free(object);
        if (strcmp(type, "commit"))
            return GS_FORMAT;
    }
    body = (unsigned char *)malloc(length);
    if (!body)
        return GB_MEMORY;
    for (i = 0; i < (size_t)count; ++i) {
        n = strlen(parts[i]);
        memcpy(body + pos, parts[i], n);
        pos += n;
        if (i == 2)
            for (j = 0; j < parentCount; ++j) {
                GBOIDFormat(parents + j * 20, parentHex);
                memcpy(body + pos, "parent ", 7); pos += 7;
                memcpy(body + pos, parentHex, 40); pos += 40;
                body[pos++] = '\n';
            }
    }
    body[pos++] = '\n';
    body[pos++] = '\n';
    n = strlen(message);
    memcpy(body + pos, message, n);
    pos += n;
    if (body[pos - 1] != '\n')
        body[pos++] = '\n';
    result = GSPutObject(r, "commit", body, pos, written);
    free(body);
    if (!result)
        memcpy(oid, written, 20);
    return result;
}
int GSCommit(GSRepository *r, const char *branch, const unsigned char tree[20],
             const unsigned char *expectedParent, const char *author, const char *committer,
             const char *seconds, const char *zone, const char *message, unsigned char oid[20]) {
    unsigned char parent[20];
    int result;
    if (!GSValidRef(branch)) return GB_BAD;
    if (expectedParent) memcpy(parent, expectedParent, 20);
    result = GSWriteCommitObject(r, tree, expectedParent ? parent : NULL,
                                 expectedParent ? 1 : 0, author, committer, seconds, zone,
                                 message, oid);
    if (!result)
        result = GSUpdateRef(r, branch, expectedParent ? parent : NULL, oid);
    return result;
}
