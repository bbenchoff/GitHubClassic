/* Native single-selection List Manager chooser, included by Main.c. */
static ListHandle gRepositoryList;
static int gRepositoryListCount;
static char gRepositorySearch[128];
static unsigned long gRepositorySearchTick;
static int gRepositoryForClone;
static int RepositorySelected(void) {
    Cell cell;cell.h=cell.v=0;
    return gRepositoryList && LGetSelect(true,&cell,gRepositoryList)?cell.v:-1;
}
static void RepositorySelection(DialogPtr dialog,int selected) {
    Cell cell;short kind;Handle item;Rect rect;Str255 text;char label[256];
    int old=RepositorySelected();
    if(old>=0){cell.h=0;cell.v=(short)old;LSetSelect(false,cell,gRepositoryList);}
    if(selected>=0 && selected<gRepositoryListCount) {
        cell.h=0;cell.v=(short)selected;LSetSelect(true,cell,gRepositoryList);if(old!=selected)LAutoScroll(gRepositoryList);
        snprintf(label,sizeof(label),"%s repository. Default branch: %.150s",gRepos[selected].isPrivate?"Private":"Public",gRepos[selected].branch);
    } else strcpy(label,gRepositoryForClone?"Select a repository, then choose Select.":"Select a repository, then choose Open. Double-click also opens it.");
    GetDialogItem(dialog,7,&kind,&item,&rect);Pascal(label,text);SetDialogItemText(item,text);
    GetDialogItem(dialog,1,&kind,&item,&rect);HiliteControl((ControlHandle)item,selected>=0?0:255);
}
static pascal void RepositoryDraw(DialogPtr dialog,short number) {
    GrafPtr saved;Handle item;short kind,font,size;Style face;Rect rect;RGBColor foreground;PenState pen;
    if(!gRepositoryList)return;
    GetPort(&saved);SetPort((GrafPtr)dialog);font=((GrafPtr)dialog)->txFont;size=((GrafPtr)dialog)->txSize;face=((GrafPtr)dialog)->txFace;
    GetForeColor(&foreground);GetPenState(&pen);PenNormal();
    GetDialogItem(dialog,number,&kind,&item,&rect);Color(0,0,0);FrameRect(&rect);
    TextFont(gGeneva);TextSize(12);TextFace(0);LUpdate(((WindowPtr)dialog)->visRgn,gRepositoryList);
    RGBForeColor(&foreground);SetPenState(&pen);TextFont(font);TextSize(size);TextFace(face);SetPort(saved);
}
static int RepositoryPrefix(const char *text,const char *prefix) {
    unsigned char a,b;
    while(*prefix){a=(unsigned char)*text++;b=(unsigned char)*prefix++;if(a>='A' && a<='Z')a+=32;if(b>='A' && b<='Z')b+=32;if(a!=b)return 0;}
    return 1;
}
static pascal Boolean RepositoryFilter(DialogPtr dialog,EventRecord *event,short *hit) {
    Point point;Rect rect;Handle item;short kind;unsigned char key;int selected=RepositorySelected(),next=selected,i,doubled;size_t n;
    *hit=0; /* Consumed selection/scroll keys and clicks do not hit a button. */
    if(event->what==mouseDown) {
        GetDialogItem(dialog,6,&kind,&item,&rect);point=event->where;SetPort((GrafPtr)dialog);GlobalToLocal(&point);
        if(PtInRect(point,&rect)) {
            TextFont(gGeneva);TextSize(12);TextFace(0);doubled=LClick(point,event->modifiers,gRepositoryList);
            selected=RepositorySelected();RepositorySelection(dialog,selected);
            if(doubled && selected>=0)*hit=1;return true;
        }
    }
    if(event->what==keyDown || event->what==autoKey) {
        key=(unsigned char)(event->message&charCodeMask);
        if((event->modifiers&cmdKey) && (key=='r' || key=='R')){*hit=11;return true;}
        if(!(event->modifiers&cmdKey)) {
            if(key==30)next=selected<=0?0:selected-1;
            else if(key==31)next=selected<0?0:selected+1;
            else if(key==1 || key==11)next=key==1?0:selected-11;
            else if(key==4 || key==12)next=key==4?gRepositoryListCount-1:selected+11;
            else if(key>=32 && key<=126) {
                if((unsigned long)(event->when-gRepositorySearchTick)>60)gRepositorySearch[0]=0;
                gRepositorySearchTick=event->when;n=strlen(gRepositorySearch);
                if(n+1<sizeof(gRepositorySearch)){gRepositorySearch[n]=(char)key;gRepositorySearch[n+1]=0;}
                for(i=0;i<gRepositoryListCount;++i)if(RepositoryPrefix(gRepos[i].fullName,gRepositorySearch) || RepositoryPrefix(gRepos[i].name,gRepositorySearch)){next=i;break;}
                if(i==gRepositoryListCount)SysBeep(1);
            } else if((key==13 || key==3) && selected<0){SysBeep(1);return true;}
            else return NativeDialogFilter(dialog,event,hit);
            if(gRepositoryListCount){if(next<0)next=0;if(next>=gRepositoryListCount)next=gRepositoryListCount-1;RepositorySelection(dialog,next);}
            return true;
        }
    }
    return NativeDialogFilter(dialog,event,hit);
}
/* Nonnegative=row; -1=cancel,-2=previous,-3=next,-4=by name,-5=refresh. */
static int RepositoryListChoose(int page,int count,int forClone) {
    DialogPtr dialog;UserItemUPP draw;ModalFilterUPP filter;Rect view,data,bounds;Point cellSize;Cell cell;
    short kind,hit=0;Handle item;char label[256];Str255 text;int i,selected,result=-1;
    dialog=GetNewDialog(131,NULL,(WindowPtr)-1);if(!dialog)return -1;
    PrepareDialogChrome(dialog,9,10);
    gRepositoryForClone=forClone;
    if(forClone) {
        Pascal("Select Repository to Clone",text);SetWTitle((WindowPtr)dialog,text);
        GetDialogItem(dialog,1,&kind,&item,&bounds);Pascal("Select",text);SetControlTitle((ControlHandle)item,text);
        GetDialogItem(dialog,5,&kind,&item,&bounds);Pascal("Enter Name...",text);SetControlTitle((ControlHandle)item,text);
    }
    draw=NewUserItemProc(RepositoryDraw);filter=NewModalFilterProc(RepositoryFilter);
    GetDialogItem(dialog,6,&kind,&item,&bounds);view=bounds;InsetRect(&view,1,1);view.right-=15;
    SetRect(&data,0,0,1,(short)count);cellSize.h=(short)(view.right-view.left);cellSize.v=20;
    SetPort((GrafPtr)dialog);TextFont(gGeneva);TextSize(12);TextFace(0);
    gRepositoryList=LNew(&view,&data,cellSize,0,(WindowPtr)dialog,false,false,false,true);
    if(!draw || !filter || !gRepositoryList)goto done;
    gRepositoryListCount=count;gRepositorySearch[0]=0;gRepositorySearchTick=0;
    (*gRepositoryList)->selFlags=lOnlyOne;(*gRepositoryList)->listFlags|=lDoVAutoscroll;
    for(i=0;i<count;++i){cell.h=0;cell.v=(short)i;LSetCell(gRepos[i].fullName,(short)strlen(gRepos[i].fullName),cell,gRepositoryList);}
    GetDialogItem(dialog,6,&kind,&item,&bounds);SetDialogItem(dialog,6,kind,(Handle)draw,&bounds);
    GetDialogItem(dialog,8,&kind,&item,&bounds);snprintf(label,sizeof(label),"Repositories for %.120s - page %d",gUser,page);Pascal(label,text);SetDialogItemText(item,text);
    GetDialogItem(dialog,3,&kind,&item,&bounds);HiliteControl((ControlHandle)item,page>1?0:255);
    GetDialogItem(dialog,4,&kind,&item,&bounds);HiliteControl((ControlHandle)item,count==GH_REPOSITORY_PAGE?0:255);
    LSetDrawingMode(true,gRepositoryList);RepositorySelection(dialog,count?0:-1);PrepareDialog(dialog,1,2);
    SetStatus(forClone?"Choose a repository to clone. Selection returns to the destination review.":"Choose a repository. Arrow keys and typing select; double-click or Open opens it.");DrawDialog(dialog);
    while(!hit){RunModalDialog(filter,&hit);if(hit==1 && RepositorySelected()<0)hit=0;}
    selected=RepositorySelected();result=hit==1?selected:hit==3?-2:hit==4?-3:hit==5?-4:hit==11?-5:-1;
done:
    if(gRepositoryList)LDispose(gRepositoryList);gRepositoryList=NULL;gRepositoryListCount=0;
    if(draw)DisposeRoutineDescriptor((UniversalProcPtr)draw);if(filter)DisposeRoutineDescriptor((UniversalProcPtr)filter);
    DisposeDialog(dialog);SetPort(gWindow);return result;
}
