/* Seed bootstrap from active user input, following RFC 4086 section 3.6.
   The timing count is a conservative collection policy, not a measurement or
   proof of physical min-entropy. A hash cannot create entropy. This requires
   an unpredictable human operator and a timer preserving input variation;
   predictable automation, a compromised OS, and cloned machines are outside
   that assumption. Keep imported CSPRNG seeds available for provisioning.

   Credit at most one sample per novel interval >=25ms, with separate motion,
   keyboard, spatial-diversity and elapsed-time gates. Idle polling, clocks,
   coordinates alone, key auto-repeat, and duplicate intervals cannot finish
   collection. All input is conditioned by two domain-separated SHA-256 pools.
   No raw event log or plaintext seed is written to disk. */
#include "GHSeedCollect.h"
#include "GHVault.h"
#include <string.h>

static void GHSPut(unsigned char *p,unsigned long n) {
    p[0]=(unsigned char)(n>>24);p[1]=(unsigned char)(n>>16);
    p[2]=(unsigned char)(n>>8);p[3]=(unsigned char)n;
}
void GHSClear(GHSeedCollector *pool) {
    if(!pool)return;
    mbedtls_sha256_free(pool->hash);mbedtls_sha256_free(pool->hash+1);
    GVClear(pool,sizeof(*pool));
}
int GHSInit(GHSeedCollector *pool,unsigned long now) {
    static const unsigned char domain[]="Classic Github local seed v1";
    unsigned char n;int i,result=0;
    if(!pool)return -1;
    memset(pool,0,sizeof(*pool));pool->started=now;pool->last=now;pool->lastKey=-1;
    for(i=0;i<2;++i)mbedtls_sha256_init(pool->hash+i);
    for(i=0;i<2 && !result;++i) {
        result=mbedtls_sha256_starts_ret(pool->hash+i,0);
        if(!result)result=mbedtls_sha256_update_ret(pool->hash+i,domain,sizeof(domain));
        n=(unsigned char)i;
        if(!result)result=mbedtls_sha256_update_ret(pool->hash+i,&n,1);
    }
    if(result)pool->failed=1;
    return result;
}
static int GHSSeen(unsigned char *set,unsigned char value) {
    unsigned char mask=(unsigned char)(1U<<(value&7));
    if(set[value>>3]&mask)return 1;
    set[value>>3]|=mask;return 0;
}
static int GHSFeed(GHSeedCollector *pool,unsigned long now,unsigned long tick,
                   short x,short y,unsigned char kind,unsigned short value) {
    unsigned char record[24];unsigned long interval;unsigned short i;int result=0;
    if(!pool || pool->failed || pool->finished)return -1;
    interval=now-pool->last;
    if(interval<25000UL)return 0;
    pool->last=now;
    memset(record,0,sizeof(record));record[0]=kind;
    GHSPut(record+2,now);GHSPut(record+6,tick);GHSPut(record+10,interval);
    record[14]=(unsigned char)((unsigned short)x>>8);record[15]=(unsigned char)x;
    record[16]=(unsigned char)((unsigned short)y>>8);record[17]=(unsigned char)y;
    record[18]=(unsigned char)(value>>8);record[19]=(unsigned char)value;
    GHSPut(record+20,++pool->events);
    for(i=0;i<2 && !result;++i)result=mbedtls_sha256_update_ret(pool->hash+i,record,sizeof(record));
    GVClear(record,sizeof(record));
    if(result){pool->failed=1;return result;}
    if(kind==1) {
        if(pool->moves<GHS_MOVES)++pool->moves;
        if(!GHSSeen(pool->cellSet,(unsigned char)value) && pool->cells<GHS_CELLS)++pool->cells;
    } else {
        if(pool->keys<GHS_KEYS)++pool->keys;
        if(!GHSSeen(pool->keySet,(unsigned char)value) && pool->distinctKeys<GHS_DISTINCT_KEYS)++pool->distinctKeys;
    }
    if(pool->haveTime && pool->timings<GHS_TIMINGS) {
        for(i=0;i<pool->timings && pool->intervals[i]!=interval;++i){}
        if(i==pool->timings)pool->intervals[pool->timings++]=interval;
    }
    pool->haveTime=1;return 0;
}
int GHSPointer(GHSeedCollector *pool,unsigned long now,unsigned long tick,short x,short y,unsigned char cell) {
    long dx,dy;int result;
    if(!pool || cell>=64 || pool->failed || pool->finished)return -1;
    if(!pool->havePoint){pool->x=x;pool->y=y;pool->havePoint=1;return 0;}
    dx=(long)x-pool->x;dy=(long)y-pool->y;
    if(dx<0)dx=-dx;
    if(dy<0)dy=-dy;
    if(dx+dy<4 || now-pool->last<25000UL)return 0;
    result=GHSFeed(pool,now,tick,x,y,1,cell);
    if(!result){pool->x=x;pool->y=y;pool->lastKey=-1;}
    return result;
}
int GHSKey(GHSeedCollector *pool,unsigned long now,unsigned long tick,unsigned char key,unsigned short modifiers) {
    int result;
    if(!pool || pool->failed || pool->finished)return -1;
    if((short)key==pool->lastKey || now-pool->last<25000UL)return 0;
    result=GHSFeed(pool,now,tick,(short)modifiers,0,2,key);
    if(!result)pool->lastKey=key;
    return result;
}
static unsigned short GHSMinimum(unsigned short a,unsigned short b) {return a<b?a:b;}
unsigned short GHSProgress(const GHSeedCollector *pool,unsigned long now) {
    unsigned long elapsed;unsigned short percent;
    if(!pool || pool->failed || pool->finished)return 0;
    elapsed=now-pool->started;
    percent=(unsigned short)(pool->timings*100UL/GHS_TIMINGS);
    percent=GHSMinimum(percent,(unsigned short)(pool->keys*100UL/GHS_KEYS));
    percent=GHSMinimum(percent,(unsigned short)(pool->moves*100UL/GHS_MOVES));
    percent=GHSMinimum(percent,(unsigned short)(pool->cells*100UL/GHS_CELLS));
    percent=GHSMinimum(percent,(unsigned short)(pool->distinctKeys*100UL/GHS_DISTINCT_KEYS));
    percent=GHSMinimum(percent,elapsed>=GHS_MIN_US?100:(unsigned short)(elapsed*100UL/GHS_MIN_US));
    return percent;
}
int GHSFinish(GHSeedCollector *pool,unsigned long now,unsigned char output[64]) {
    int result;
    if(!output)return -1;
    GVClear(output,64);
    if(!pool || GHSProgress(pool,now)!=100)return -1;
    result=mbedtls_sha256_finish_ret(pool->hash,output);
    if(!result)result=mbedtls_sha256_finish_ret(pool->hash+1,output+32);
    pool->finished=1;
    if(result){pool->failed=1;GVClear(output,64);}
    return result;
}
