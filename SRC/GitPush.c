#include "GitPush.h"
#include "GHCore.h"
#include <stdlib.h>
#include <string.h>

typedef struct {
    unsigned char *bytes;
    size_t used, capacity, maximum;
    int (*progress)(void *, size_t);
    void *context;
} GUBuffer;
static void GUWord(unsigned char *p, GBWord n) {
    p[0] = (unsigned char)(n >> 24); p[1] = (unsigned char)(n >> 16);
    p[2] = (unsigned char)(n >> 8); p[3] = (unsigned char)n;
}
static int GUReserve(GUBuffer *b, size_t extra) {
    size_t need, capacity;
    unsigned char *grown;
    if (extra > b->maximum - b->used) return GB_SPACE;
    need = b->used + extra;
    if (need <= b->capacity) return 0;
    capacity = b->capacity ? b->capacity : 16384;
    if (capacity > b->maximum) capacity = b->maximum;
    while (capacity < need) {
        if (capacity > b->maximum / 2) capacity = b->maximum;
        else capacity *= 2;
    }
    grown = (unsigned char *)realloc(b->bytes, capacity);
    if (!grown) return GB_MEMORY;
    b->bytes = grown; b->capacity = capacity; return 0;
}
static int GUObject(void *context, const unsigned char oid[20], const char *type,
                      const unsigned char *body, size_t length) {
    GUBuffer *b = (GUBuffer *)context;
    unsigned char header[16], c;
    size_t size = length, n = 0, blocks, compressed, written;
    int kind, error;
    (void)oid; /* GVWalk already verified the exact canonical object ID. */
    if (!strcmp(type, "commit")) kind = 1;
    else if (!strcmp(type, "tree")) kind = 2;
    else if (!strcmp(type, "blob")) kind = 3;
    else return GS_FORMAT;
    c = (unsigned char)((kind << 4) | (size & 15)); size >>= 4;
    while (size) {
        header[n++] = (unsigned char)(c | 128); c = (unsigned char)(size & 127); size >>= 7;
    }
    header[n++] = c;
    blocks = length / 65535 + (length % 65535 != 0); if (!blocks) blocks = 1;
    if (blocks > ((size_t)-1 - 6) / 5 || length > (size_t)-1 - (blocks * 5 + 6)) return GB_SPACE;
    compressed = length + blocks * 5 + 6;
    if (compressed > (size_t)-1 - n - 20) return GB_SPACE;
    error = GUReserve(b, compressed + n + 20); if (error) return error;
    memcpy(b->bytes + b->used, header, n); b->used += n;
    error = GBDeflateStore(body, length, b->bytes + b->used, compressed, &written);
    if (!error) b->used += written;
    return error;
}
static int GUProgress(void *context, size_t count) {
    GUBuffer *b = (GUBuffer *)context;
    return b->progress ? b->progress(b->context, count) : 0;
}
int GUPackBuildSince(GSRepository *repo, const unsigned char tip[20], const unsigned char base[20],const GVLimits *limits,
                  size_t maxPackBytes, int (*progress)(void *, size_t), void *context,
                  unsigned char **bytes, size_t *length, GVResult *out) {
    GUBuffer buffer;
    GVResult result;
    GBSHA1 hash;
    unsigned char digest[20];
    int error;
    if (!bytes || !length || !out) return GB_BAD;
    *bytes = NULL; *length = 0; memset(out, 0, sizeof(*out));
    if (maxPackBytes < 32) return GB_SPACE;
    memset(&buffer, 0, sizeof(buffer)); buffer.maximum = maxPackBytes;
    buffer.progress = progress; buffer.context = context;
    error = GUReserve(&buffer, 32);
    if (error) return error;
    memcpy(buffer.bytes, "PACK", 4); GUWord(buffer.bytes + 4, 2); buffer.used = 12;
    error = GVWalkDifference(repo, tip, base, limits, GUObject, GUProgress, &buffer, &result);
    if (!error && result.objects > 0xffffffffUL) error = GB_SPACE;
    if (!error) {
        GUWord(buffer.bytes + 8, (GBWord)result.objects);
        GBSHA1Start(&hash); GBSHA1Update(&hash, buffer.bytes, buffer.used); GBSHA1Finish(&hash, digest);
        memcpy(buffer.bytes + buffer.used, digest, 20); buffer.used += 20;
        *bytes = buffer.bytes; *length = buffer.used; *out = result; buffer.bytes = NULL;
    }
    free(buffer.bytes); return error;
}
int GUPackBuild(GSRepository *repo,const unsigned char tip[20],const GVLimits *limits,
                  size_t maximum,int (*progress)(void *,size_t),void *context,
                  unsigned char **bytes,size_t *length,GVResult *out) {
    return GUPackBuildSince(repo,tip,NULL,limits,maximum,progress,context,bytes,length,out);
}

typedef struct {
    const GUFileIO *file;
    size_t used, maximum, objects;
    int (*progress)(void *, size_t);
    void *context;
} GUFilePack;
static int GUFileAppend(GUFilePack *b, const void *p, size_t n) {
    int error;
    if (b->used > b->maximum - 20 || n > b->maximum - 20 - b->used) return GB_SPACE;
    error = b->file->write(b->file->context, b->used, p, n);
    if (!error) b->used += n;
    return error;
}
static int GUFileObject(void *context, const unsigned char oid[20], const char *type,
                        const unsigned char *body, size_t length) {
    GUFilePack *b = (GUFilePack *)context;
    unsigned char header[16], z[5], c;
    size_t size = length, n = 0, left = length, part, at, amount;
    int kind, error;
    (void)oid;
    if (!strcmp(type, "commit")) kind = 1;
    else if (!strcmp(type, "tree")) kind = 2;
    else if (!strcmp(type, "blob")) kind = 3;
    else return GS_FORMAT;
    c = (unsigned char)((kind << 4) | (size & 15)); size >>= 4;
    while (size) { header[n++] = (unsigned char)(c | 128); c = (unsigned char)(size & 127); size >>= 7; }
    header[n++] = c;
    error = GUFileAppend(b, header, n);
    z[0] = 0x78; z[1] = 0x01;
    if (!error) error = GUFileAppend(b, z, 2);
    do {
        part = left > 65535 ? 65535 : left;
        z[0] = (unsigned char)(left <= 65535); z[1] = (unsigned char)part;
        z[2] = (unsigned char)(part >> 8); z[3] = (unsigned char)(~part); z[4] = (unsigned char)((~part) >> 8);
        if (!error) error = GUFileAppend(b, z, 5);
        at = 0;
        while (!error && at < part) {
            amount = part - at; if (amount > 16384) amount = 16384;
            error = GUFileAppend(b, body + length - left + at, amount); at += amount;
            if (!error && b->progress) error = b->progress(b->context, b->objects);
        }
        left -= part;
    } while (!error && left);
    GUWord(z, GBAdler32(body, length));
    if (!error) error = GUFileAppend(b, z, 4);
    if (!error) ++b->objects;
    return error;
}
static int GUFileProgress(void *context, size_t count) {
    GUFilePack *b = (GUFilePack *)context;
    return b->progress ? b->progress(b->context, count) : 0;
}
int GUPackWriteSince(GSRepository *repo, const unsigned char tip[20],const unsigned char base[20], const GVLimits *limits,
                size_t maximum, int (*progress)(void *, size_t), void *context,
                const GUFileIO *file, size_t *length, GVResult *out) {
    GUFilePack b;
    GVResult graph;
    GBSHA1 hash;
    unsigned char header[12], digest[20], *buffer;
    size_t at, amount;
    int error;
    if (!length || !out) return GB_BAD;
    *length = 0; memset(out, 0, sizeof(*out));
    if (!file || !file->read || !file->write || maximum < 32) return GB_BAD;
    memset(&b, 0, sizeof(b)); b.file = file; b.maximum = maximum; b.progress = progress; b.context = context;
    memcpy(header, "PACK", 4); GUWord(header + 4, 2); GUWord(header + 8, 0);
    error = GUFileAppend(&b, header, 12);
    if (!error) error = GVWalkDifference(repo, tip, base, limits, GUFileObject, GUFileProgress, &b, &graph);
    if (!error && graph.objects > 0xffffffffUL) error = GB_SPACE;
    if (error) return error;
    GUWord(header + 8, (GBWord)graph.objects);
    error = file->write(file->context, 0, header, 12);
    buffer = (unsigned char *)malloc(16384);
    if (!buffer) return error ? error : GB_MEMORY;
    GBSHA1Start(&hash);
    for (at = 0; !error && at < b.used; at += amount) {
        amount = b.used - at; if (amount > 16384) amount = 16384;
        error = file->read(file->context, at, buffer, amount);
        if (!error) GBSHA1Update(&hash, buffer, amount);
        if (!error && progress) error = progress(context, graph.objects);
    }
    free(buffer);
    if (!error) {
        GBSHA1Finish(&hash, digest);
        error = file->write(file->context, b.used, digest, 20);
    }
    if (!error) { *length = b.used + 20; *out = graph; }
    return error;
}

int GUPackWrite(GSRepository *repo,const unsigned char tip[20],const GVLimits *limits,
                size_t maximum,int (*progress)(void *,size_t),void *context,
                const GUFileIO *file,size_t *length,GVResult *out) {
    return GUPackWriteSince(repo,tip,NULL,limits,maximum,progress,context,file,length,out);
}

static GBWord GUGetWord(const unsigned char *p) {
    return ((GBWord)p[0] << 24) | ((GBWord)p[1] << 16) | ((GBWord)p[2] << 8) | p[3];
}
static void GUHash(const void *p, size_t n, unsigned char digest[20]) {
    GBSHA1 hash; GBSHA1Start(&hash); GBSHA1Update(&hash, p, n); GBSHA1Finish(&hash, digest);
}
void GUIntentInit(GUIntent *intent) { memset(intent, 0, sizeof(*intent)); intent->version = 1; }
static const char *GULocalBranch(const GUIntent *intent) {
    return intent->version >= 2 ? intent->localBranch : intent->branch;
}
static int GUIntentFieldsValid(const GUIntent *intent) {
    size_t i, n;
    if (!intent || !memchr(intent->repository, 0, sizeof(intent->repository)) ||
        !memchr(intent->branch, 0, sizeof(intent->branch)) ||
        !memchr(intent->localBranch, 0, sizeof(intent->localBranch)) ||
        !memchr(intent->accountID, 0, sizeof(intent->accountID))) return 0;
    if ((intent->version != 1 && intent->version != 2 && intent->version != 3) ||
        (intent->version == 1 && intent->localBranch[0]) ||
        (intent->version >= 2 && !GSValidRef(intent->localBranch)) ||
        !GHValidRepository(intent->repository) || !GSValidRef(intent->branch) ||
        strncmp(intent->branch, "refs/heads/", 11) ||
        (intent->haveTracking != 0 && intent->haveTracking != 1)) return 0;
    n = strlen(intent->accountID);
    if (!n || intent->accountID[0] == '0') return 0;
    for (i = 0; i < n; ++i) if (intent->accountID[i] < '0' || intent->accountID[i] > '9') return 0;
    return 1;
}
static int GUIntentValid(const GUIntent *intent) {
    unsigned char zero[20];
    if(!GUIntentFieldsValid(intent))return 0;
    memset(zero, 0, sizeof(zero));
    if(intent->version==3 && !memcmp(intent->oldTip,zero,20))return 0;
    return memcmp(intent->newTip, zero, 20) && memcmp(intent->newTip, intent->oldTip, 20) &&
           (intent->haveTracking ? memcmp(intent->trackingTip, zero, 20) != 0
                                 : memcmp(intent->trackingTip, zero, 20) == 0);
}
int GUIntentEncode(const GUIntent *intent, unsigned char **bytes, size_t *length) {
    unsigned char *p;
    size_t rn, bn, an, ln, header, n;
    if (!bytes || !length) return GB_BAD;
    *bytes = NULL; *length = 0;
    if (!GUIntentValid(intent)) return GB_BAD;
    rn = strlen(intent->repository); bn = strlen(intent->branch); an = strlen(intent->accountID);
    ln = intent->version >= 2 ? strlen(intent->localBranch) : 0;
    header = intent->version >= 2 ? 88 : 84;
    n = header + 20 + rn + bn + an + ln; p = (unsigned char *)malloc(n);
    if (!p) return GB_MEMORY;
    memcpy(p, intent->version == 3 ? "GHPUSH03" : intent->version == 2 ? "GHPUSH02" : "GHPUSH01", 8); GUWord(p + 8, (GBWord)rn); GUWord(p + 12, (GBWord)bn);
    GUWord(p + 16, (GBWord)an); GUWord(p + 20, (GBWord)intent->haveTracking);
    if (intent->version >= 2) GUWord(p + 24, (GBWord)ln);
    memcpy(p + header - 60, intent->oldTip, 20); memcpy(p + header - 40, intent->newTip, 20); memcpy(p + header - 20, intent->trackingTip, 20);
    memcpy(p + header, intent->repository, rn); memcpy(p + header + rn, intent->branch, bn);
    memcpy(p + header + rn + bn, intent->accountID, an);
    if (ln) memcpy(p + header + rn + bn + an, intent->localBranch, ln);
    GUHash(p, n - 20, p + n - 20);
    *bytes = p; *length = n; return 0;
}
int GUIntentParse(const void *input, size_t length, GUIntent *out) {
    const unsigned char *p = (const unsigned char *)input;
    GUIntent intent;
    unsigned char digest[20];
    size_t rn, bn, an, ln, header;
    int version;
    if (!p || !out) return GB_BAD;
    if (length < 104 || length > 2441) return GS_FORMAT;
    version = !memcmp(p, "GHPUSH01", 8) ? 1 : !memcmp(p, "GHPUSH02", 8) ? 2 : !memcmp(p, "GHPUSH03", 8) ? 3 : 0;
    if (!version || (version >= 2 && length < 108)) return GS_FORMAT;
    header = version >= 2 ? 88 : 84; ln = version >= 2 ? GUGetWord(p + 24) : 0;
    rn = GUGetWord(p + 8); bn = GUGetWord(p + 12); an = GUGetWord(p + 16);
    if (!rn || rn > 254 || !bn || bn > 1024 || !an || an > 31 ||
        (version >= 2 && (!ln || ln > 1024)) ||
        length != header + 20 + rn + bn + an + ln || GUGetWord(p + 20) > 1 || memchr(p + header, 0, rn + bn + an + ln)) return GS_FORMAT;
    GUHash(p, length - 20, digest);
    if (memcmp(digest, p + length - 20, 20)) return GB_CHECKSUM;
    GUIntentInit(&intent); intent.version = version; intent.haveTracking = (int)GUGetWord(p + 20);
    memcpy(intent.oldTip, p + header - 60, 20); memcpy(intent.newTip, p + header - 40, 20); memcpy(intent.trackingTip, p + header - 20, 20);
    memcpy(intent.repository, p + header, rn); memcpy(intent.branch, p + header + rn, bn);
    memcpy(intent.accountID, p + header + rn + bn, an);
    if (ln) memcpy(intent.localBranch, p + header + rn + bn + an, ln);
    if (!GUIntentValid(&intent)) return GS_FORMAT;
    *out = intent; return 0;
}
static void GUIdle(unsigned char bytes[28]) {
    memcpy(bytes, "GHPUSH00", 8); GUHash(bytes, 8, bytes + 8);
}
static int GUReadState(GSRepository *repo, GUIntent *intent, int *pending,
                        unsigned char **bytes, size_t *length) {
    unsigned char idle[28];
    int error;
    *pending = 0; *bytes = NULL; *length = 0;
    if (!repo || !repo->read || !repo->replace) return GB_BAD;
    error = repo->read(repo->context, "ghclient-push", bytes, length);
    if (error == GS_NOT_FOUND) return 0;
    if (error) return error;
    GUIdle(idle);
    if (*length == sizeof(idle) && !memcmp(*bytes, idle, sizeof(idle))) return 0;
    error = GUIntentParse(*bytes, *length, intent);
    if (!error) *pending = 1;
    return error;
}
int GUIntentRead(GSRepository *repo, GUIntent *out, int *pending) {
    GUIntent intent;
    unsigned char *bytes;
    size_t n;
    int error;
    if (!out || !pending) return GB_BAD;
    GUIntentInit(&intent); error = GUReadState(repo, &intent, pending, &bytes, &n);
    free(bytes);
    if (!error) *out = intent;
    return error;
}
int GUPrepare(GSRepository *repo, const GUIntent *intent) {
    GUIntent current;
    unsigned char *before = NULL, *after = NULL;
    size_t bn, an;
    int error, pending;
    error = GUIntentEncode(intent, &after, &an); if (error) return error;
    error = GUReadState(repo, &current, &pending, &before, &bn);
    if (!error && pending) error = GS_CONFLICT;
    if (!error) error = repo->replace(repo->context, "ghclient-push", before, bn, after, an);
    free(before); free(after); return error;
}
static int GUCurrent(GSRepository *repo, const GUIntent *intent, unsigned char **expected, size_t *length) {
    unsigned char *current = NULL;
    size_t n = 0;
    int error = GUIntentEncode(intent, expected, length);
    if (!error) error = repo->read(repo->context, "ghclient-push", &current, &n);
    if (!error && (n != *length || memcmp(current, *expected, n))) error = GS_CONFLICT;
    free(current); return error;
}
int GUClear(GSRepository *repo, const GUIntent *intent) {
    unsigned char *expected = NULL, idle[28];
    size_t n;
    int error;
    if (!repo || !repo->read || !repo->replace) return GB_BAD;
    error = GUCurrent(repo, intent, &expected, &n); GUIdle(idle);
    if (!error) error = repo->replace(repo->context, "ghclient-push", expected, n, idle, sizeof(idle));
    free(expected); return error;
}
int GURetire(GSRepository *repo, const GUIntent *intent) {
    unsigned char *expected = NULL, *history = NULL, digest[20];
    char hex[41], key[80];
    size_t n = 0, hn = 0, at;
    int error;
    if (!repo || !repo->read || !repo->replace) return GB_BAD;
    error = GUCurrent(repo, intent, &expected, &n);
    if (error) goto done;
    GUHash(expected, n, digest); GBOIDFormat(digest, hex);
    strcpy(key, "ghclient-push-history/"); at = strlen(key);
    memcpy(key + at, hex, 2); at += 2; key[at++] = '/';
    memcpy(key + at, hex + 2, 12); at += 12; key[at++] = '/';
    strcpy(key + at, hex + 14);
    error = repo->read(repo->context, key, &history, &hn);
    if (error == GS_NOT_FOUND) { free(history); history = NULL; hn = 0; error = 0; }
    else if (!error && (hn != n || memcmp(history, expected, n))) error = GS_CONFLICT;
    /* Rewriting an existing matching snapshot obtains a fresh durability
       guarantee, including after a previous write returned an uncertain error. */
    if (!error) error = repo->replace(repo->context, key, history, hn, expected, n);
    if (!error) error = GUClear(repo, intent);
done:
    free(history); free(expected); return error;
}
int GUAcknowledge(GSRepository *repo, const GUIntent *intent) {
    unsigned char *expected = NULL, current[20];
    size_t n;
    char tracking[1100];
    int error, have = 0;
    if (!repo || !repo->read || !repo->replace) return GB_BAD;
    error = GUCurrent(repo, intent, &expected, &n); free(expected);
    if (error) return error;
    strcpy(tracking, "refs/remotes/origin/"); strcat(tracking, intent->branch + 11);
    error = GSReadRef(repo, tracking, current);
    if (!error) have = 1;
    else if (error == GS_NOT_FOUND) error = 0;
    if (error) return error;
    if (!have || memcmp(current, intent->newTip, 20)) {
        if (have != intent->haveTracking || (have && memcmp(current, intent->trackingTip, 20))) return GS_CONFLICT;
        error = GSUpdateRef(repo, tracking, have ? current : NULL, intent->newTip);
        if (error) return error;
    }
    return GUClear(repo, intent);
}
int GUReconcile(const GUIntent *intent, const GNAdvertisement *a, int *state) {
    const GNRef *ref;
    unsigned char zero[20];
    const unsigned char *current;
    if (!state) return GB_BAD;
    *state = GU_REMOTE_CHANGED;
    if (!a || !GUIntentValid(intent)) return GB_BAD;
    memset(zero, 0, sizeof(zero)); ref = GNFind(a, intent->branch); current = ref ? ref->oid : zero;
    *state = !memcmp(current, intent->newTip, 20) ? GU_REMOTE_ACCEPTED :
             !memcmp(current, intent->oldTip, 20) ? GU_REMOTE_RETRY : GU_REMOTE_CHANGED;
    return 0;
}
static int GUHeadMatches(GSRepository *repo, const GUIntent *intent) {
    char *branch = NULL;
    unsigned char tip[20];
    int error = GSHead(repo, &branch, tip);
    if (!error && (strcmp(branch, GULocalBranch(intent)) || memcmp(tip, intent->newTip, 20))) error = GS_CONFLICT;
    free(branch); return error;
}
static int GUExecuteNames(const GUFileIO *file, GSRepository *repo, const char *repository, const char *localBranch, const char *branch, int version,
                 const char *accountID, const unsigned char tip[20], const unsigned char expectedRemote[20],
                 const GVLimits *limits, size_t maximum, const GUCallbacks *calls, GUPushResult *out) {
    GUIntent intent, saved;
    GNAdvertisement a;
    GNPushStatus status;
    GVResult graph;
    const GNRef *ref;
    unsigned char *wire = NULL, *command = NULL, *pack = NULL, *grown,zero[20],lease[20];
    size_t n = 0, cn = 0, pn = 0;
    char tracking[1100];
    int error = 0, pending = 0, state, found, readError, fileStarted = 0, closed;
    if (!out) return GB_BAD;
    memset(out, 0, sizeof(*out));
    if (!repo || !repository || !localBranch || !branch || !accountID || !tip || !limits || !calls ||
        !calls->exchange || !calls->bind || strlen(repository) > 254 ||
        strlen(branch) > 1024 || strlen(localBranch) > 1024 || !GSValidRef(localBranch) || strlen(accountID) > 31) return GB_BAD;
    if (file && (!file->begin || !file->read || !file->write || !file->post || !file->end)) return GB_BAD;
    GUIntentInit(&intent); GUIntentInit(&saved); GNInit(&a);memset(zero,0,sizeof(zero));
    strcpy(intent.repository, repository); strcpy(intent.branch, branch); strcpy(intent.accountID, accountID);
    intent.version = version;
    if (version >= 2) strcpy(intent.localBranch, localBranch);
    memcpy(intent.newTip, tip, 20);
    if(version==3){if(!expectedRemote || !memcmp(expectedRemote,zero,20)){error=GB_BAD;goto done;}memcpy(lease,expectedRemote,20);memcpy(intent.oldTip,lease,20);}
    if (!GUIntentFieldsValid(&intent) || !memcmp(tip,zero,20)) { error = GB_BAD; goto done; }
    error = GUIntentRead(repo, &saved, &pending);
    if (error) { out->pending = 1; goto done; }
    out->pending = pending;
    if (pending) {
        if (strcmp(saved.repository, repository) || strcmp(saved.branch, branch) || strcmp(GULocalBranch(&saved), localBranch) ||
            strcmp(saved.accountID, accountID)) { error = GS_CONFLICT; goto done; }
        if(version==3 && (saved.version!=3 || memcmp(saved.oldTip,lease,20))){error=GS_CONFLICT;goto done;}
        intent = saved;
    }
    error = calls->bind(calls->context, &intent);
    if (!error) error = calls->exchange(calls->context, 0, repository, NULL, 0, &wire, &n);
    if (!error) error = GNReceiveDiscover(wire, n, 16384, &a);
    free(wire); wire = NULL;
    if (!error) error = calls->bind(calls->context, &intent);
    if (error) goto done;
    if (pending) {
        error = GUReconcile(&intent, &a, &state);
        if (error) goto done;
        if (state == GU_REMOTE_ACCEPTED) {
            out->remoteAccepted = 1; out->outcome = GU_PUSH_ACCEPTED;
            error = calls->bind(calls->context, &intent);
            if (!error) error = GUAcknowledge(repo, &intent);
            goto done;
        }
        if (state == GU_REMOTE_CHANGED) { out->outcome = GU_PUSH_REMOTE_CHANGED; goto done; }
        if (memcmp(intent.newTip, tip, 20) || GUHeadMatches(repo, &intent)) {
            out->outcome = GU_PUSH_LOCAL_CHANGED; goto done;
        }
        if (!calls->retry || !calls->retry(calls->context, &intent)) {
            out->outcome = GU_PUSH_RETRY_CANCELLED; goto done;
        }
    } else {
        ref = GNFind(&a, branch);
        if(version==3 && (!ref || memcmp(ref->oid,lease,20))){out->outcome=GU_PUSH_LEASE_CHANGED;goto done;}
        if (ref && !memcmp(ref->oid, tip, 20)) { out->outcome = GU_PUSH_CURRENT; goto done; }
        if (ref) {
            memcpy(intent.oldTip, ref->oid, 20);
            if(version!=3) {
                error = GVIsAncestor(repo, ref->oid, tip, limits, calls->progress, calls->context, &found);
                if (error) goto done;
                if (!found) { out->outcome = GU_PUSH_DIVERGED; goto done; }
            }
        }
        strcpy(tracking, "refs/remotes/origin/"); strcat(tracking, branch + 11);
        error = GSReadRef(repo, tracking, intent.trackingTip);
        if (!error) intent.haveTracking = 1;
        else if (error == GS_NOT_FOUND) error = 0;
        if (error) goto done;
    }
    if (file) {
        error = file->begin(file->context);
        if (!error) {
            fileStarted = 1;
            error = GUPackWriteSince(repo, intent.newTip, intent.version==3?NULL:intent.oldTip, limits, maximum, calls->progress, calls->context, file, &pn, &graph);
        }
    } else error = GUPackBuildSince(repo, intent.newTip, intent.version==3?NULL:intent.oldTip, limits, maximum, calls->progress, calls->context,
                         &pack, &pn, &graph);
    if (!error) error = GNPushCommand(&a, branch, intent.oldTip, intent.newTip, &command, &cn);
    if (error) goto done;
    if (pn > (size_t)-1 - cn) { error = GB_SPACE; goto done; }
    if (!file) {
    grown = (unsigned char *)realloc(command, cn + pn);
    if (!grown) { error = GB_MEMORY; goto done; } command = grown;
    memcpy(command + cn, pack, pn); free(pack); pack = NULL;
    }
    out->packBytes = pn; out->objects = graph.objects;
    error = calls->bind(calls->context, &intent);
    if (!error) error = GUHeadMatches(repo, &intent);
    if (!error && calls->progress) error = calls->progress(calls->context, graph.objects);
    if (error) goto done;
    if (!pending) {
        out->pending = 1; /* A failed durable write may still have persisted. */
        error = GUPrepare(repo, &intent);
        if (error) goto done;
    }
    error = calls->bind(calls->context, &intent);
    if (!error) error = GUHeadMatches(repo, &intent);
    if (!error) {
        if (file) error = file->post(file->context, repository, command, cn, pn, &wire, &n);
        else error = calls->exchange(calls->context, 1, repository, command, cn + pn, &wire, &n);
    }
    if (error) goto done;
    error = GNPushResponse(wire, n, a.sideBand, branch, &status);
    if (!error) {
        out->remoteAccepted = 1; out->outcome = GU_PUSH_ACCEPTED;
        error = calls->bind(calls->context, &intent);
        if (!error) error = GUAcknowledge(repo, &intent);
    } else if (error == GN_REMOTE_ERROR && status.reason[0]) {
        out->outcome = GU_PUSH_REJECTED; strcpy(out->reason, status.reason);
        /* A retry rejection cannot settle the earlier uncertain POST: that
           request might have won the remote ref lock just before this one.
           Keep the intent for fresh reconciliation, rather than declaring the
           original upload rejected from only this retry's report. */
        error = pending ? 0 : GUClear(repo, &intent);
    }
done:
    if (fileStarted) { closed = file->end(file->context); if (!error) error = closed; }
    free(wire); free(command); free(pack); GNFree(&a);
    if (repo && repo->read && repo->replace) {
        readError = GUIntentRead(repo, &saved, &pending);
        if (!readError) out->pending = pending;
        else { out->pending = 1; if (!error) error = readError; }
    }
    return error;
}
int GUExecute(GSRepository *repo, const char *repository, const char *branch,
                 const char *accountID, const unsigned char tip[20],
                 const GVLimits *limits, size_t maximum, const GUCallbacks *calls, GUPushResult *out) {
    return GUExecuteNames(NULL, repo, repository, branch, branch, 1, accountID, tip, NULL, limits, maximum, calls, out);
}
int GUExecuteTo(GSRepository *repo, const char *repository, const char *localBranch, const char *remoteBranch,
                 const char *accountID, const unsigned char tip[20],
                 const GVLimits *limits, size_t maximum, const GUCallbacks *calls, GUPushResult *out) {
    return GUExecuteNames(NULL, repo, repository, localBranch, remoteBranch, 2, accountID, tip, NULL, limits, maximum, calls, out);
}
int GUExecuteWithLeaseTo(GSRepository *repo,const char *repository,const char *localBranch,const char *remoteBranch,
                 const char *accountID,const unsigned char tip[20],const unsigned char expectedRemote[20],
                 const GVLimits *limits,size_t maximum,const GUCallbacks *calls,GUPushResult *out) {
    return GUExecuteNames(NULL, repo,repository,localBranch,remoteBranch,3,accountID,tip,expectedRemote,limits,maximum,calls,out);
}

int GUExecuteFileTo(GSRepository *repo, const char *repository, const char *localBranch,
                    const char *remoteBranch, const char *accountID, const unsigned char tip[20],
                    const unsigned char *expectedRemote, const GVLimits *limits, size_t maximum,
                    const GUCallbacks *calls, const GUFileIO *file, GUPushResult *out) {
    if (!file) return GB_BAD;
    return GUExecuteNames(file, repo, repository, localBranch, remoteBranch, expectedRemote ? 3 : 2,
                          accountID, tip, expectedRemote, limits, maximum, calls, out);
}
