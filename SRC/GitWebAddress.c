#include "GitWebAddress.h"
#include "GHCore.h"
#include <stdlib.h>
#include <string.h>

static int GLRef(const char *ref) {return ref && strlen(ref)<=1024 && GSValidRef(ref);}
static char *GLEncode(const char *ref) {
    size_t n=3*strlen(ref+11)+1;char *encoded=(char *)malloc(n);
    if(encoded && GHURLEncode(ref+11,encoded,n)){free(encoded);encoded=NULL;}return encoded;
}
int GLAddress(const char *repository,const char *base,const char *head,int kind,char **out) {
    const char *prefix="https://github.com/",*path,*query="";char *left=NULL,*right=NULL,*url,*at;size_t n;
    if(!out || *out || !repository || strlen(repository)>254 || !GHValidRepository(repository) || kind<GL_REPOSITORY || kind>GL_PULL_REQUEST)return GB_BAD;
    if((kind==GL_BRANCH || kind>=GL_COMPARE) && !GLRef(head))return GB_BAD;
    if(kind>=GL_COMPARE && !GLRef(base))return GB_BAD;
    path=kind==GL_REPOSITORY?"":kind==GL_ISSUE?"/issues/new":kind==GL_BRANCH?"/tree/":"/compare/";
    if(kind==GL_PULL_REQUEST)query="?quick_pull=1";
    if(kind>=GL_COMPARE){left=GLEncode(base);if(!left)return GB_MEMORY;}
    if(kind>=GL_BRANCH){right=GLEncode(head);if(!right){free(left);return GB_MEMORY;}}
    n=strlen(prefix)+strlen(repository)+strlen(path)+strlen(query)+1;
    if(left)n+=strlen(left)+3;if(right)n+=strlen(right);url=(char *)malloc(n);
    if(!url){free(left);free(right);return GB_MEMORY;}
    at=url;memcpy(at,prefix,strlen(prefix));at+=strlen(prefix);memcpy(at,repository,strlen(repository));at+=strlen(repository);
    memcpy(at,path,strlen(path));at+=strlen(path);
    if(left){memcpy(at,left,strlen(left));at+=strlen(left);memcpy(at,"...",3);at+=3;}
    if(right){memcpy(at,right,strlen(right));at+=strlen(right);}memcpy(at,query,strlen(query)+1);
    free(left);free(right);*out=url;return 0;
}
