#include "GitGraph.h"
#include "GitHistory.h"
#include "GitIndex.h"
#include <stdlib.h>
#include <string.h>

typedef struct { unsigned char oid[20]; char kind; } GVNode;
typedef struct {
    GVNode *nodes;
    size_t count, capacity, maximum, slots, *map;
} GVQueue;
static size_t GVHash(const unsigned char *id, size_t mask) {
    size_t i;
    GBWord h = 2166136261U;
    for (i = 0; i < 20; ++i) h = (h ^ id[i]) * 16777619U;
    return (size_t)h & mask;
}
static int GVAdd(GVQueue *q, const unsigned char *id, char kind) {
    size_t at = GVHash(id, q->slots - 1), capacity, i;
    GVNode *grown;
    for (i = 0; i < 20 && !id[i]; ++i) { }
    if (i == 20) return GS_FORMAT;
    while (q->map[at]) {
        i = q->map[at] - 1;
        if (!memcmp(q->nodes[i].oid, id, 20)) return q->nodes[i].kind == kind ? 0 : GS_FORMAT;
        at = (at + 1) & (q->slots - 1);
    }
    if (q->count == q->maximum) return GB_SPACE;
    if (q->count == q->capacity) {
        capacity = q->capacity ? q->capacity * 2 : 16;
        if (capacity < q->capacity || capacity > q->maximum) capacity = q->maximum;
        grown = (GVNode *)realloc(q->nodes, capacity * sizeof(GVNode));
        if (!grown) return GB_MEMORY;
        q->nodes = grown; q->capacity = capacity;
    }
    memcpy(q->nodes[q->count].oid, id, 20); q->nodes[q->count].kind = kind;
    q->map[at] = ++q->count;
    return 0;
}
static int GVCommit(GVQueue *q, const unsigned char *p, size_t n, int trees) {
    GHCommitInfo info;
    size_t at, end;
    char hex[41];
    unsigned char oid[20];
    int error = GHCommitParse(p, n, &info);
    if (error) return error;
    if (trees) error = GVAdd(q, info.tree, 't');
    at = 46; /* GHCommitParse checked the complete first tree line. */
    while (!error && at < info.messageOffset - 1) {
        end = at;
        while (end < info.messageOffset && p[end] != '\n') ++end;
        if (end - at >= 7 && !memcmp(p + at, "parent ", 7)) {
            memcpy(hex, p + at + 7, 40); hex[40] = 0;
            error = GBOIDParse(hex, oid);
            if (!error) error = GVAdd(q, oid, 'c');
        }
        at = end + 1;
    }
    return error;
}
static int GVTree(GVQueue *q, const unsigned char *p, size_t n, GVResult *result) {
    size_t at = 0, modeAt, nameAt, nameLength, priorAt = 0, priorLength = 0, common, i;
    int isTree, wasTree = 0, order, a, b, error;
    char kind, *name;
    while (at < n) {
        modeAt = at;
        while (at < n && p[at] != ' ') ++at;
        if (at == n) return GS_FORMAT;
        isTree = at - modeAt == 5 && !memcmp(p + modeAt, "40000", 5);
        if (isTree) kind = 't';
        else if (at - modeAt == 6 && (!memcmp(p + modeAt, "100644", 6) ||
                 !memcmp(p + modeAt, "100755", 6) || !memcmp(p + modeAt, "120000", 6))) kind = 'b';
        else if (at - modeAt == 6 && !memcmp(p + modeAt, "160000", 6)) kind = 'g';
        else return GS_FORMAT;
        nameAt = ++at;
        while (at < n && p[at]) ++at;
        nameLength = at - nameAt;
        if (!nameLength || at == n || n - at - 1 < 20 || memchr(p + nameAt, '/', nameLength)) return GS_FORMAT;
        name = (char *)malloc(nameLength + 1);
        if (!name) return GB_MEMORY;
        memcpy(name, p + nameAt, nameLength); name[nameLength] = 0;
        error = GIValidPath(name) ? 0 : GS_FORMAT; free(name);
        if (error) return error;
        if (priorLength) {
            common = priorLength < nameLength ? priorLength : nameLength;
            order = memcmp(p + priorAt, p + nameAt, common);
            if (!order) {
                if (priorLength == nameLength) return GS_FORMAT;
                a = common < priorLength ? p[priorAt + common] : wasTree ? '/' : 0;
                b = common < nameLength ? p[nameAt + common] : isTree ? '/' : 0;
                order = a - b;
            }
            if (order >= 0) return GS_FORMAT;
        }
        priorAt = nameAt; priorLength = nameLength; wasTree = isTree;
        ++at;
        if (kind == 'g') {
            for (i = 0; i < 20 && !p[at + i]; ++i) { }
            if (i == 20) return GS_FORMAT;
            ++result->gitlinks;
        } else {
            error = GVAdd(q, p + at, kind);
            if (error) return error;
        }
        at += 20;
    }
    return 0;
}
static int GVStart(GVQueue *q, const GVLimits *limits) {
    memset(q, 0, sizeof(*q));
    if (!limits || !limits->objects || limits->objects > (size_t)-1 / sizeof(GVNode)) return GB_BAD;
    q->maximum = limits->objects; q->slots = 1;
    while (q->slots < q->maximum) {
        if (q->slots > (size_t)-1 / 2) return GB_SPACE;
        q->slots *= 2;
    }
    if (q->slots > (size_t)-1 / 2 || q->slots * 2 > (size_t)-1 / sizeof(size_t)) return GB_SPACE;
    q->slots *= 2; q->map = (size_t *)calloc(q->slots, sizeof(size_t));
    return q->map ? 0 : GB_MEMORY;
}
int GVWalk(GSRepository *repo, const unsigned char tip[20], const GVLimits *limits,
             GVVisitor visitor, int (*progress)(void *, size_t), void *context, GVResult *out) {
    GVQueue q;
    GVResult result;
    size_t at, n;
    unsigned char *body = NULL;
    char type[7], kind;
    int error;
    if (!out) return GB_BAD;
    memset(out, 0, sizeof(*out)); memset(&result, 0, sizeof(result));
    if (!repo || !tip) return GB_BAD;
    error = GVStart(&q, limits);
    if (error) return error;
    error = GVAdd(&q, tip, 'c');
    for (at = 0; !error && at < q.count; ++at) {
        kind = q.nodes[at].kind;
        error = GSGetObjectLimit(repo, q.nodes[at].oid, type, &body, &n, limits->objectBytes);
        if (error) break;
        if (n > limits->readBytes - result.readBytes) { error = GB_SPACE; break; }
        result.readBytes += n;
        if (kind == 'c' && !strcmp(type, "commit")) {
            ++result.commits; error = GVCommit(&q, body, n, 1);
        } else if (kind == 't' && !strcmp(type, "tree")) {
            ++result.trees; error = GVTree(&q, body, n, &result);
        } else if (kind == 'b' && !strcmp(type, "blob")) ++result.blobs;
        else error = GS_FORMAT;
        if (!error && visitor) error = visitor(context, q.nodes[at].oid, type, body, n);
        free(body); body = NULL;
        if (!error) {
            ++result.objects;
            if (progress) error = progress(context, result.objects);
        }
    }
    free(body); free(q.nodes); free(q.map); *out = result;
    return error;
}
int GVVerify(GSRepository *repo, const unsigned char tip[20], const GVLimits *limits,
             int (*progress)(void *, size_t), void *context, GVResult *out) {
    return GVWalk(repo, tip, limits, NULL, progress, context, out);
}
int GVIsAncestor(GSRepository *repo, const unsigned char ancestor[20],
                  const unsigned char descendant[20], const GVLimits *limits,
                  int (*progress)(void *, size_t), void *context, int *found) {
    GVQueue q;
    size_t at, n, readBytes = 0, i;
    unsigned char *body = NULL;
    char type[7];
    int error, yes = 0;
    if (!found) return GB_BAD;
    *found = 0;
    if (!repo || !ancestor || !descendant) return GB_BAD;
    for (i = 0; i < 20 && !ancestor[i]; ++i) { }
    if (i == 20) return GB_BAD;
    error = GVStart(&q, limits);
    if (error) return error;
    error = GVAdd(&q, descendant, 'c');
    for (at = 0; !error && at < q.count; ++at) {
        error = GSGetObjectLimit(repo, q.nodes[at].oid, type, &body, &n, limits->objectBytes);
        if (error) break;
        if (n > limits->readBytes - readBytes) { error = GB_SPACE; break; }
        readBytes += n;
        if (strcmp(type, "commit")) error = GS_FORMAT;
        else {
            /* GVCommit can grow q.nodes, so compare before appending parents. */
            if (!memcmp(q.nodes[at].oid, ancestor, 20)) yes = 1;
            error = GVCommit(&q, body, n, 0);
        }
        free(body); body = NULL;
        if (!error && progress) error = progress(context, at + 1);
    }
    free(body); free(q.nodes); free(q.map);
    if (!error) *found = yes;
    return error;
}
