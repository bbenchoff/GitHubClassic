/* GitHub Classic: native Toolbox UI. Portable modules are included for the CW4 template. */
#include <Types.h>
#include <Quickdraw.h>
#include <Fonts.h>
#include <Events.h>
#include <Windows.h>
#include <Controls.h>
#include <Dialogs.h>
#include <Menus.h>
#include <TextEdit.h>
#include <Memory.h>
#include <Resources.h>
#include <Icons.h>
#include <OSUtils.h>
#include <Scrap.h>
#include <AppleEvents.h>
#include <Lists.h>
#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include "SSLWrapper.h"
#include "platform_util.h"
#include "base64.h"
#include "GHCore.c"
#include "GHRemoteCache.c"
#include "GHAuth.c"
#include "GHVault.c"
#include "GHCredentialRecord.c"
#include "GHStartupVault.c"
#include "GHVaultMac.c"
#include "OAuthConfig.h"
#include "GitBytes.c"
#include "GHRecent.c"
#include "GitStore.c"
#include "GitPack.c"
#include "GitSmart.c"
#include "GitMac.c"
#include "GitIndex.c"
#include "GitPathMap.c"
#include "GitIgnore.c"
#include "GitWorkMac.c"
#include "GitHistory.c"
#include "GitGraph.c"
#include "GitPush.c"
#include "GitUpstream.c"
#include "GitDefaultBranch.c"
#include "GitWebAddress.c"
#include "GitDiff.c"
#include "GitTextMerge.c"
#include "GitFileMerge.c"
#include "GitPreview.c"
#include "GitRestore.c"
#include "GitObjectRead.c"
#include "GitCommitDiff.c"
#include "GitBranchCompare.c"
#include "GitTreeMerge.c"
#include "GitPullPreview.c"
#include "GitRebasePlan.c"
#include "GitRebaseCommit.c"
#include "GitRebaseStep.c"
#include "GitRebasePublish.c"
#include "GitRebaseReplay.c"
#include "GitRebaseCheckout.c"
#include "DiffViewport.c"
#include "GitRestoreMac.c"
#include "GitCheckout.c"
#include "GitCheckoutSession.c"
#include "GitBranchEdit.c"
#include "GitCheckoutPlan.c"
#include "GitWorkspaceSave.c"
#include "GitStashLog.c"
#include "GitStashPlan.c"
#include "GitStashDrop.c"
#include "GitWorkspaceRestore.c"
#include "GitWorkspaceRestorePlan.c"
#include "GitStashApply.c"
#include "GitStashApplyPlan.c"
#include "GitMergePlan.c"
#include "GitMergeSession.c"
#include "GitMergeWorkspace.c"
#include "GitRebaseResolve.c"
#include "GitRebaseState.c"
#include "GitRebaseProof.c"
#include "GitRebaseVerify.c"
#include "GitRebaseCheckpoint.c"
#include "GitRebaseLifecycle.c"
#include "GitFileMac.c"
#include "GitText.c"
#include "GitEditMac.c"
#include "GitIgnoreEditMac.c"
#include "GitCheckoutMac.c"
#include "GitRebaseWorkspaceMac.c"
#include "GHWindowLayout.c"

static WindowPtr gWindow;
/* The baseline window fits a 640x480 desktop, using readable native fonts. */
static GHWindowLayout gUI;
static int gMonochrome;
static IconSuiteRef gMonoIcons[11];
static int DisplayHasColor(void) {
    GDHandle device=GetMainDevice();
    return device && (*(*device)->gdPMap)->pixelSize>1;
}
static void DisplayLayout(void) {
    GHLayout(&gUI,620,420);
    gMonochrome=!DisplayHasColor();
}
static short RightEdge(short x) {return (short)(x+gUI.width-800);}
static short BottomEdge(short y) {return (short)(y+gUI.height-500);}
static short PaneCenter(void) {return (short)(518+(gUI.width-800)/2);}
static short WelcomeY(short y) {return (short)(y+(gUI.height-420)/2);}
static void WindowChrome(void);
static void WindowResize(Point);
static void WindowZoom(Point,short);
static void WindowRemember(void);
static void WindowRestore(void);
static void WindowRelayout(void);
static Rect WindowBounds(void);
static Rect WindowAvailable(const Rect *);
static Rect WindowDialogAvailable(DialogPtr,const Rect *);
static Rect WindowConstrain(Rect,const Rect *,short,short);
static void WindowCheckDisplay(void);
static void ShowWorkspace(void);
static void CloseWorkspace(void);
static void FitDialogToScreen(DialogPtr dialog) {
    GrafPtr saved;Rect anchor,screen,content=((WindowPtr)dialog)->portRect;
    short width=(short)(content.right-content.left),height=(short)(content.bottom-content.top),x,y;
    GetPort(&saved);anchor=gWindow?WindowBounds():qd.screenBits.bounds;screen=WindowDialogAvailable(dialog,&anchor);
    x=(short)(screen.left+(screen.right-screen.left-width)/2);
    y=(short)(screen.top+(screen.bottom-screen.top-height)/3);
    SetRect(&content,x,y,(short)(x+width),(short)(y+height));content=WindowConstrain(content,&screen,width,height);
    MoveWindow((WindowPtr)dialog,content.left,content.top,false);SetPort(saved);
}
static void KeepDialogOnScreen(DialogPtr dialog) {
    GrafPtr saved;Rect content=((WindowPtr)dialog)->portRect,available,next;Point p;
    GetPort(&saved);SetPort((GrafPtr)dialog);p.h=content.left;p.v=content.top;LocalToGlobal(&p);
    OffsetRect(&content,p.h-content.left,p.v-content.top);available=WindowDialogAvailable(dialog,&content);
    next=WindowConstrain(content,&available,(short)(content.right-content.left),(short)(content.bottom-content.top));
    if(next.left!=content.left || next.top!=content.top)MoveWindow((WindowPtr)dialog,next.left,next.top,false);
    SetPort(saved);
}
static ModalFilterUPP gDialogFilter;
static ControlHandle gSignIn,gFetch,gCommit,gBrowse,gDiffScroll,gDiffHorizontal;
static SSLState gTLS;
static InetSvcRef gInternet=kOTInvalidProviderRef;
static int gOT=0,gDone=0,gBusy=0,gCancel=0,gTab=0,gModalDepth=0;
static char gStatus[256]="Ready. Sign in, or test the GitHub connection from the Help menu.";
static OACredentials gCredentials;
static RCCache gRemoteCache;
static unsigned long gHTTPAttempts;
static unsigned long gHTTPHandshakes,gHTTPReuseAttempts,gHTTPReconnectRetries;
static unsigned long gHTTPWarmSerial,gHTTPWarmTick;
static unsigned long gGitHTTPAttempts,gGitHandshakes,gGitReuseAttempts,gGitReconnectRetries;
static unsigned long gGitFetchHaveCount,gGitFetchPackBytes,gGitFetchImportedObjects;
#define gToken gCredentials.access
#define gUser gCredentials.login
static char gPendingToken[8192],gRemote[256],gBranch[256];
static int gPendingTokenSelected;
static char gOAuthClient[129]=GH_OAUTH_CLIENT_ID;
static DialogPtr gDeviceDialog;
static unsigned long gAuthTick,gAuthSeconds,gAuthRemainder;
static int RefreshCredentials(void);
static void AuthInstall(const OACredentials *);
static void ClearSession(void);
static void VaultResetMemory(void);
static int VaultForgetRemembered(void);
static void VaultAfterRotation(void);
static void VaultSaveCredentials(void);
static void VaultUnlockCredentials(void);
static int StartupInitializeTLS(void);
static int StartupPrepare(unsigned char **,size_t *,const unsigned char [32],const char *);
static int StartupWrap(const void *,size_t,unsigned char **,size_t *);
static int StartupSaveCredentials(const void *,size_t,const char *,const unsigned char *,size_t,int,unsigned char **,size_t *);
static int StartupReadConfirmed(unsigned char **,size_t *);
static int StartupClearCredentials(const unsigned char *,size_t,int);
static int StartupHasCredentials(const void *,size_t,int *);
static void StartupShutdown(void);
static void StartupKeepUnlocked(void);
static int StartupRekeyPassword(const void *,size_t,const char *,unsigned char **,size_t *);
static int StartupCopyPassword(char [1025]);
static int StartupChooseProvisionFile(FSSpec *);
static void RecentRemember(const FSSpec *);
static void RecentRepositories(void);
static void RecentRemoveCurrent(void);
static void EUIRebaseLimits(RQLimits *);
static void ERLimits(RLLimits *);
static int MUIVersion(GSRepository *,const GRSnapshot *,size_t,TMOutput *,GRContents *);
static char gDetail[256]="Connect your GitHub account to browse your repositories.";
static short gChicago,gGeneva,gMonaco;
static CIconHandle gWelcomeIcon;
#define GH_REPOSITORY_PAGE 50
static GHRepository gRepos[GH_REPOSITORY_PAGE];
static GHRevision gRevisions[GH_HISTORY_CAPACITY];
static GHChange gChanges[100];
static int gRepoCount,gRepoPage=1,gHistoryPage=1,gRevisionCount,gChangeCount,gRevisionIndex=-1,gFileIndex=-1,gFilePage=1;
static int gHistoryOffset,gLocalHistoryOffset;
static char *gCommitJSON;
static size_t gCommitLength;
static char gPatch[32000];
static int gDiffTop,gDiffLines,gPatchTruncated;
static unsigned long gDiffLeft,gDiffColumns;
static short gDiffVisibleColumns=1;
static GWWorkspace gWork;
static int gLocal=0,gLocalSelection=-1,gLocalPage=0,gCommitField=0;
static int gLocalBlocked=0;
static int gLocalDiffMode=1;
static size_t *gLocalRows,gLocalRowCount,gLocalStaged;
static TEHandle gSummaryEdit,gDescriptionEdit;
static char gLocalIdentity[256];
static char gOriginName[256],gOriginBranch[1025];
static char gUpstreamText[256];
static void NetworkFetch(void);
static void NetworkPull(void);
static void NetworkPush(void);
static void NetworkForcePush(void);
static void NetworkReviewPush(void);
static void NetworkPushCheck(void);
static void NetworkClone(void);
static void NetworkHeader(void);
static int NetworkUpstream(void);
static void LocalDraw(void);
static void LocalOpen(void);
static void LocalRefresh(void);
static int MergeManage(const FSSpec *);
static int RebaseManage(const FSSpec *);
static void RebasePaused(void);
static void MergeCommand(void);
static void SquashCommand(void);
static void RebaseCommand(void);
static void UpdateDefaultCommand(void);
static void FetchDefaultCommand(void);
static void PullPreviewCommand(void);
static void LocalGitHubAddress(short command);
static void MergePaused(void);
static int gMergePending;
static int gRebasePending;
static void LocalToggle(void);
static void LocalToggleAll(void);
static void LocalSelect(int);
static void LocalCommit(void);
static void LocalClose(void);
static int SettingsRelease(void);
static void RepositorySettings(void);
static void LocalEditState(void);
static void LocalEditMenu(short);
static void LocalOpenMode(int);
static void EditReset(void);
static void EditCapture(void);
static int LocalMatches(const char *);
static int LocalFiltered(void);
static void LocalFilterReset(void);
static void FindReset(void);
static void DiffScroll(void);
static void LocalHistoryLoad(void);
static void LocalHistorySelect(int);
static void LocalHistoryRows(void);
static void LocalHistoryReset(void);
static void LocalHistoryMessage(void);
static void LocalHistoryChooseFile(void);
static void LocalHistoryHeader(void);
static int LocalHistoryHasNext(void);
static int BCUIActive(void);
static void BCUIReset(void);
static void BCUIDrawToolbar(void);
static void BCUIDrawRows(void);
static void BCUIDrawHeader(void);
static void BCUIMode(int);
static void BCUIDirection(unsigned);
static void BCUIPage(int);
static void BCUISelect(int);
static void CompareBranch(void);
static void UpdateMenus(void);
static void PrepareDialog(DialogPtr,short,short);
static int PrepareDialogChrome(DialogPtr,short,short);
static void Message(const char *,const char *);
static void DialogText(DialogPtr,short,const char *);
static int PrepareDialogChrome(DialogPtr,short,short);
static void CheckoutSwitch(void);
static int CheckoutRelease(void);
static int CheckoutRecovery(const FSSpec *);
static void CheckoutButtonTitle(DialogPtr,short,const char *);
static void CheckoutEnable(DialogPtr,short,int);
static pascal Boolean NativeDialogFilter(DialogPtr,EventRecord *,short *);
static int gDiffSize=9;
static short DiffVisibleRows(void) {
    return (short)((BottomEdge(451)-18-172)/(gDiffSize+4)+1);
}
static void HideDiffControls(void) {HideControl(gDiffScroll);HideControl(gDiffHorizontal);}
static void ShowDiffControls(void) {ShowControl(gDiffScroll);ShowControl(gDiffHorizontal);}
static int gLocalHistoryCount,gLocalHistoryPage=1,gLocalHistorySelection;
static void SignIn(void);
static void ChooseRepository(void);
static int LoadHistory(void);
static void RemoteHistoryPage(int);
static void ChooseFile(void);
static void LoadCommit(int index,int page);
static void Event(EventRecord *event);
static void Draw(void);
static void Pascal(const char *s,Str255 p) {
    size_t n=strlen(s);if(n>255)n=255;p[0]=(unsigned char)n;BlockMoveData(s,p+1,n);
}
static int CopyTextSelection(TEHandle edit) {
    Handle text = (*edit)->hText;
    short start = (*edit)->selStart, length = (*edit)->selEnd - start;
    OSErr error;
    /* Export the exact selected bytes to a cleared desk scrap. Avoid a second
       allocation/private TextEdit scrap; PutScrap may move unlocked Handles.
       A Cut deletes its selection only after this export succeeds. */
    if (length <= 0) { SysBeep(1); return 0; }
    error = ZeroScrap();
    if (!error) {
        HLock(text); error = PutScrap((long)length, 'TEXT', *text + start); HUnlock(text);
    }
    if (error) { SysBeep(1); return 0; }
    return 1;
}
static void RunModalDialog(ModalFilterUPP filter,short *item) {
    ++gModalDepth;ModalDialog(filter,item);--gModalDepth;
}
static void PrepareDialog(DialogPtr d,short defaultItem,short cancelItem) {
    FitDialogToScreen(d);
    SetDialogDefaultItem(d,defaultItem);
    SetDialogCancelItem(d,cancelItem);
    SetDialogTracksCursor(d,true);
    SetWRefCon((WindowPtr)d,0x47480000L|((long)defaultItem<<8)|cancelItem);
}
static pascal Boolean NativeDialogFilter(DialogPtr d,EventRecord *event,short *item) {
    char key;
    GrafPtr saved;
    EventRecord pending;
    long tag=GetWRefCon((WindowPtr)d);
    if(event->what==nullEvent)KeepDialogOnScreen(d);
    /* The classic nonmovable ModalDialog loop can mask high-level events.
       Poll only that queue on idle; never run ordinary commands or deferred
       repository opening while a dialog owns the UI. Quit must still cancel. */
    if(event->what==nullEvent && GetNextEvent(highLevelEventMask,&pending)) {
        GetPort(&saved);AEProcessAppleEvent(&pending);SetPort(saved);
        if(gDone && (tag&0xffff0000UL)==0x47480000UL){*item=(short)(tag&255);return true;}
    }
    if(event->what==kHighLevelEvent) {
        AEProcessAppleEvent(event);
        if(gDone && (tag&0xffff0000UL)==0x47480000UL){*item=(short)(tag&255);return true;}
        return false;
    }
    if(event->what==updateEvt && (WindowPtr)event->message==gWindow) {
        GetPort(&saved);Event(event);SetPort(saved);return false;
    }
    if(event->what==keyDown && (event->modifiers&cmdKey)) {
        key=(char)(event->message&charCodeMask);
        if((tag&0xffff8000UL)==0x47488000UL && key=='c'){*item=2;return true;}
        if(((DialogPeek)d)->editField>=0) {
            if(key=='x'){DialogCut(d);return true;}
            if(key=='c'){DialogCopy(d);return true;}
            if(key=='v'){DialogPaste(d);return true;}
            if(key=='a'){SelectDialogItemText(d,((DialogPeek)d)->editField+1,0,32767);return true;}
        }
    }
    return StdFilterProc(d,event,item);
}
static void Color(unsigned short r,unsigned short g,unsigned short b) {
    RGBColor c;
    if(gMonochrome) {ForeColor((r*30UL+g*59UL+b*11UL)>12800UL?whiteColor:blackColor);return;}
    c.red=r*257;c.green=g*257;c.blue=b*257;RGBForeColor(&c);
}
static void Box(short l,short t,short r,short b,int red,int green,int blue) {
    Rect rect;SetRect(&rect,l,t,r,b);Color(red,green,blue);PaintRect(&rect);
    /* A selected row must remain visible when its light purple fill is white. */
    if(gMonochrome && red==225 && green==217 && blue==240) {
        Color(0,0,0);FrameRect(&rect);
    }
}
static void Text(short x,short y,const char *s,short font,short size,int red,int green,int blue) {
    TextFont(font);TextSize(size);TextFace(0);Color(red,green,blue);MoveTo(x,y);DrawText(s,0,(short)strlen(s));
}
static void SetStatus(const char *s) {
    strncpy(gStatus,s,255);gStatus[255]=0;
    if(gWindow) {SetPort(gWindow);InvalRect(&gWindow->portRect);}
}
static void MonoIcon(short id,const Rect *rect) {
    short index=id==128?0:(short)(id-255);
    IconSuiteRef suite=NULL;
    if(index<0 || index>=11)return;
    if(!gMonoIcons[index]) {
        if(GetIconSuite(&suite,id,kSelectorLarge1Bit|kSelectorSmall1Bit)!=noErr) {
            if(suite)DisposeIconSuite(suite,false);
            Color(0,0,0);FrameRect(rect);return;
        }
        gMonoIcons[index]=suite;
    }
    PlotIconSuite(rect,atNone,ttNone,gMonoIcons[index]);
}
static void Icon(short id,short x,short y) {
    Rect r;SetRect(&r,x,y,x+16,y+16);Color(0,0,0);
    if(gMonochrome)MonoIcon(id,&r);else PlotIconID(&r,atNone,ttNone,id);
}
static void CenterText(short center,short y,const char *s,short font,short size) {
    TextFont(font);TextSize(size);TextFace(0);
    Text(center-TextWidth(s,0,(short)strlen(s))/2,y,s,font,size,0,0,0);
}
static void Bevel(short l,short t,short r,short b,int inset) {
    Rect rect;SetRect(&rect,l,t,r,b);Color(0,0,0);FrameRect(&rect);
    if(gMonochrome) {if(inset){InsetRect(&rect,2,2);FrameRect(&rect);}return;}
    Color(inset?128:255,inset?128:255,inset?128:255);
    MoveTo(l+1,b-2);LineTo(l+1,t+1);LineTo(r-2,t+1);
    Color(inset?255:128,inset?255:128,inset?255:128);
    MoveTo(r-2,t+2);LineTo(r-2,b-2);LineTo(l+2,b-2);
}
static void FitText(short x,short y,const char *text,short font,short size,short width,int red,int green,int blue) {
    short n=(short)strlen(text);TextFont(font);TextSize(size);TextFace(0);
    while(n>0 && TextWidth(text,0,n)>width)--n;
    Color(red,green,blue);MoveTo(x,y);DrawText(text,0,n);
}
static void DrawDiff(void) {
    Rect clip,lineClip;RgnHandle saved;const char *p=gPatch,*start;char text[256];
    int line=0,visible=0,inHunk=0,kind;short y=169,n,top,bottom,x,width,columns;
    saved=NewRgn();if(!saved)return;GetClip(saved);SetRect(&clip,251,152,RightEdge(772),BottomEdge(451)-17);ClipRect(&clip);
    Box(251,152,RightEdge(772),BottomEdge(451)-17,255,255,255);TextFont(gMonaco);TextSize(gDiffSize);TextFace(0);
    while(*p && visible<DiffVisibleRows()) {
        start=p;while(*p && *p!='\r')++p;
        if(p-start>=2 && start[0]=='@' && start[1]=='@')inHunk=1;
        kind=inHunk && (*start=='+' || *start=='-' || *start==' ') ? *start : 0;
        if(line++>=gDiffTop) {
            top=(short)(y-gDiffSize-1);bottom=(short)(y+3);
            if(gMonochrome) {
                Color(0,0,0);TextFace(*start=='@'?bold:0);
                if(kind=='+' || kind=='-') {MoveTo(254,y);DrawText(start,0,1);}
            }else if(kind=='+') {
                Box(251,top,RightEdge(772),bottom,193,237,200);Box(251,top,264,bottom,26,124,63);
                Color(255,255,255);MoveTo(254,y);DrawText(start,0,1);Color(9,78,30);
            }else if(kind=='-') {
                Box(251,top,RightEdge(772),bottom,248,194,199);Box(251,top,264,bottom,184,41,56);
                Color(255,255,255);MoveTo(254,y);DrawText(start,0,1);Color(124,18,30);
            }else if(*start=='@') {
                Box(251,top,RightEdge(772),bottom,218,202,241);Color(74,36,120);
            }else if(!inHunk && (!strncmp(start,"--- ",4) || !strncmp(start,"+++ ",4))) {
                Box(251,top,RightEdge(772),bottom,228,237,249);Color(32,72,127);
            }else Color(0,0,0);
            x=kind?269:256;
            width=CharWidth('M');if(width<1)width=1;
            columns=(short)((RightEdge(772)-x)/width);if(columns<1)columns=1;
            n=(short)DVSlice(kind?start+1:start,(size_t)(p-start)-(kind?1:0),gDiffLeft,
                             (size_t)columns,text,sizeof(text));
            lineClip=clip;lineClip.left=x;ClipRect(&lineClip);
            MoveTo(x,y);DrawText(text,0,n);SetClip(saved);ClipRect(&clip);TextFace(0);
            y+=(short)(gDiffSize+4);++visible;
        }
        if(*p)++p;
    }
    Color(0,0,0);TextFace(0);SetClip(saved);DisposeRgn(saved);
}
static void Draw(void) {
    Rect r;
    if(!DisplayHasColor())gMonochrome=1;
    if(gLocal){LocalDraw();return;}
    SetPort(gWindow);
    Box(0,0,gUI.width,gUI.height,221,221,221);
    /* Desktop's three header segments, rendered as Toolbox-era recessed fields. */
    Bevel(5,5,237,57,0);Bevel(241,5,RightEdge(577),57,0);Bevel(RightEdge(581),5,RightEdge(795),57,0);
    Icon(256,18,27);
    Text(44,22,"Current Repository:",gGeneva,9,64,64,64);
    FitText(44,43,gRemote[0]?gRemote:"Choose Repository...",gChicago,12,182,0,0,0);
    Icon(257,252,27);
    Text(278,22,"Current Branch:",gGeneva,9,64,64,64);
    FitText(278,43,gBranch[0]?gBranch:"(No repository)",gChicago,12,RightEdge(280),0,0,0);
    Icon(260,RightEdge(588),20);
    FitText(RightEdge(620),52,"Clone a repository first",gGeneva,9,170,96,96,96);
    /* Raised tabs, an inset file list, and the classic commit well. */
    Box(8,65,232,94,221,221,221);
    Bevel(8,65,119,94,gTab?0:1);Bevel(122,65,232,94,gTab?1:0);
    Icon(265,16,72);Text(38,84,"Changes",gChicago,12,0,0,0);
    Icon(264,132,72);Text(154,84,"History",gChicago,12,0,0,0);
    Box(8,98,232,gUI.listBottom,255,255,255);Bevel(7,97,233,gUI.listBottom+1,1);
    Box(10,100,230,125,238,238,238);
    Text(17,117,gTab?"History on GitHub":"Changed Files",gChicago,12,0,0,0);
    if(gTab && gRemote[0]) {
        Bevel(190,101,209,123,0);Bevel(211,101,230,123,0);
        Text(196,116,"<",gGeneva,9,0,0,0);Text(217,116,">",gGeneva,9,0,0,0);
    }
    Box(10,126,230,127,128,128,128);
    if(gTab && gRemote[0]) {
        int i;short y;char detail[160];
        for(i=0;i+gHistoryOffset<gRevisionCount && i<gUI.rows;++i) {
            y=148+i*28;
            if(i+gHistoryOffset==gRevisionIndex)Box(10,y-14,230,y+13,225,217,240);
            FitText(17,y,gRevisions[i+gHistoryOffset].summary,gGeneva,9,205,0,0,0);
            snprintf(detail,sizeof(detail),"%.7s  %.10s",gRevisions[i+gHistoryOffset].sha,gRevisions[i+gHistoryOffset].date);
            Text(17,y+11,detail,gGeneva,9,96,96,96);
        }
        if(!gRevisionCount)Text(18,151,"No remote commits loaded.",gGeneva,9,96,96,96);
    } else Text(18,151,gRemote[0]?"No local clone yet.":"No repository selected.",gGeneva,9,96,96,96);
    FitText(16,gUI.authorY,gUser[0]?gUser:"Account: Not signed in",gGeneva,9,208,64,64,64);
    Text(16,gUI.summaryLabel,"Summary:",gGeneva,9,0,0,0);
    Box(16,gUI.summaryTop,223,gUI.summaryTop+22,255,255,255);Bevel(14,gUI.summaryTop-2,225,gUI.summaryTop+24,1);
    Text(21,gUI.summaryTop+15,"Commit summary",gGeneva,9,128,128,128);
    Text(16,gUI.descriptionLabel,"Description:",gGeneva,9,0,0,0);
    Box(16,gUI.descriptionTop,223,gUI.descriptionTop+22,255,255,255);Bevel(14,gUI.descriptionTop-2,225,gUI.descriptionTop+24,1);
    /* The right pane remains the eventual diff editor, with its own title strip. */
    Box(243,67,RightEdge(792),BottomEdge(470),255,255,255);Bevel(241,65,RightEdge(794),BottomEdge(472),1);
    Box(245,69,RightEdge(790),94,238,238,238);
    Text(255,86,gRemote[0]?"Commit on GitHub":"Repository",gChicago,12,0,0,0);Box(245,95,RightEdge(790),96,128,128,128);
    if(gRemote[0] && gRevisionIndex>=0) {
        char detail[160];
        FitText(255,113,gRevisions[gRevisionIndex].summary,gChicago,12,RightEdge(525),0,0,0);
        snprintf(detail,sizeof(detail),"%.7s by %.80s - %.10s",gRevisions[gRevisionIndex].sha,gRevisions[gRevisionIndex].author,gRevisions[gRevisionIndex].date);
        FitText(255,129,detail,gGeneva,9,RightEdge(525),80,80,80);
        Bevel(251,134,RightEdge(788),151,0);
        FitText(257,146,gFileIndex>=0?gChanges[gFileIndex].filename:"No changed files",gGeneva,9,RightEdge(510),0,0,0);
        DrawDiff();
        if(!gPatch[0])FitText(265,176,"GitHub supplied no text patch for this file.",gGeneva,9,RightEdge(510),96,96,96);
        if(gPatchTruncated)Text(255,BottomEdge(464),"Patch preview truncated at 32 KB.",gGeneva,9,128,0,0);
    } else {
        SetRect(&r,PaneCenter()-32,WelcomeY(114),PaneCenter()+32,WelcomeY(178));
        if(gMonochrome)MonoIcon(128,&r);
        else if(gWelcomeIcon)PlotCIcon(&r,gWelcomeIcon);
        CenterText(PaneCenter(),WelcomeY(208),gUser[0]?"Account Connected":"Welcome to GitHub Classic",gChicago,12);
        FitText(265,WelcomeY(232),gUser[0]?gDetail:"Work with GitHub on your Macintosh.",gGeneva,9,RightEdge(510),0,0,0);
        if(!gUser[0]) {
            CenterText(PaneCenter(),WelcomeY(250),"Sign in to connect your GitHub account.",gGeneva,9);
            SetRect(&r,PaneCenter()-113,WelcomeY(273),PaneCenter()+117,WelcomeY(310));PenSize(3,3);Color(0,0,0);FrameRoundRect(&r,16,16);PenSize(1,1);
            FitText(265,WelcomeY(340),"Help > Test GitHub Connection",gGeneva,9,RightEdge(510),64,64,64);
        } else CenterText(PaneCenter(),WelcomeY(250),"Choose a repository to browse its history.",gGeneva,9);
    }
    Bevel(5,BottomEdge(479),RightEdge(779),BottomEdge(498),1);
    FitText(10,BottomEdge(492),gStatus,gGeneva,9,gUI.width-36,0,0,0);
    Color(0,0,0);TextFont(gChicago);TextSize(12);DrawControls(gWindow);WindowChrome();
}
static int PumpEvents(short sleepTicks) {
    EventRecord e;DialogPtr d;short hit;GrafPtr saved;
    if(gDeviceDialog)KeepDialogOnScreen(gDeviceDialog);
    if(WaitNextEvent(everyEvent,&e,sleepTicks,NULL)) {
        if((e.what==keyDown || e.what==autoKey) && (e.message&charCodeMask)==27) {gCancel=1;return gCancel;}
        if(gDeviceDialog && IsDialogEvent(&e)) {
            GetPort(&saved);SetPort((GrafPtr)gDeviceDialog);
            if(DialogSelect(&e,&d,&hit) && d==gDeviceDialog && hit==1)gCancel=1;
            SetPort(saved);
            return gCancel;
        }
        if(e.what==updateEvt || e.what==activateEvt || e.what==osEvt || e.what==kHighLevelEvent) Event(&e);
        else if((e.what==keyDown || e.what==autoKey) && (e.message&charCodeMask)==27) gCancel=1;
        else if(e.what==mouseDown) {
            WindowPtr w;short part=FindWindow(e.where,&w);
            if(part==inDrag) {Rect bounds=qd.screenBits.bounds;DragWindow(w,e.where,&bounds);}
        }
    }
    return gCancel;
}
static int Pump(void *context) { (void)context; return PumpEvents(1); }
static int InitializeTLS(void) {
    if(gTLS.initialized) return 0;
    return StartupInitializeTLS();
}
static void HTTPIdle(void) {
    if(gHTTPWarmSerial && !gBusy &&
       (unsigned long)(TickCount()-gHTTPWarmTick)>30UL*60UL) {
        if(gHTTPWarmSerial==gTLS.connectionSerial)SSL_Disconnect(&gTLS);
        gHTTPWarmSerial=0;
    }
}
static int RawRequest(const char *hostname,const char *path,const char *token,const char *form,
                      unsigned char **body,size_t *bodySize) {
    InetHostInfo host;InetAddress address;OSStatus osError;int error=0,status=0,n,framing=1;
    unsigned char *data;char *request;size_t used=0,length=0;unsigned long started;
    int reused=0,retried=0,reusable=0,keep=0;
    *body=NULL;*bodySize=0;
    if(!hostname || (strcmp(hostname,"api.github.com") && strcmp(hostname,"github.com")) ||
       !path || path[0]!='/' || strpbrk(path,"\r\n") ||
       (!form && strcmp(hostname,"api.github.com")) ||
       (token && (strcmp(hostname,"api.github.com") || strpbrk(token," \t\r\n"))) ||
       (form && (strcmp(hostname,"github.com") || (strcmp(path,"/login/device/code") && strcmp(path,"/login/oauth/access_token")))))return paramErr;
    ++gHTTPAttempts;gBusy=1;gCancel=0;
    data=(unsigned char*)malloc(1048577UL);request=(char*)malloc(12288);
    if(!data || !request) {error=memFullErr;goto done;}
    SetStatus(form?"Contacting GitHub authorization... Escape cancels.":"Contacting api.github.com... Escape cancels.");Pump(NULL);
    if(gCancel || gDone){error=SSL_CANCELLED;goto done;}
    if(!gOT) {osError=InitOpenTransport();if(osError) {error=osError;goto done;}gOT=1;}
    if(gInternet==kOTInvalidProviderRef) {
        gInternet=OTOpenInternetServices(kDefaultInternetServicesPath,0,&osError);
        if(osError) {error=osError;goto done;}
    }
    error=InitializeTLS();if(error) goto done;
    reused=!form && gHTTPWarmSerial && gHTTPWarmSerial==gTLS.connectionSerial &&
        (unsigned long)(TickCount()-gHTTPWarmTick)<=30UL*60UL && SSL_CanReuse(&gTLS,hostname);
    gHTTPWarmSerial=0;
again:
    if(reused)++gHTTPReuseAttempts;
    else {
        SSL_Disconnect(&gTLS);
        osError=OTInetStringToAddress(gInternet,(char*)hostname,&host);
        if(osError) {error=osError;goto done;}
        OTInitInetAddress(&address,443,host.addrs[0]);
        error=SSL_Connect(&gTLS,hostname,&address);if(error) goto done;
        ++gHTTPHandshakes;
    }
    SSL_BeginIO(&gTLS);
    if(form)n=snprintf(request,12288,"POST %s HTTP/1.1\r\nHost: github.com\r\nUser-Agent: GitHubClassic-ClassicMac/0.1\r\nAccept: application/json\r\nContent-Type: application/x-www-form-urlencoded\r\nContent-Length: %lu\r\nAccept-Encoding: identity\r\nConnection: close\r\n\r\n",path,(unsigned long)strlen(form));
    else n=snprintf(request,12288,"GET %s HTTP/1.1\r\nHost: api.github.com\r\nUser-Agent: GitHubClassic-ClassicMac/0.1\r\nAccept: application/vnd.github+json\r\nX-GitHub-Api-Version: 2022-11-28\r\nAccept-Encoding: identity\r\nConnection: keep-alive\r\n%s%s%s\r\n",
               path,token && token[0]?"Authorization: Bearer ":"",token?token:"",token && token[0]?"\r\n":"");
    if(n<0 || n>=12288) {error=paramErr;goto done;}
    error=SSL_Send(&gTLS,request,(size_t)n);
    mbedtls_platform_zeroize(request,12288);if(error) goto transportFailure;
    if(form){error=SSL_Send(&gTLS,form,strlen(form));if(error)goto done;}
    SetStatus("Receiving GitHub response... Escape cancels.");started=TickCount();
    while(framing==1) {
        if(used>=1048576UL) {error=memFullErr;goto done;}
        n=SSL_Receive(&gTLS,data+used,1048576UL-used);
        if(n<0) {error=n;goto transportFailure;}
        if(!n && !used){error=-30004;goto transportFailure;}
        used+=n;reusable=n>0 && GHHTTPReusable(data,used);
        framing=DecodeHTTP(data,used,n==0,&length,&status);
        if(framing<0 || (!n && framing)) {error=-30004;goto done;}
        if((unsigned long)(TickCount()-started)>7200UL) {error=SSL_TIMEOUT;goto done;}
    }
    if(status!=200 && !(form && status==400)) {error=status;goto done;}
    keep=!form && reusable && !gCancel && !gDone && SSL_CanReuse(&gTLS,hostname);
    /* DecodeHTTP moves the body over its headers. Erase the old body copy and
       all spare capacity before handing an OAuth response to the caller. */
    mbedtls_platform_zeroize(data+length,1048577UL-length);
    *body=data;*bodySize=length;data=NULL;
    goto done;
transportFailure:
    /* Only a read on a previously verified idle connection is replayed, once,
       before any response bytes. OAuth submissions and smart Git never enter
       this retry. Cancellation, malformed and partial responses fail closed. */
    if(reused && !retried && !used && error!=SSL_CANCELLED && !gCancel && !gDone) {
        SSL_Disconnect(&gTLS);reused=0;retried=1;error=0;
        ++gHTTPReconnectRetries;++gHTTPAttempts;goto again;
    }
done:
    if(!error && keep){gHTTPWarmSerial=gTLS.connectionSerial;gHTTPWarmTick=TickCount();}
    else {gHTTPWarmSerial=0;SSL_Disconnect(&gTLS);}
    if(request) {mbedtls_platform_zeroize(request,12288);free(request);}
    if(data){mbedtls_platform_zeroize(data,1048577UL);free(data);}gBusy=0;
    if(error) {char message[160];
        if(error==GV_CANCEL){error=SSL_CANCELLED;SetStatus("Secure network setup cancelled.");}
        else if(error==SSL_NO_SEED) SetStatus(gTLS.initialized?"Secure random request limit reached. Quit and reopen GitHub Classic.":"That setup file could not be used. Choose a fresh network setup file and try again.");
        else {snprintf(message,sizeof(message),"GitHub request failed %d (OT %ld / event %ld; crypto %lus, TLS %lus).",error,gTLS.transportError,gTLS.transportEvent,gTLS.cryptoTicks/60,gTLS.handshakeTicks/60);SetStatus(message);}
    }
    return error;
}
static unsigned long AuthNow(void) {
    unsigned long tick=TickCount(),delta=tick-gAuthTick;
    gAuthTick=tick;gAuthSeconds+=delta/60;gAuthRemainder+=delta%60;
    gAuthSeconds+=gAuthRemainder/60;gAuthRemainder%=60;return gAuthSeconds;
}
static int Request(const char *path,const char *token,unsigned char **body,size_t *bodySize) {
    int error;
    *body=NULL;*bodySize=0;
    if(token==gToken && OARefreshNeeded(&gCredentials,AuthNow())) {
        if(RefreshCredentials())return OA_BAD_RESPONSE;
    }
    error=RawRequest("api.github.com",path,token,NULL,body,bodySize);
    if(error==401 && token==gToken){ClearSession();SetStatus("GitHub authorization expired or was revoked. Sign in again.");}
    return error;
}
/* Only the remote API viewer uses this cache. Authentication and smart Git
   requests remain fresh. Local repositories never enter this path. */
static int RemoteRequest(const char *path,unsigned char **body,size_t *length) {
    int cached,error;unsigned long epoch;char owner[32];
    strcpy(owner,gCredentials.bound?gCredentials.accountID:"public");
    if(!RCBind(&gRemoteCache,owner))return Request(path,gToken,body,length);
    cached=RCGet(&gRemoteCache,path,body,length);
    if(cached)return cached<0?memFullErr:0;
    epoch=gRemoteCache.epoch;error=Request(path,gToken,body,length);
    if(!error && !gCancel && !gDone && !strcmp(gRemoteCache.owner,owner))
        (void)RCPut(&gRemoteCache,epoch,path,*body,*length);
    return error;
}
static int WriteTLSProbe(int result,int vaultResult,unsigned long vaultTicks) {
    FILE *file=fopen("TLS Probe.txt","wb");int i;unsigned long clock;
    static const char *names[]={"hello_request","client_hello","server_hello","server_certificate",
        "server_key_exchange","certificate_request","server_hello_done","client_certificate",
        "client_key_exchange","certificate_verify","client_change_cipher_spec","client_finished",
        "server_change_cipher_spec","server_finished","flush_buffers","handshake_wrapup",
        "handshake_over","new_session_ticket","hello_verify_request"};
    if(!file)return -1;
    GetDateTime(&clock);
    fprintf(file,"GHClient public TLS probe v1\nrequest=GET https://api.github.com/users/bbenchoff\n");
#if defined(__MC68K__)
    fprintf(file,"application_slice=68K\n");
#else
    fprintf(file,"application_slice=PowerPC\n");
#endif
    fprintf(file,"mac_clock_local_seconds=%lu\nticks_per_second=60\nresult=%d\n",clock,result);
    fprintf(file,"vault_known_answer_result=%d\nvault_known_answer_ticks=%lu\n",vaultResult,vaultTicks);
    fprintf(file,"crypto_ticks=%lu\nconnect_ticks=%lu\nhandshake_ticks=%lu\n",gTLS.cryptoTicks,gTLS.connectTicks,gTLS.handshakeTicks);
    fprintf(file,"http_attempts=%lu\nremote_cache_hits=%lu\nremote_cache_misses=%lu\nremote_cache_bytes=%lu\n",
        gHTTPAttempts,gRemoteCache.hits,gRemoteCache.misses,(unsigned long)gRemoteCache.bytes);
    fprintf(file,"http_tls_handshakes=%lu\nhttp_reuse_attempts=%lu\nhttp_reconnect_retries=%lu\n",
        gHTTPHandshakes,gHTTPReuseAttempts,gHTTPReconnectRetries);
    fprintf(file,"git_http_attempts=%lu\ngit_tls_handshakes=%lu\ngit_http_reuse_attempts=%lu\ngit_reconnect_retries=%lu\n",
        gGitHTTPAttempts,gGitHandshakes,gGitReuseAttempts,gGitReconnectRetries);
    fprintf(file,"last_fetch_have_count=%lu\nlast_fetch_pack_bytes=%lu\nlast_fetch_imported_objects=%lu\n",
        gGitFetchHaveCount,gGitFetchPackBytes,gGitFetchImportedObjects);
    fprintf(file,"last_handshake_state=%d\nverify_flags=%08lx\ncertificate_callbacks=%d\n",gTLS.lastHandshakeState,gTLS.verifyFlags,gTLS.certificateChecks);
    fprintf(file,"transport_error=%ld\ntransport_event=%ld\n",gTLS.transportError,gTLS.transportEvent);
    for(i=0;i<19;++i)fprintf(file,"phase_%s_ticks=%lu\n",names[i],gTLS.phaseTicks[i]);
    for(i=0;i<8;++i)fprintf(file,"certificate_depth_%d_flags=%08lx\n",i,gTLS.certificateFlags[i]);
    i=ferror(file);if(fclose(file))i=1;return i?-1:0;
}
static void TestConnection(void) {
    unsigned char *data;size_t length;char login[128];int result,vaultResult;unsigned long started,vaultTicks;
    started=TickCount();vaultResult=GVCheck();vaultTicks=TickCount()-started;
    result=vaultResult?vaultResult:Request("/users/bbenchoff",NULL,&data,&length);
    if(vaultResult)SetStatus("Saved-credential crypto self-check failed. No connection was attempted.");
    if(!result) {
        if(!GHField((char*)data,length,"login",login,sizeof(login)))
            SetStatus("Verified GitHub HTTPS succeeded. Public account: bbenchoff.");
        else SetStatus("GitHub returned an unrecognized account response.");
        free(data);
    }
    if(WriteTLSProbe(result,vaultResult,vaultTicks))SetStatus("The connection test finished, but its public diagnostic log could not be written.");
}
/* Account-owned remote caches never own the current local preview or editor. */
static void ClearRemoteAccount(void) {
    gRemote[0]=gBranch[0]=0;gRevisionCount=gChangeCount=0;gRevisionIndex=gFileIndex=-1;
    if(gCommitJSON){free(gCommitJSON);gCommitJSON=NULL;}gCommitLength=0;
    memset(gRepos,0,sizeof(gRepos));memset(gRevisions,0,sizeof(gRevisions));memset(gChanges,0,sizeof(gChanges));
    gRepoCount=0;gRepoPage=gHistoryPage=gFilePage=1;gHistoryOffset=0;
}
static void ClearRemote(void) {
    ClearRemoteAccount();gPatch[0]=0;HideDiffControls();
}
static void LoadPatch(int index) {
    char *p;int lines=1;
    if(index<0 || index>=gChangeCount)return;
    gFileIndex=index;gPatchTruncated=GHReadPatch(gCommitJSON,gCommitLength,index,gPatch,sizeof(gPatch));
    if(gPatchTruncated<0){gPatch[0]=0;gPatchTruncated=0;SetStatus("Could not decode the selected patch.");}
    for(p=gPatch;*p;++p)if(*p=='\r')++lines;
    gDiffTop=0;FindReset();gDiffLines=lines>24 ? lines-24 : 0;
    DiffScroll();ShowDiffControls();
    SetPort(gWindow);InvalRect(&gWindow->portRect);
}
static void LoadCommit(int index,int page) {
    unsigned char *body;size_t length;char path[512],message[160];int count,error;
    if(index<0 || index>=gRevisionCount || page<1)return;
    snprintf(path,sizeof(path),"/repos/%s/commits/%s?per_page=100&page=%d",gRemote,gRevisions[index].sha,page);
    if(RemoteRequest(path,&body,&length))return;
    error=GHReadChanges((char*)body,length,gChanges,100,&count);
    if(error){RCForget(&gRemoteCache,path);free(body);gRevisionIndex=gFileIndex=-1;gChangeCount=0;gPatch[0]=0;HideDiffControls();SetStatus("Commit file response exceeds this view's limits or is malformed.");return;}
    if(gCommitJSON)free(gCommitJSON);gCommitJSON=(char*)body;gCommitLength=length;
    gRevisionIndex=index;gChangeCount=count;gFilePage=page;gFileIndex=-1;gPatch[0]=0;
    HideControl(gBrowse);HideDiffControls();if(count)LoadPatch(0);
    snprintf(message,sizeof(message),"Remote commit %.7s: %d files on page %d. Click the filename to choose a patch.",gRevisions[index].sha,count,page);
    SetStatus(message);
}
static int LoadHistory(void) {
    unsigned char *body;size_t length;char path[512];int count,error;
    if(!gRemote[0]){SetStatus("Choose a repository first.");return 1;}
    snprintf(path,sizeof(path),"/repos/%s/commits?per_page=%d&page=%d",gRemote,GH_HISTORY_CAPACITY,gHistoryPage);
    error=RemoteRequest(path,&body,&length);
    if(error){if(error==409)SetStatus("This repository has no commits yet.");return 1;}
    error=GHReadRevisions((char*)body,length,gRevisions,GH_HISTORY_CAPACITY,&count);free(body);
    if(error){RCForget(&gRemoteCache,path);gRevisionCount=0;gRevisionIndex=gFileIndex=-1;gPatch[0]=0;HideDiffControls();SetStatus("Could not decode GitHub's commit history.");return 1;}
    gRevisionCount=count;gRevisionIndex=-1;gTab=1;gHistoryOffset=0;
    if(gCommitJSON){free(gCommitJSON);gCommitJSON=NULL;}gCommitLength=0;
    gChangeCount=0;gFileIndex=-1;gPatch[0]=0;HideDiffControls();
    if(count)LoadCommit(0,1);else {ShowControl(gBrowse);SetStatus("No commits on this page. Use the previous-page arrow.");}
    SetPort(gWindow);InvalRect(&gWindow->portRect);return 0;
}
static void RemoteHistoryPage(int direction) {
    int page=gHistoryPage-1,oldPage=gHistoryPage,offset=gHistoryOffset;
    int moved=GHPageMove(direction,gUI.rows,gRevisionCount,gRevisionCount==GH_HISTORY_CAPACITY,&page,&offset);
    if(!moved)return;
    if(moved==2) {
        gHistoryPage=page+1;
        if(LoadHistory()){gHistoryPage=oldPage;return;}
    }
    gHistoryOffset=GHVisibleOffset(offset,-1,gRevisionCount,gUI.rows);
    if(gRevisionCount)LoadCommit(gHistoryOffset,1);
    InvalRect(&gWindow->portRect);
}
static void SelectRemote(const char *name,const char *branch) {
    char saved[256],savedBranch[256];
    if(!GHValidRepository(name))return;
    strcpy(saved,name);strncpy(savedBranch,branch,255);savedBranch[255]=0;
    if(gLocal){LocalClose();if(gLocal)return;}
    ClearRemote();strcpy(gRemote,saved);strcpy(gBranch,savedBranch);gHistoryPage=1;
    HideControl(gBrowse);LoadHistory();
}
static pascal Boolean RemoteNameFilter(DialogPtr d,EventRecord *event,short *hit) {
    Handle item,button;short kind,enabledKind;Rect r;Str255 p;char name[256];int valid;
    GetDialogItem(d,4,&kind,&item,&r);GetDialogItemText(item,p);
    memcpy(name,p+1,p[0]);name[p[0]]=0;valid=GHValidRepository(name);
    GetDialogItem(d,1,&kind,&button,&r);enabledKind=(short)((kind&127)|(valid?0:128));
    if(enabledKind!=kind)SetDialogItem(d,1,enabledKind,button,&r);
    if((**(ControlHandle)button).contrlHilite!=(valid?0:255))HiliteControl((ControlHandle)button,valid?0:255);
    if(event && (event->what==keyDown || event->what==autoKey) &&
       !(event->modifiers&cmdKey) &&
       ((event->message&charCodeMask)==13 || (event->message&charCodeMask)==3) && !valid) {
        *hit=0;SysBeep(1);return true;
    }
    return event?NativeDialogFilter(d,event,hit):false;
}
static void OpenRemoteByName(void) {
    DialogPtr dialog;short hit=0,kind;Handle item;Rect r;Str255 text;char name[256],path[512],branch[256];
    unsigned char *body;size_t length;
    ModalFilterUPP filter;
    dialog=GetNewDialog(130,NULL,(WindowPtr)-1);if(!dialog)return;
    filter=NewModalFilterProc(RemoteNameFilter);if(!filter){DisposeDialog(dialog);SetPort(gWindow);return;}
    PrepareDialogChrome(dialog,6,7);
    ShowWindow((WindowPtr)dialog);
    GetDialogItem(dialog,4,&kind,&item,&r);Pascal(gRemote,text);SetDialogItemText(item,text);SelectDialogItemText(dialog,4,0,32767);
    RemoteNameFilter(dialog,NULL,NULL);
    PrepareDialog(dialog,1,2);
    while(hit!=1 && hit!=2)RunModalDialog(filter,&hit);
    GetDialogItemText(item,text);memcpy(name,text+1,text[0]);name[text[0]]=0;DisposeDialog(dialog);
    DisposeRoutineDescriptor((UniversalProcPtr)filter);SetPort(gWindow);
    if(hit!=1)return;
    if(!GHValidRepository(name)){SetStatus("Enter a repository as owner/name, without a URL.");return;}
    snprintf(path,sizeof(path),"/repos/%s",name);
    if(RemoteRequest(path,&body,&length))return;
    if(GHField((char*)body,length,"default_branch",branch,sizeof(branch)))branch[0]=0;
    free(body);SelectRemote(name,branch);
}
static void AddItem(MenuHandle menu,const char *name) {
    Str255 text;AppendMenu(menu,"\px");Pascal(name,text);SetMenuItemText(menu,CountMItems(menu),text);
}
#include "GHRepositoryUI.c"
static void ChooseRepository(void) {
    unsigned char *body;size_t length;char path[256];
    int page=gRepoPage,count,error,selected;
    if(!gUser[0]){SignIn();if(!gUser[0])return;}
    for(;;) {
        snprintf(path,sizeof(path),"/user/repos?sort=updated&direction=desc&per_page=%d&page=%d",GH_REPOSITORY_PAGE,page);
        if(RemoteRequest(path,&body,&length))return;
        error=GHReadRepositories((char*)body,length,gRepos,GH_REPOSITORY_PAGE,&count);free(body);
        if(error){RCForget(&gRemoteCache,path);SetStatus("Could not decode the repository list.");return;}
        gRepoCount=count;gRepoPage=page;selected=RepositoryListChoose(page,count,0);
        if(selected==-5){RCClear(&gRemoteCache);continue;}
        if(selected==-2 && page>1){--page;continue;}if(selected==-3 && count==GH_REPOSITORY_PAGE){++page;continue;}
        if(selected==-4)OpenRemoteByName();
        else if(selected>=0 && selected<count)SelectRemote(gRepos[selected].fullName,gRepos[selected].branch);
        return;
    }
}
static void ChooseFile(void) {
    MenuHandle menu;long choice;short selected;int i,previous=0,next=0;Point point;
    menu=NewMenu(201,"\pChanged Files");if(!menu)return;
    for(i=0;i<gChangeCount;++i)AddItem(menu,gChanges[i].filename);
    if(gFilePage>1){AddItem(menu,"Previous files...");previous=CountMItems(menu);}
    if(gChangeCount==100){AddItem(menu,"Next files...");next=CountMItems(menu);}
    if(!CountMItems(menu)){DisposeMenu(menu);return;}
    InsertMenu(menu,-1);CalcMenuSize(menu);SetPort(gWindow);point.h=251;point.v=150;LocalToGlobal(&point);
    choice=PopUpMenuSelect(menu,point.v,point.h,gFileIndex+1);DeleteMenu(201);DisposeMenu(menu);selected=(short)choice;
    if(!selected)return;
    if(selected==previous)LoadCommit(gRevisionIndex,gFilePage-1);
    else if(selected==next)LoadCommit(gRevisionIndex,gFilePage+1);
    else if(selected<=gChangeCount)LoadPatch(selected-1);
}
/* The secret never enters TextEdit or a dialog text Handle. A separate user
   item draws the field frame on every Dialog Manager update; item4 holds only
   stars. Drawing a frame once before ShowWindow loses it on initial repaint. */
static pascal void TokenFrame(DialogPtr dialog,short number) {
    GrafPtr saved;PenState pen;RGBColor foreground,black={0,0,0};
    short kind,font,size,width;Style face;Handle item;Rect r,selection;Str255 stars;size_t n,i;
    GetPort(&saved);SetPort((GrafPtr)dialog);GetPenState(&pen);GetForeColor(&foreground);
    font=((GrafPtr)dialog)->txFont;size=((GrafPtr)dialog)->txSize;face=((GrafPtr)dialog)->txFace;
    GetDialogItem(dialog,number,&kind,&item,&r);PenNormal();Box(r.left,r.top,r.right,r.bottom,255,255,255);RGBForeColor(&black);FrameRect(&r);
    n=strlen(gPendingToken);if(n>42)n=42;stars[0]=(unsigned char)n;for(i=1;i<=n;++i)stars[i]='*';
    TextFont(gGeneva);TextSize(12);TextFace(0);MoveTo((short)(r.left+7),(short)(r.top+21));DrawString(stars);
    if(gPendingTokenSelected && n) {
        width=TextWidth((char *)stars+1,0,(short)n);selection=r;InsetRect(&selection,7,7);
        if(selection.left+width<selection.right)selection.right=(short)(selection.left+width);InvertRect(&selection);
    }
    /* Initial Dialog Manager drawing can repaint the default button after
       setup. This user item follows it in DITL order, so the visible button
       is synchronized during real window updates, without an idle redraw. */
    GetDialogItem(dialog,1,&kind,&item,&r);
    HiliteControl((ControlHandle)item,gPendingToken[0]?0:255);Draw1Control((ControlHandle)item);
    RGBForeColor(&foreground);SetPenState(&pen);TextFont(font);TextSize(size);TextFace(face);SetPort(saved);
}
static void DrawMask(DialogPtr dialog) {
    GrafPtr saved;Str255 stars;short kind,enabledKind;Handle item;Rect r;size_t n=strlen(gPendingToken),i;
    GetPort(&saved);SetPort((GrafPtr)dialog);
    if(n>42)n=42;stars[0]=(unsigned char)n;for(i=1;i<=n;++i) stars[i]='*';
    GetDialogItem(dialog,4,&kind,&item,&r);SetDialogItemText(item,stars);
    GetDialogItem(dialog,1,&kind,&item,&r);
    enabledKind=gPendingToken[0]?(kind&~itemDisable):(kind|itemDisable);
    if(enabledKind!=kind)SetDialogItem(dialog,1,enabledKind,item,&r);
    HiliteControl((ControlHandle)item,gPendingToken[0]?0:255);TokenFrame(dialog,6);SetPort(saved);
}
static pascal Boolean TokenFilter(DialogPtr dialog,EventRecord *e,short *hit) {
    unsigned char key;size_t length;Handle scrap;long size,offset=0,i;
    /* Handle token keys before StdFilterProc can accept an empty Return or
       pass clipboard commands to a normal editor. Non-key events still use
       the shared native filter and Dialog Manager update handling. */
    if(e->what!=keyDown && e->what!=autoKey)return NativeDialogFilter(dialog,e,hit);
    *hit=0;key=(unsigned char)(e->message&charCodeMask);length=strlen(gPendingToken);
    if(key==13 || key==3) {if(gPendingToken[0])*hit=1;else SysBeep(1);return true;}
    if(key==27) {*hit=2;return true;}
    if((e->modifiers&cmdKey) && key=='.'){*hit=2;return true;}
    if((e->modifiers&cmdKey) && (key=='q' || key=='Q')){gDone=1;*hit=2;return true;}
    if((e->modifiers&cmdKey) && (key=='v' || key=='V')) {
        size=GetScrap(NULL,'TEXT',&offset);
        if(size>0 && size<(long)sizeof(gPendingToken)) {
            scrap=NewHandle(size);
            if(scrap) {
                HLock(scrap);
                if(GetScrap(scrap,'TEXT',&offset)==size) {
                    for(i=0;i<size;++i) if((unsigned char)(*scrap)[i]<33 || (unsigned char)(*scrap)[i]>126) break;
                    if(i==size) {mbedtls_platform_zeroize(gPendingToken,sizeof(gPendingToken));memcpy(gPendingToken,*scrap,(size_t)size);gPendingTokenSelected=0;}
                }
                mbedtls_platform_zeroize(*scrap,(size_t)size);HUnlock(scrap);DisposeHandle(scrap);
            }
        }
    } else if(e->modifiers&cmdKey) {
        if(key=='a' || key=='A')gPendingTokenSelected=1;
    } else if(key==8 || key==127) {
        if(gPendingTokenSelected)mbedtls_platform_zeroize(gPendingToken,sizeof(gPendingToken));else if(length)gPendingToken[length-1]=0;
        gPendingTokenSelected=0;
    } else if(key>=33 && key<=126) {
        if(gPendingTokenSelected){mbedtls_platform_zeroize(gPendingToken,sizeof(gPendingToken));length=0;}
        gPendingTokenSelected=0;if(length+1<sizeof(gPendingToken)){gPendingToken[length]=key;gPendingToken[length+1]=0;}else SysBeep(1);
    }
    DrawMask(dialog);return true;
}
static int TokenSignIn(void) {
    DialogPtr dialog;ModalFilterUPP filter;UserItemUPP frame;short hit=0,kind;Handle item;Rect r;
    unsigned char *body;size_t size;OACredentials *pending;int accepted=0;
    if(gDone)return 0;
    mbedtls_platform_zeroize(gPendingToken,sizeof(gPendingToken));gPendingTokenSelected=0;
    dialog=GetNewDialog(129,NULL,(WindowPtr)-1);if(!dialog)return 0;
    filter=NewModalFilterProc(TokenFilter);frame=NewUserItemProc(TokenFrame);
    if(!filter || !frame){
        if(filter){DisposeRoutineDescriptor((UniversalProcPtr)filter);}
        if(frame){DisposeRoutineDescriptor((UniversalProcPtr)frame);}
        DisposeDialog(dialog);SetPort(gWindow);return 0;
    }
    GetDialogItem(dialog,6,&kind,&item,&r);SetDialogItem(dialog,6,kind,(Handle)frame,&r);
    if(!PrepareDialogChrome(dialog,8,9)) {
        DisposeRoutineDescriptor((UniversalProcPtr)filter);DisposeRoutineDescriptor((UniversalProcPtr)frame);DisposeDialog(dialog);SetPort(gWindow);return 0;
    }
    PrepareDialog(dialog,1,2);ShowWindow((WindowPtr)dialog);DrawMask(dialog);
    while(!gDone && hit!=1 && hit!=2){
        hit=0;
        RunModalDialog(filter,&hit);
        if(hit==1 && !gPendingToken[0]){SysBeep(1);hit=0;DrawMask(dialog);}
    }
    DisposeRoutineDescriptor((UniversalProcPtr)filter);DisposeDialog(dialog);
    DisposeRoutineDescriptor((UniversalProcPtr)frame);
    if(!gDone && hit==1 && gPendingToken[0]) {
        if(!Request("/user",gPendingToken,&body,&size)) {
            pending=(OACredentials*)calloc(1,sizeof(*pending));
            if(pending) {
                strcpy(pending->access,gPendingToken);
                if(!OAAccount(pending,(char*)body,size,NULL)) {
                    AuthInstall(pending);accepted=1;
                    SetStatus("Your GitHub account is verified. Token held only in memory.");
                } else SetStatus("GitHub did not return a valid authenticated account.");
                OAClear(pending,sizeof(*pending));free(pending);
            }
            OAClear(body,size);free(body);
        }
    }
    mbedtls_platform_zeroize(gPendingToken,sizeof(gPendingToken));gPendingTokenSelected=0;SetPort(gWindow);InvalRect(&gWindow->portRect);
    return accepted;
}
#include "GHAuthUI.c"
#include "GHLoginCache.c"
#include "GHCredentialUI.c"
#include "GHStartupUI.c"
static int TestNativeCheckout(const char *);
#include "GitFileCheck.c"
#include "GitCheckoutCheck.c"
#include "GitNativeCheck.c"
static void TestMergeCheckout(void);
#include "GitFolderUI.c"
#include "GitLocalUI.c"
#include "GHRecentMac.c"
#include "GHDialogUI.c"
static void BranchEditCommand(int);
static void SavedChangesCommand(void);
static int StashAvailable(void);
static void StashChangesCommand(void);
static void StashedChangesCommand(void);
static int DiscardAvailable(void);
static void DiscardChangesCommand(void);
#include "GitMenuUI.c"
#include "GHRecentUI.c"
#include "GitSettingsUI.c"
#include "GitCheckoutUI.c"
#include "GitBranchEditUI.c"
#include "GitWorkspaceUI.c"
#include "GitMergeCheck.c"
#include "GitCompareUI.c"
#include "GitMergeUI.c"
#include "GitStashUI.c"
#include "GitNetworkUI.c"
#include "GitDefaultBranchUI.c"
#include "GitPullRequestUI.c"
#include "GitWebUI.c"
#include "GitRebaseConflictUI.c"
#include "GitRebaseUI.c"
#include "GitPlatformUI.c"
#include "GHWindowUI.c"
static void Event(EventRecord *e) {
    WindowPtr w;short part;Point p;ControlHandle control;
    if(e->what==kHighLevelEvent)AEProcessAppleEvent(e);
    else if(e->what==updateEvt) {w=(WindowPtr)e->message;BeginUpdate(w);if(w==gWindow)Draw();EndUpdate(w);}
    else if(e->what==activateEvt && (WindowPtr)e->message==gWindow) {
        SetPort(gWindow);InvalRect(&gWindow->portRect);
        if(gLocal && gCommitField && !gTab) {
            if(e->modifiers&activeFlag)TEActivate(gCommitField==1?gSummaryEdit:gDescriptionEdit);
            else TEDeactivate(gCommitField==1?gSummaryEdit:gDescriptionEdit);
        }
    }
    else if(e->what==mouseDown) {
        part=FindWindow(e->where,&w);
        if(part==inMenuBar && !gBusy){UpdateMenus();Menu(MenuSelect(e->where));}
        else if(part==inSysWindow)SystemClick(e,w);
        else if(part==inDrag) {Rect bounds=qd.screenBits.bounds;DragWindow(w,e->where,&bounds);}
        else if(part==inGoAway && w==gWindow && !gBusy && TrackGoAway(w,e->where))CloseWorkspace();
        else if(part==inGrow && w==gWindow && !gBusy)WindowResize(e->where);
        else if((part==inZoomIn || part==inZoomOut) && w==gWindow && !gBusy)WindowZoom(e->where,part);
        else if(part==inContent && w==gWindow) {
            if(FrontWindow()!=w)SelectWindow(w);
            else if(!gBusy) {SetPort(w);p=e->where;GlobalToLocal(&p);
                part=FindControl(p,w,&control);
                if(part && control==gSignIn && TrackControl(control,p,NULL))SignIn();
                else if(part && control==gCommit && gLocal && TrackControl(control,p,NULL))LocalCommit();
                else if(part && control==gBrowse && TrackControl(control,p,NULL))ChooseRepository();
                else if(part && control==gFetch && gLocal && TrackControl(control,p,NULL))NetworkFetch();
                else if(part && control==gDiffHorizontal) {
                    part=TrackControl(control,p,NULL);
                    if(part==kControlUpButtonPart){if(gDiffLeft)--gDiffLeft;}
                    else if(part==kControlDownButtonPart){if(gDiffLeft<gDiffColumns)++gDiffLeft;}
                    else if(part==kControlPageUpPart)gDiffLeft=gDiffLeft>(unsigned long)gDiffVisibleColumns?gDiffLeft-gDiffVisibleColumns:0;
                    else if(part==kControlPageDownPart)gDiffLeft+=(unsigned long)gDiffVisibleColumns;
                    else if(part==kControlIndicatorPart)gDiffLeft=DVPosition(GetControlValue(control),gDiffColumns);
                    if(gDiffLeft>gDiffColumns)gDiffLeft=gDiffColumns;
                    SetControlValue(control,DVValue(gDiffLeft,gDiffColumns));InvalRect(&w->portRect);
                }
                else if(part && control==gDiffScroll) {
                    part=TrackControl(control,p,NULL);
                    if(part==kControlUpButtonPart)--gDiffTop;else if(part==kControlDownButtonPart)++gDiffTop;
                    else if(part==kControlPageUpPart)gDiffTop-=DiffVisibleRows();else if(part==kControlPageDownPart)gDiffTop+=DiffVisibleRows();
                    else if(part==kControlIndicatorPart)gDiffTop=GetControlValue(control);
                    if(gDiffTop<0)gDiffTop=0;if(gDiffTop>gDiffLines)gDiffTop=gDiffLines;
                    SetControlValue(control,(short)gDiffTop);InvalRect(&w->portRect);
                }
                else if(gLocal && p.h>=241 && p.h<RightEdge(577) && p.v<58)CheckoutSwitch();
                else if(gLocal && p.h<238 && p.v<58)RecentRepositories();
                else if(p.h<238 && p.v<58)ChooseRepository();
                else if(gLocalBlocked) { /* Refresh/repository/branch actions above remain available. */ }
                else if(gLocal && gTab && BCUIActive() && p.h>=255 && p.h<600 && p.v>=119 && p.v<145) {
                    if(p.h<365)BCUIMode(0);else if(p.h>=375 && p.h<485)BCUIMode(1);else if(p.h>=495)BCUIMode(2);
                }
                else if(gLocal && gTab && BCUIActive() && p.h>=10 && p.h<233 && p.v>=100 && p.v<125) {
                    if(p.h<95)BCUIDirection(BC_RIGHT);else if(p.h>=100 && p.h<185)BCUIDirection(BC_LEFT);
                    else if(p.h>=190)BCUIPage(p.h<210?-1:1);
                }
                else if(gLocal && gTab && p.h>=255 && p.h<600 && p.v>=119 && p.v<145) {
                    if(p.h<365)LocalHistoryMessage();else if(p.h>=375)LocalHistoryChooseFile();
                }
                else if(gLocal && !gTab && gLocalSelection>=0 && p.h>=255 && p.h<575 && p.v>=119 && p.v<145) {
                    gLocalDiffMode=p.h>=415;LocalSelect(gLocalSelection);
                }
                else if(gLocal && !gTab && p.h>=14 && p.h<225 && ((p.v>=gUI.summaryTop-2 && p.v<gUI.summaryTop+24) || (p.v>=gUI.descriptionTop-2 && p.v<gUI.descriptionTop+24))) {
                    if(gCommitField)TEDeactivate(gCommitField==1?gSummaryEdit:gDescriptionEdit);
                    gCommitField=p.v<gUI.descriptionTop-2?1:2;TEActivate(gCommitField==1?gSummaryEdit:gDescriptionEdit);
                    TEClick(p,(e->modifiers&shiftKey)!=0,gCommitField==1?gSummaryEdit:gDescriptionEdit);
                } else if(gLocal && !gTab && p.h>=12 && p.h<34 && p.v>=100 && p.v<125) {
                    LocalToggleAll();
                } else if(gLocal && p.h>=190 && p.h<233 && p.v>=100 && p.v<125) {
                    if(gTab){
                        LocalHistoryPage(p.h<210?-1:1);
                    }else {if(p.h<210){if(gLocalPage>0)--gLocalPage;}else if((size_t)(gLocalPage+1)*gUI.rows<gLocalRowCount)++gLocalPage;}
                    InvalRect(&w->portRect);
                } else if(gLocal && p.h<233 && p.v>=134 && p.v<134+gUI.rows*28) {
                    int row=gLocalPage*gUI.rows+(p.v-134)/28;
                    if(gTab){if(BCUIActive())BCUISelect((p.v-134)/28);else LocalHistorySelect(gLocalHistoryOffset+(p.v-134)/28);}
                    else if((size_t)row<gLocalRowCount){LocalSelect(row);if(p.h<34)LocalToggle();}
                }
                else if(p.h<240 && p.v>=58 && p.v<94) {
                    if(gLocal){
                        if(gCommitField)TEDeactivate(gCommitField==1?gSummaryEdit:gDescriptionEdit);
                        gCommitField=0;gTab=p.h>=120;
                        if(gTab){gLocalHistoryPage=1;LocalHistoryLoad();}else LocalRows();
                        LocalEditState();
                    }else {gTab=p.h>=120;if(gTab && gRemote[0] && !gRevisionCount)LoadHistory();}InvalRect(&w->portRect);
                } else if(gTab && gRemote[0] && p.h>=190 && p.h<233 && p.v>=100 && p.v<125) {
                    RemoteHistoryPage(p.h<210?-1:1);
                } else if(gTab && p.h<233 && p.v>=134 && p.v<134+gUI.rows*28) {
                    int index=gHistoryOffset+(p.v-134)/28;if(index<gRevisionCount)LoadCommit(index,1);
                } else if(p.h>=251 && p.h<RightEdge(789) && p.v>=134 && p.v<152 && gCommitJSON)ChooseFile();

            }
        }
    } else if((e->what==keyDown || e->what==autoKey) && !gBusy) {
        if(e->modifiers&cmdKey){UpdateMenus();Menu(MenuKey((char)(e->message&charCodeMask)));}
        else if(gLocal && gCommitField && !gTab) {
            TEHandle edit=gCommitField==1?gSummaryEdit:gDescriptionEdit;
            if((e->message&charCodeMask)==9){TEDeactivate(edit);gCommitField=3-gCommitField;TEActivate(gCommitField==1?gSummaryEdit:gDescriptionEdit);}
            else if((*edit)->teLength<8000 || (e->message&charCodeMask)==8) {
                char key=(char)(e->message&charCodeMask);
                if(key==8 || key==13 || (unsigned char)key>=32)EditCapture();
                TEKey(key,edit);
            }
            LocalEditState();
        }
    }
}
int main(void) {
    EventRecord e;MenuHandle menu;int i;Rect button;
    InitGraf(&qd.thePort);InitFonts();InitWindows();InitMenus();TEInit();InitDialogs(NULL);InitCursor();MaxApplZone();
    gDialogFilter=NewModalFilterProc(NativeDialogFilter);if(!gDialogFilter)return 1;
    GetFNum("\pChicago",&gChicago);GetFNum("\pGeneva",&gGeneva);GetFNum("\pMonaco",&gMonaco);
    for(i=128;i<=134;++i) {menu=GetMenu((short)i);if(menu)InsertMenu(menu,0);}
    menu=GetMenuHandle(128);if(menu)AppendResMenu(menu,'DRVR');DrawMenuBar();
    DisplayLayout();
    gWindow=(WindowPtr)GetNewCWindow(128,NULL,(WindowPtr)-1);if(!gWindow)return 1;
    SizeWindow(gWindow,gUI.width,gUI.height,false);
    MoveWindow(gWindow,10,45,false);
    gWelcomeIcon=GetCIcon(300);
    SetRect(&button,PaneCenter()-108,WelcomeY(278),PaneCenter()+112,WelcomeY(304));
    gSignIn=NewControl(gWindow,&button,"\pSign In to GitHub...",true,0,0,0,pushButProc,0);
    gBrowse=NewControl(gWindow,&button,"\pBrowse Repositories...",false,0,0,0,pushButProc,0);
    SetRect(&button,RightEdge(775),153,RightEdge(789),BottomEdge(451)-17);
    gDiffScroll=NewControl(gWindow,&button,"\p",false,0,0,0,scrollBarProc,0);
    SetRect(&button,251,BottomEdge(451)-15,RightEdge(772),BottomEdge(451)-1);
    gDiffHorizontal=NewControl(gWindow,&button,"\p",false,0,0,0,scrollBarProc,0);
    if(!gDiffScroll || !gDiffHorizontal)return 1;
    SetRect(&button,RightEdge(612),15,RightEdge(768),39);
    gFetch=NewControl(gWindow,&button,"\pFetch Origin",true,0,0,0,pushButProc,0);HiliteControl(gFetch,255);
    SetRect(&button,14,gUI.commitTop,225,gUI.commitTop+24);
    gCommit=NewControl(gWindow,&button,"\pCommit to Branch",true,0,0,0,pushButProc,0);HiliteControl(gCommit,255);
    GWInit(&gWork);SetPort(gWindow);TextFont(gGeneva);TextSize(9);SetRect(&button,20,gUI.summaryTop+3,220,gUI.summaryTop+20);gSummaryEdit=TENew(&button,&button);
    SetRect(&button,20,gUI.descriptionTop+3,220,gUI.descriptionTop+20);gDescriptionEdit=TENew(&button,&button);
    if(!gSummaryEdit || !gDescriptionEdit)return 1;
    (*gSummaryEdit)->txFont=gGeneva;(*gSummaryEdit)->txSize=9;TECalText(gSummaryEdit);
    (*gDescriptionEdit)->txFont=gGeneva;(*gDescriptionEdit)->txSize=9;TECalText(gDescriptionEdit);
    WindowRestore();InstallNativeEvents();Draw();VaultAutoRestore();
    while(!gDone) {
        if(WaitNextEvent(everyEvent,&e,6,NULL))Event(&e);
        WindowCheckDisplay();
        NativeDispatchPendingOpen();
        HTTPIdle();
        if(gLocal && gCommitField)TEIdle(gCommitField==1?gSummaryEdit:gDescriptionEdit);
    }
    WindowRemember();SSL_Close(&gTLS);if(gInternet!=kOTInvalidProviderRef)OTCloseProvider(gInternet);if(gOT)CloseOpenTransport();
    RemoveNativeEvents();LocalHistoryReset();GXClose(&gUICheckout);if(!SettingsRelease())GWClose(&gWork);free(gLocalRows);TEDispose(gSummaryEdit);TEDispose(gDescriptionEdit);
    if(gCommitJSON)free(gCommitJSON);RCClear(&gRemoteCache);OAClear(&gCredentials,sizeof(gCredentials));OAClear(gPendingToken,sizeof(gPendingToken));if(gWelcomeIcon)DisposeCIcon(gWelcomeIcon);
    if(gAuthArtProc)DisposeRoutineDescriptor((UniversalProcPtr)gAuthArtProc);
    StartupShutdown();VaultShutdown();
    for(i=0;i<11;++i)if(gMonoIcons[i])DisposeIconSuite(gMonoIcons[i],false);
    DisposeRoutineDescriptor((UniversalProcPtr)gDialogFilter);DisposeWindow(gWindow);return 0;
}
