/* System 7 Standard File folder selection. No pathname-entry fallback.
   Selection-change gating and validation after setting the title follow Apple's
   StandardGetFolder sample (Andy Bachorski, Apple Computer, 1998-1999), adapted
   for GitHub Classic's selection, creation and event handling. See the retained sample
   and notice in third_party/AppleStandardGetFolder; that sample is not linked. */
#include <StandardFile.h>
#include <LowMem.h>
#include <Script.h>

typedef struct {
    StandardFileReply reply;
    FSSpec selected;
    FSSpec newFolder;
    int haveSelection, accepted, create, selectNewFolder, paintChoice;
    FSSpec previousReply;
    int haveReply, previousIsFolder, previousIsVolume;
    const char *prompt, *action;
} GHFolderChoice;

static OSErr FolderAt(short volume, long directory, FSSpec *folder) {
    CInfoPBRec pb;
    Str255 name;
    OSErr error;
    memset(&pb, 0, sizeof(pb));
    pb.dirInfo.ioVRefNum = volume;
    pb.dirInfo.ioDrDirID = directory;
    pb.dirInfo.ioFDirIndex = -1;
    pb.dirInfo.ioNamePtr = name;
    error = PBGetCatInfoSync(&pb);
    if (error)
        return error;
    return FSMakeFSSpec(volume, pb.dirInfo.ioDrParID, name, folder);
}
static OSErr CurrentPickerFolder(FSSpec *folder) {
    return FolderAt((short)-LMGetSFSaveDisk(), LMGetCurDirStore(), folder);
}
static pascal Boolean FolderOnly(CInfoPBPtr pb, Ptr data) {
    (void)data;
    return (pb->hFileInfo.ioFlAttrib & 16) == 0;
}
static void FolderButton(DialogPtr d, GHFolderChoice *state, int repaint) {
    GrafPtr saved;
    RgnHandle clip;
    Handle item;
    short kind;
    Rect r;
    Str255 title, oldTitle;
    char name[64], text[128];
    OSErr error;
    CInfoPBRec pb;
    if (state->reply.sfIsFolder || state->reply.sfIsVolume) {
        state->selected = state->reply.sfFile;
        error = noErr;
    } else
        error = CurrentPickerFolder(&state->selected);
    if (!error) {
        memset(&pb, 0, sizeof(pb));
        pb.dirInfo.ioVRefNum = state->selected.vRefNum;
        pb.dirInfo.ioDrDirID = state->selected.parID;
        pb.dirInfo.ioNamePtr = state->selected.name;
        error = PBGetCatInfoSync(&pb);
        if (!error && !(pb.dirInfo.ioFlAttrib & 16))
            error = dirNFErr;
    }
    state->haveSelection = !error;
    state->previousReply = state->reply.sfFile;
    state->previousIsFolder = state->reply.sfIsFolder;
    state->previousIsVolume = state->reply.sfIsVolume;
    state->haveReply = 1;
    /* SetControlTitle invalidates the button. Repeating it on null events
       creates an erase/redraw cycle. Standard File owns ordinary updates. */
    GetPort(&saved);
    SetPort((GrafPtr)d);
    GetDialogItem(d, 10, &kind, &item, &r);
    if (!error) {
        memcpy(name, state->selected.name + 1, state->selected.name[0]);
        name[state->selected.name[0]] = 0;
        snprintf(text, sizeof(text), "%s \"%s\"", state->action, name);
    } else
        strcpy(text, "Choose a folder");
    Pascal(text, title);
    GetControlTitle((ControlHandle)item, oldTitle);
    if (oldTitle[0] != title[0] || memcmp(oldTitle + 1, title + 1, title[0])) repaint = 1;
    if ((**(ControlHandle)item).contrlHilite != (error ? 255 : 0)) repaint = 1;
    if (repaint) {
        clip = NewRgn();
        if (clip) {
            GetClip(clip); ClipRect(&r);
            if (oldTitle[0] != title[0] || memcmp(oldTitle + 1, title + 1, title[0]))
                SetControlTitle((ControlHandle)item, title);
            if ((**(ControlHandle)item).contrlHilite != (error ? 255 : 0))
                HiliteControl((ControlHandle)item, error ? 255 : 0);
            Draw1Control((ControlHandle)item);
            /* As in Apple's sample, do not leave the painted button pending
               for another erase/update. Never validate other dialog items. */
            ValidRect(&r);
            SetClip(clip); DisposeRgn(clip);
        } else {
            /* Allocation failure keeps ordinary Dialog Manager repainting. */
            SetControlTitle((ControlHandle)item, title);
            HiliteControl((ControlHandle)item, error ? 255 : 0);
            InvalRect(&r);
        }
    }
    SetPort(saved);
}
static int FolderNameValid(ConstStr255Param name) {
    short i;
    if (!name[0] || name[0] > 31)
        return 0;
    for (i = 1; i <= name[0]; ++i)
        if (name[i] < 32 || name[i] == 127 || name[i] == ':')
            return 0;
    return 1;
}
static pascal Boolean NewFolderFilter(DialogPtr d, EventRecord *event, short *hit) {
    Handle item, button;
    short kind;
    Rect r;
    Str255 name;
    int valid;
    GetDialogItem(d, 4, &kind, &item, &r);
    GetDialogItemText(item, name);
    valid=FolderNameValid(name);
    GetDialogItem(d, 1, &kind, &button, &r);
    if ((**(ControlHandle)button).contrlHilite != (valid ? 0 : 255))
        HiliteControl((ControlHandle)button, valid ? 0 : 255);
    /* A disabled default otherwise lets Return enter TextEdit as a newline,
       scrolling this single-line field and making the name partly invisible. */
    if(event && (event->what==keyDown || event->what==autoKey) &&
       !(event->modifiers&cmdKey) &&
       ((event->message&charCodeMask)==13 || (event->message&charCodeMask)==3) && !valid) {
        *hit=0;SysBeep(1);return true;
    }
    return event ? NativeDialogFilter(d, event, hit) : false;
}
static int PickerNewFolder(DialogPtr parent, FSSpec *created) {
    DialogPtr d;
    FSSpec container, child;
    CInfoPBRec pb;
    short hit = 0, kind;
    Handle item;
    Str255 name;
    Rect r;
    long directory;
    OSErr error;
    char message[256];
    ModalFilterUPP filter;
    error = CurrentPickerFolder(&container);
    if (error) {
        SysBeep(1);
        return 0;
    }
    memset(&pb, 0, sizeof(pb));
    pb.dirInfo.ioVRefNum = container.vRefNum;
    pb.dirInfo.ioDrDirID = container.parID;
    pb.dirInfo.ioNamePtr = container.name;
    error = PBGetCatInfoSync(&pb);
    if (error) {
        SysBeep(1);
        return 0;
    }
    directory = pb.dirInfo.ioDrDirID;
    d = GetNewDialog(140, NULL, (WindowPtr)-1);
    if (!d)
        return 0;
    filter = NewModalFilterProc(NewFolderFilter);
    if (!filter) {
        DisposeDialog(d);
        return 0;
    }
    PrepareDialogChrome(d,6,7);
    {
        char containerName[64];
        memcpy(containerName,container.name+1,container.name[0]);containerName[container.name[0]]=0;
        snprintf(message,sizeof(message),"Create a folder in \"%s\".",containerName);
        GetDialogItem(d,3,&kind,&item,&r);Pascal(message,name);SetDialogItemText(item,name);
    }
    GetDialogItem(d, 4, &kind, &item, &r);
    SelectDialogItemText(d, 4, 0, 32767);
    PrepareDialog(d, 1, 2);
    NewFolderFilter(d, NULL, NULL);
    while (hit != 1 && hit != 2)
        RunModalDialog(filter, &hit);
    GetDialogItemText(item, name);
    DisposeDialog(d);
    DisposeRoutineDescriptor((UniversalProcPtr)filter);
    SetPort((GrafPtr)parent);
    if (hit != 1)
        return 0;
    if (!FolderNameValid(name)) {
        Message("New Folder", "Use a folder name of 1 to 31 characters, without a colon.");
        return 0;
    }
    error = FSMakeFSSpec(container.vRefNum, directory, name, &child);
    if (error != fnfErr) {
        Message("New Folder", error == noErr ? "A file or folder with this name already exists."
                                             : "The folder name could not be used here.");
        return 0;
    }
    error = DirCreate(container.vRefNum, directory, name, &directory);
    if (error) {
        snprintf(message, sizeof(message),
                 "The new folder could not be created (error %d). Try another name or location.",
                 error);
        Message("New Folder", message);
        return 0;
    }
    *created = child;
    return 1;
}
static pascal short FolderHook(short item, DialogPtr d, Ptr data) {
    GHFolderChoice *state = (GHFolderChoice *)data;
    Handle control;
    short kind;
    Rect r;
    Str255 prompt;
    if (GetWRefCon((WindowPtr)d) != sfMainDialogRefCon)
        return item;
    if (item == sfHookFirstCall) {
        FitDialogToScreen(d);
        state->paintChoice = 1;
        Pascal(state->prompt, prompt);
        GetDialogItem(d, 11, &kind, &control, &r);
        SetDialogItemText(control, prompt);
    }
    if (gDone)
        return sfItemCancelButton;
    if (state->accepted || item == sfHookLastCall)
        return item;
    if (state->selectNewFolder) {
        state->selectNewFolder = 0;
        state->reply.sfFile = state->newFolder;
        state->reply.sfIsFolder = true;
        state->reply.sfIsVolume = false;
        return sfHookChangeSelection;
    }
    /* Apple's directory picker leaves an unchanged idle selection alone. */
    if (item == sfHookNullEvent && state->haveReply &&
        state->previousIsFolder == state->reply.sfIsFolder &&
        state->previousIsVolume == state->reply.sfIsVolume &&
        state->previousReply.vRefNum == state->reply.sfFile.vRefNum &&
        state->previousReply.parID == state->reply.sfFile.parID &&
        state->previousReply.name[0] == state->reply.sfFile.name[0] &&
        !memcmp(state->previousReply.name + 1, state->reply.sfFile.name + 1,
                state->reply.sfFile.name[0])) return item;
    FolderButton(d, state, 0);
    if (item == 10) {
        if (!state->haveSelection)
            return sfHookNullEvent;
        state->accepted = 1;
        return sfItemCancelButton;
    }
    if (item == 12) {
        int made = PickerNewFolder(d, &state->newFolder);
        SetPort(gWindow);
        Draw();
        SetPort((GrafPtr)d);
        state->paintChoice = 1;
        if (made) {
            state->selectNewFolder = 1;
            return sfHookRebuildList;
        }
        return sfHookNullEvent;
    }
    return item;
}
static pascal Boolean FolderKeys(DialogPtr d, EventRecord *event, short *item, Ptr data) {
    GrafPtr saved;
    if(event->what==nullEvent && GetWRefCon((WindowPtr)d)==sfMainDialogRefCon)KeepDialogOnScreen(d);
    /* FirstCall precedes ShowWindow. Paint once after it becomes visible;
       Standard File owns ordinary dialog updates and its private list clips. */
    if (event->what == nullEvent && ((GHFolderChoice *)data)->paintChoice &&
        GetWRefCon((WindowPtr)d) == sfMainDialogRefCon) {
        FolderButton(d, (GHFolderChoice *)data, 1);
        ((GHFolderChoice *)data)->paintChoice = 0;
    }
    if (event->what == updateEvt && (WindowPtr)event->message == gWindow) {
        GetPort(&saved);
        Event(event);
        SetPort(saved);
        return true;
    }
    if (event->what == kHighLevelEvent) {
        AEProcessAppleEvent(event);
        if (gDone) {
            *item = sfItemCancelButton;
            return true;
        }
        return false;
    }
    if (GetWRefCon((WindowPtr)d) == sfMainDialogRefCon && event->what == keyDown &&
        (event->modifiers & cmdKey)) {
        if ((event->message & charCodeMask) == 's') {
            *item = 10;
            return true;
        }
        if ((event->message & charCodeMask) == 'n') {
            *item = 12;
            return true;
        }
    }
    return false;
}
static int ChooseFolderFor(int create, const char *prompt, const char *action, FSSpec *folder) {
    GHFolderChoice state;
    FileFilterYDUPP filter;
    DlgHookYDUPP hook;
    ModalFilterYDUPP keys;
    Point where;
    memset(&state, 0, sizeof(state));
    state.create = create;
    state.prompt = prompt; state.action = action;
    where.h = where.v = -1;
    filter = NewFileFilterYDProc(FolderOnly);
    hook = NewDlgHookYDProc(FolderHook);
    keys = NewModalFilterYDProc(FolderKeys);
    if (!filter || !hook || !keys) {
        if (filter)
            DisposeRoutineDescriptor((UniversalProcPtr)filter);
        if (hook)
            DisposeRoutineDescriptor((UniversalProcPtr)hook);
        if (keys)
            DisposeRoutineDescriptor((UniversalProcPtr)keys);
        SetStatus("There is not enough memory to open the folder picker.");
        return 0;
    }
    ++gModalDepth;
    CustomGetFile(filter, -1, NULL, &state.reply, 139, where, hook, keys, NULL, NULL, (Ptr)&state);
    --gModalDepth;
    DisposeRoutineDescriptor((UniversalProcPtr)filter);
    DisposeRoutineDescriptor((UniversalProcPtr)hook);
    DisposeRoutineDescriptor((UniversalProcPtr)keys);
    if (state.accepted && state.haveSelection)
        *folder = state.selected;
    SetPort(gWindow);
    InvalRect(&gWindow->portRect);
    return state.accepted && state.haveSelection;
}
static int ChooseLocalFolder(int create, FSSpec *folder) {
    return ChooseFolderFor(create,create?"Choose a location for your new repository:":
                           "Choose a repository folder:",create?"Create in":"Choose",folder);
}
