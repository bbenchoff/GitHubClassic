/* Native clean-replay review. Included after branch/merge/network helpers. */
static void EUIRebaseLimits(RQLimits *l) {
    MMLimits merge;NativeMergeLimits(&merge);memset(l,0,sizeof(*l));l->stateBytes=merge.stateBytes;
    l->replay.plan.graph=merge.graph;l->replay.plan.steps=4096;l->replay.step=merge.tree;l->replay.all=merge.tree.read;
    l->replay.all.readBytes=256UL*1024*1024;l->replay.all.reads=131072;
}
static int EUIActive(const FSSpec *folder,const RQReview *review) {
    return gLocal && gWork.haveHead && gWork.branch && !strcmp(gWork.branch,review->branch) && !memcmp(gWork.tip,review->graph.graph.left,20) &&
        gWork.folder.vRefNum==folder->vRefNum && gWork.folder.parID==folder->parID && gWork.folder.name[0]==folder->name[0] && !memcmp(gWork.folder.name,folder->name,folder->name[0]+1);
}
static int EUIConfirm(const FSSpec *folder,const RQReview *review) {
    OperationPrompt prompt;char repository[256],state[620],tip[41],count[80],current[256],target[256];
    memset(&prompt,0,sizeof(prompt));MUIOperationContext(folder,review->branch,review->ontoRef,repository,state,&prompt);GBOIDFormat(review->graph.graph.right,tip);
    LocalDisplayPath(review->branch+11,current);LocalDisplayPath(review->ontoRef+(GSValidTrackingRef(review->ontoRef)?13:11),target);
    snprintf(state,sizeof(state),"Current: %s\rRebase onto: %s",current,target);prompt.labels[1]="Rebase onto";
    snprintf(count,sizeof(count),"%lu committed change%s",(unsigned long)review->graph.count,review->graph.count==1?"":"s");
    prompt.title="Rebase Current Branch";prompt.primary=review->graph.kind==RB_FAST_FORWARD?"Advance Branch":"Rebase";prompt.canPrimary=1;
    prompt.labels[2]="Selected target commit";prompt.values[2]=tip;prompt.labels[3]="Replay candidates";prompt.values[3]=count;
    prompt.primaryText=review->graph.kind==RB_FAST_FORWARD?"Advance the current branch to the selected commit. No commits need rewriting.":
        "Replay committed changes onto the selected branch. This rewrites local commit IDs; rewritten commits are unsigned.";
    prompt.secondaryText="Keep the current branch and working files in place.";
    prompt.footer="Commit or stash staged and unsaved tracked changes first. Conflicts stop in a saved review; the original branch stays in place until completion. Uses local or fetched history; no network request.";
    return OperationConfirm(&prompt)==1;
}
static int EUIProtectionError(const GQError *why) {
    const char *action;char path[256],body[620];
    if(why->reason==GQ_DIRTY)action="Commit or stash unsaved changes before rebasing.";
    else if(why->reason==GQ_STAGED)action="Commit or stash staged changes before rebasing.";
    else if(why->reason==GQ_UNTRACKED)action="Move or save the untracked file that blocks this checkout, then try again.";
    else if(why->reason==GQ_DIRECTORY)action="Move or save the folder that blocks this checkout, then try again.";
    else return 0;
    LocalDisplayPath(why->path,path);
    snprintf(body,sizeof(body),"%s\r\r%s%s%s\r\rThe rebase checkout has not started. Your branch and working files remain in place.",
        action,path[0]?"File: ":"",path,path[0]?"":"Refresh the repository to review its changes.");
    Message("Changes Prevent Rebase",body);return 1;
}
static void RebaseCommand(void) {
    CUIBranches branches;GXRebaseReview *review=NULL;GXRebaseOutcome outcome;RQLimits limits;RLLimits savedLimits;GSRepository reader;GQError why;
    char *chosen=NULL,*branch=NULL,seconds[32],status[300];FSSpec folder;unsigned char head[20],onto[20];
    unsigned long macTime;long delta;MachineLocation location;int result=0,closed,performed=0,fastForward=0,started=0;
    if(!gLocal || gBusy)return;
    if(gRebasePending){if(RebaseManage(&gWork.folder)){gRebasePending=0;LocalRefresh();}else RebasePaused();return;}
    if(gLocalBlocked || gMergePending || !gWork.haveHead)return;
    HiliteMenu(0);LocalRefresh();if(gDone || gLocalBlocked || gMergePending || !gWork.haveHead)return;
    folder=gWork.folder;memset(&branches,0,sizeof(branches));memset(&outcome,0,sizeof(outcome));memset(&why,0,sizeof(why));result=CUILoadNamed(&branches,1);
    if(result)goto failed;chosen=CUIPickNamed(&branches,"Rebase Current Branch");if(!chosen || gDone)goto done;
    review=(GXRebaseReview *)calloc(1,sizeof(*review));if(!review){result=GB_MEMORY;goto failed;}EUIRebaseLimits(&limits);
    result=CheckoutAttach(&folder);if(!result){CheckoutBegin("Reviewing the selected rebase target...");result=GSMacEnter(&gUICheckout.store,0);}
    if(!result){MUIReader(&reader);result=GSHead(&reader,&branch,head);}
    if(!result && (!gLocal || !gWork.branch || strcmp(branch,gWork.branch) || memcmp(head,gWork.tip,20)))result=GS_CONFLICT;
    if(!result)result=GSReadRef(&reader,chosen,onto);
    if(gUICheckout.store.leaseHeld){closed=GSMacLeave(&gUICheckout.store);if(!result)result=closed;}
    if(!result)result=GXRebasePrepare(&gUICheckout,branch,head,chosen,onto,'\n',&limits,review);
    result=MUICloseReader(result);if(result)goto failed;
    if(review->review.graph.kind==RB_UPTODATE){Message("Already Up to Date","The selected target is already included in the current branch. No commits need replaying.");goto done;}
    if(review->review.graph.kind==RB_MULTIPLE_BASES){Message("Rebase Unavailable","These histories have multiple best common ancestors. This rebase has not been started.");goto done;}
    if(review->review.graph.kind==RB_UNRELATED){Message("Unrelated Histories","These branches have no common ancestor. This rebase has not been started.");goto done;}
    if(review->review.graph.kind==RB_MERGE_HISTORY){Message("Merge History Needs Support","The commits to replay include merge history. This version rebases linear histories; it has not started or flattened this history.");goto done;}
    fastForward=review->review.graph.kind==RB_FAST_FORWARD;
    if(!EUIActive(&folder,&review->review)){result=GS_CONFLICT;goto failed;}
    if(gDone || !EUIConfirm(&folder,&review->review))goto done;
    if(review->review.graph.kind==RB_REPLAY && !LocalAuthor(0))goto done;
    if(!EUIActive(&folder,&review->review)){result=GS_CONFLICT;goto failed;}
    GetDateTime(&macTime);ReadLocation(&location);delta=location.u.gmtDelta&0x00ffffffL;if(delta&0x00800000L)delta|=0xff000000L;
    snprintf(seconds,sizeof(seconds),"%lu",macTime-delta-2082844800UL);result=CheckoutAttach(&folder);
    if(!result){CheckoutBegin("Replaying local commits... Escape stops at a recoverable checkpoint.");performed=1;result=GXRebaseApply(&gUICheckout,review,gLocalIdentity,seconds,"+0000",&why,&outcome);}
    result=MUICloseReader(result);if(result)goto failed;
    if(outcome.kind==RQ_CONFLICT) {
        ERLimits(&savedLimits);result=CheckoutAttach(&folder);
        if(!result){CheckoutBegin("Saving a recoverable rebase review...");result=GXRebaseBegin(&gUICheckout,review,gLocalIdentity,seconds,"+0000",&savedLimits,&why,&started);}
        result=MUICloseReader(result);if(result)goto failed;
        if(!started){result=GS_CONFLICT;goto failed;}
    } else if(outcome.kind==RQ_POLICY)Message("Rebase Not Started","The selected history needs a replay policy that is not supported yet. The branch and working files remain in place.");
    goto done;
failed:
    if(result==GS_CONFLICT && performed && EUIProtectionError(&why)){}
    else if(result==GS_CONFLICT && !performed)Message("Rebase Could Not Start","The repository changed after selection, or staged or unsaved changes prevent a clean replay. Commit or stash changes, refresh the repository, and choose the target again.");
    else CheckoutError("Rebase Branch",result);
done:
    if(gUICheckout.store.leaseHeld || gUICheckout.state)result=MUICloseReader(result);
    free(branch);CUIFree(&branches);if(review){GXRebaseReviewFree(review);free(review);}
    if(!gDone)LocalRefresh();
    if(!gDone && started && gRebasePending)SetStatus("Rebase paused. Choose Branch > Rebase or Refresh to resolve conflicts, Continue or Abort.");
    if(!gDone && performed && !result && outcome.advanced){
        if(fastForward)SetStatus("Branch advanced to the selected commit. No commits were rewritten.");
        else {snprintf(status,sizeof(status),"Rebased locally: %lu replay candidate%s processed.%s",(unsigned long)outcome.completed,outcome.completed==1?"":"s",outcome.droppedSignatures?" Old commit signatures were removed.":"");SetStatus(status);}
    }
}
