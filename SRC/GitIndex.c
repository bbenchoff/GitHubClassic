#include "GitIndex.h"
#include <stdlib.h>
#include <string.h>

static GBWord GIWord(const unsigned char *p) {
    return ((GBWord)p[0] << 24) | ((GBWord)p[1] << 16) | ((GBWord)p[2] << 8) | p[3];
}
static void GIPut(unsigned char *p, GBWord n) {
    p[0] = (unsigned char)(n >> 24);
    p[1] = (unsigned char)(n >> 16);
    p[2] = (unsigned char)(n >> 8);
    p[3] = (unsigned char)n;
}
static char *GIString(const char *p, size_t n) {
    char *s;
    if (n == (size_t)-1)
        return NULL;
    s = (char *)malloc(n + 1);
    if (s) {
        memcpy(s, p, n);
        s[n] = 0;
    }
    return s;
}
void GIInit(GIIndex *index) { memset(index, 0, sizeof(*index)); }
void GIFree(GIIndex *index) {
    size_t i;
    for (i = 0; i < index->count; ++i)
        free(index->entries[i].path);
    free(index->entries);
    free(index->original);
    GIInit(index);
}
int GIValidPath(const char *path) {
    const char *p, *start;
    size_t n;
    if (!path || !path[0])
        return 0;
    p = start = path;
    for (;; ++p)
        if (!*p || *p == '/') {
            n = (size_t)(p - start);
            if (!n || (n == 1 && start[0] == '.') || (n == 2 && !memcmp(start, "..", 2)) ||
                (n == 4 && (start[0] == '.') && (start[1] == 'g' || start[1] == 'G') &&
                 (start[2] == 'i' || start[2] == 'I') && (start[3] == 't' || start[3] == 'T')))
                return 0;
            if (!*p)
                return 1;
            start = p + 1;
        }
}
static int GIStage(const GIEntry *e) { return (e->flags >> 12) & 3; }
static int GIOrder(const void *a, const void *b) {
    const GIEntry *x = (const GIEntry *)a, *y = (const GIEntry *)b;
    int order = strcmp(x->path, y->path);
    return order ? order : GIStage(x) - GIStage(y);
}
static int GIMode(GBWord mode) {
    return mode == 0100644 || mode == 0100755 || mode == 0120000 || mode == 0160000;
}
static int GIValidate(const GIIndex *index) {
    size_t i, j, n;
    int stage, last;
    for (i = 0; i < index->count; ++i) {
        if (!GIValidPath(index->entries[i].path) || !GIMode(index->entries[i].stat[6]) ||
            (index->entries[i].extended & ~0x6000U))
            return GB_BAD;
        if (i && GIOrder(index->entries + i - 1, index->entries + i) >= 0)
            return GB_BAD;
        stage = GIStage(index->entries + i);
        if (i && !strcmp(index->entries[i - 1].path, index->entries[i].path)) {
            last = GIStage(index->entries + i - 1);
            if (!last || !stage)
                return GB_BAD;
        }
        /* Check the nearest earlier ancestor using binary search per slash;
           conflict stages still must not create a file/directory overlap. */
        n = strlen(index->entries[i].path);
        for (j = 0; j < n; ++j)
            if (index->entries[i].path[j] == '/') {
                size_t lo = 0, hi = i, mid;
                int cmp;
                while (lo < hi) {
                    mid = lo + (hi - lo) / 2;
                    cmp = strncmp(index->entries[mid].path, index->entries[i].path, j);
                    if (!cmp && index->entries[mid].path[j])
                        cmp = 1;
                    if (cmp < 0)
                        lo = mid + 1;
                    else
                        hi = mid;
                }
                while (lo < i && strlen(index->entries[lo].path) == j &&
                       !memcmp(index->entries[lo].path, index->entries[i].path, j)) {
                    if (GIStage(index->entries + lo) == stage)
                        return GB_BAD;
                    ++lo;
                }
            }
    }
    return 0;
}
int GIParse(const void *data, size_t length, GIIndex *destination) {
    const unsigned char *p = (const unsigned char *)data, *end, *nul;
    GIIndex index;
    GBSHA1 hash;
    unsigned char digest[20];
    size_t count, i, j, pos = 12, start, n, strip, previousLength;
    GBWord version;
    unsigned byte;
    GIEntry *e;
    int result = GB_BAD;
    if (!p || !destination || length < 32 || memcmp(p, "DIRC", 4))
        return GB_BAD;
    version = GIWord(p + 4);
    if (version < 2 || version > 4)
        return GI_UNSUPPORTED;
    GBSHA1Start(&hash);
    GBSHA1Update(&hash, p, length - 20);
    GBSHA1Finish(&hash, digest);
    if (memcmp(digest, p + length - 20, 20))
        return GB_CHECKSUM;
    count = GIWord(p + 8);
    end = p + length - 20;
    if (count > (size_t)(end - p - 12) / 63 || count > (size_t)-1 / sizeof(GIEntry))
        return GB_BAD;
    GIInit(&index);
    index.entries = (GIEntry *)calloc(count ? count : 1, sizeof(GIEntry));
    if (!index.entries)
        return GB_MEMORY;
    index.count = count;
    for (i = 0; i < count; ++i) {
        if ((size_t)(end - p) - pos < 62)
            goto done;
        start = pos;
        e = index.entries + i;
        for (j = 0; j < 10; ++j)
            e->stat[j] = GIWord(p + pos + j * 4);
        memcpy(e->oid, p + pos + 40, 20);
        e->flags = (unsigned short)(p[pos + 60] * 256U + p[pos + 61]);
        pos += 62;
        if (e->flags & 0x4000) {
            if (version == 2 || (size_t)(end - p) - pos < 2)
                goto done;
            e->extended = (unsigned short)(p[pos] * 256U + p[pos + 1]);
            pos += 2;
        }
        strip = 0;
        if (version == 4) {
            if (p + pos == end)
                goto done;
            byte = p[pos++];
            strip = byte & 127;
            while (byte & 128) {
                if (p + pos == end || strip > ((size_t)-1 >> 7) - 1)
                    goto done;
                byte = p[pos++];
                strip = ((strip + 1) << 7) | (byte & 127);
            }
        }
        nul = (const unsigned char *)memchr(p + pos, 0, (size_t)(end - p) - pos);
        if (!nul)
            goto done;
        n = (size_t)(nul - p - pos);
        previousLength = i ? strlen(index.entries[i - 1].path) : 0;
        if (version == 4) {
            if (strip > previousLength || n > (size_t)-1 - (previousLength - strip))
                goto done;
            previousLength -= strip;
        } else
            previousLength = 0;
        e->path = (char *)malloc(previousLength + n + 1);
        if (!e->path) {
            result = GB_MEMORY;
            goto done;
        }
        if (previousLength)
            memcpy(e->path, index.entries[i - 1].path, previousLength);
        memcpy(e->path + previousLength, p + pos, n + 1);
        pos += (n + 1);
        n += previousLength;
        if ((e->flags & 4095) != (n < 4095 ? n : 4095))
            goto done;
        if (version < 4) {
            while ((pos - start) % 8) {
                if (p + pos == end || p[pos++])
                    goto done;
            }
        }
    }
    while (p + pos < end) {
        if ((size_t)(end - p) - pos < 8)
            goto done;
        if (p[pos] < 'A' || p[pos] > 'Z') {
            result = GI_UNSUPPORTED;
            goto done;
        }
        n = GIWord(p + pos + 4);
        pos += 8;
        if (n > (size_t)(end - p) - pos)
            goto done;
        pos += n;
    }
    result = GIValidate(&index);
    if (result)
        goto done;
    index.original = (unsigned char *)malloc(length);
    if (!index.original) {
        result = GB_MEMORY;
        goto done;
    }
    memcpy(index.original, p, length);
    index.originalLength = length;
    GIFree(destination);
    *destination = index;
    return 0;
done:
    GIFree(&index);
    return result;
}
int GIEncode(const GIIndex *index, unsigned char **output, size_t *length) {
    size_t i, j, n, entryLength, total = 32, pos = 12;
    GBWord version = 2;
    unsigned short flags;
    unsigned char *p;
    GBSHA1 hash;
    int result;
    if (!index || !output || !length || index->count > 0xffffffffU)
        return GB_BAD;
    *output = NULL;
    *length = 0;
    result = GIValidate(index);
    if (result)
        return result;
    for (i = 0; i < index->count; ++i) {
        if (index->entries[i].extended)
            version = 3;
        n = strlen(index->entries[i].path);
        if (n > (size_t)-1 - 72)
            return GB_SPACE;
        entryLength = (62 + (index->entries[i].extended ? 2 : 0) + n + 8) & ~(size_t)7;
        if (total > (size_t)-1 - entryLength)
            return GB_SPACE;
        total += entryLength;
    }
    p = (unsigned char *)calloc(1, total);
    if (!p)
        return GB_MEMORY;
    memcpy(p, "DIRC", 4);
    GIPut(p + 4, version);
    GIPut(p + 8, (GBWord)index->count);
    for (i = 0; i < index->count; ++i) {
        const GIEntry *e = index->entries + i;
        n = strlen(e->path);
        for (j = 0; j < 10; ++j)
            GIPut(p + pos + j * 4, e->stat[j]);
        memcpy(p + pos + 40, e->oid, 20);
        flags = (unsigned short)((e->flags & 0xb000) | (e->extended ? 0x4000 : 0) |
                                 (n < 4095 ? n : 4095));
        p[pos + 60] = (unsigned char)(flags >> 8);
        p[pos + 61] = (unsigned char)flags;
        entryLength = 62;
        if (e->extended) {
            p[pos + 62] = (unsigned char)(e->extended >> 8);
            p[pos + 63] = (unsigned char)e->extended;
            entryLength += 2;
        }
        memcpy(p + pos + entryLength, e->path, n);
        entryLength = (entryLength + n + 8) & ~(size_t)7;
        pos += entryLength;
    }
    GBSHA1Start(&hash);
    GBSHA1Update(&hash, p, pos);
    GBSHA1Finish(&hash, p + pos);
    *output = p;
    *length = total;
    return 0;
}
int GILoad(GSRepository *r, GIIndex *index) {
    unsigned char *bytes;
    size_t n;
    int result;
    if (!r || !r->read || !index)
        return GB_BAD;
    result = r->read(r->context, "index", &bytes, &n);
    if (result == GS_NOT_FOUND) {
        GIFree(index);
        return 0;
    }
    if (result)
        return result;
    result = GIParse(bytes, n, index);
    free(bytes);
    return result;
}
int GISave(GSRepository *r, GIIndex *index) {
    unsigned char *bytes;
    size_t n;
    int result;
    if (!r || !r->replace || !index)
        return GB_BAD;
    result = GIEncode(index, &bytes, &n);
    if (result)
        return result;
    result = r->replace(r->context, "index", index->original, index->originalLength, bytes, n);
    if (result) {
        free(bytes);
        return result;
    }
    free(index->original);
    index->original = bytes;
    index->originalLength = n;
    return 0;
}
const GIEntry *GIFind(const GIIndex *index, const char *path, int stage) {
    size_t lo = 0, hi = index->count, mid;
    int cmp;
    if (!path || stage < 0 || stage > 3)
        return NULL;
    while (lo < hi) {
        mid = lo + (hi - lo) / 2;
        cmp = strcmp(index->entries[mid].path, path);
        if (!cmp)
            cmp = GIStage(index->entries + mid) - stage;
        if (cmp < 0)
            lo = mid + 1;
        else
            hi = mid;
    }
    return lo < index->count && !strcmp(index->entries[lo].path, path) &&
                   GIStage(index->entries + lo) == stage
               ? index->entries + lo
               : NULL;
}
int GIRemove(GIIndex *index, const char *path) {
    size_t i, first = 0, end;
    if (!index || !GIValidPath(path))
        return GB_BAD;
    while (first < index->count && strcmp(index->entries[first].path, path))
        ++first;
    end = first;
    while (end < index->count && !strcmp(index->entries[end].path, path))
        ++end;
    if (first == end)
        return 0;
    for (i = first; i < end; ++i)
        free(index->entries[i].path);
    memmove(index->entries + first, index->entries + end,
            (index->count - end) * sizeof(*index->entries));
    index->count -= end - first;
    return 0;
}
int GISet(GIIndex *index, const char *path, GBWord mode, const unsigned char oid[20], GBWord size) {
    GIEntry *entries, *e;
    unsigned char copyOID[20];
    char *copy;
    size_t i, n, m;
    if (!index || !GIValidPath(path) || !oid || !GIMode(mode))
        return GB_BAD;
    n = strlen(path);
    memcpy(copyOID, oid, 20);
    for (i = 0; i < index->count; ++i) {
        m = strlen(index->entries[i].path);
        if ((m < n && path[m] == '/' && !memcmp(path, index->entries[i].path, m)) ||
            (n < m && index->entries[i].path[n] == '/' && !memcmp(path, index->entries[i].path, n)))
            return GS_CONFLICT;
    }
    copy = GIString(path, n);
    if (!copy)
        return GB_MEMORY;
    if (index->count >= (size_t)-1 / sizeof(*entries)) {
        free(copy);
        return GB_SPACE;
    }
    entries = (GIEntry *)realloc(index->entries, (index->count + 1) * sizeof(*entries));
    if (!entries) {
        free(copy);
        return GB_MEMORY;
    }
    index->entries = entries;
    GIRemove(index, copy);
    e = entries + index->count++;
    memset(e, 0, sizeof(*e));
    e->path = copy;
    e->stat[6] = mode;
    e->stat[9] = size;
    memcpy(e->oid, copyOID, 20);
    qsort(index->entries, index->count, sizeof(*entries), GIOrder);
    return 0;
}
int GIStageBlob(GSRepository *r, GIIndex *index, const char *path, GBWord mode, const void *bytes,
                size_t length) {
    unsigned char oid[20];
    int result;
    if (!GIValidPath(path) || !GIMode(mode))
        return GB_BAD;
    result = GSPutObject(r, "blob", bytes, length, oid);
    return result ? result : GISet(index, path, mode, oid, (GBWord)length);
}

typedef struct {
    size_t prefix, pos, end, count;
    GSTreeEntry *children;
    char *name;
} GIFrame;
static void GIFrameFree(GIFrame *f) {
    size_t i;
    for (i = 0; i < f->count; ++i)
        free((char *)f->children[i].name);
    free(f->children);
    free(f->name);
    memset(f, 0, sizeof(*f));
}
static int GIChild(GIFrame *f, const char *name, size_t n, GBWord mode,
                   const unsigned char oid[20]) {
    GSTreeEntry *children;
    char *copy;
    if (f->count >= (size_t)-1 / sizeof(*children))
        return GB_SPACE;
    copy = GIString(name, n);
    if (!copy)
        return GB_MEMORY;
    children = (GSTreeEntry *)realloc(f->children, (f->count + 1) * sizeof(*children));
    if (!children) {
        free(copy);
        return GB_MEMORY;
    }
    f->children = children;
    children += f->count++;
    children->name = copy;
    children->mode = mode;
    memcpy(children->oid, oid, 20);
    return 0;
}
int GIWriteTree(GSRepository *r, const GIIndex *index, unsigned char oid[20]) {
    GIFrame *stack, *f, *child;
    size_t i, j, maxDepth = 1, depth = 0, slashCount, n, end;
    const char *name, *slash;
    unsigned char tree[20];
    int result;
    if (!r || !index || !oid)
        return GB_BAD;
    result = GIValidate(index);
    if (result)
        return result;
    for (i = 0; i < index->count; ++i) {
        if (GIStage(index->entries + i))
            return GI_UNMERGED;
        slashCount = 1;
        for (name = index->entries[i].path; *name; ++name)
            if (*name == '/')
                ++slashCount;
        if (slashCount > maxDepth)
            maxDepth = slashCount;
    }
    if (maxDepth > (size_t)-1 / sizeof(*stack))
        return GB_SPACE;
    stack = (GIFrame *)calloc(maxDepth, sizeof(*stack));
    if (!stack)
        return GB_MEMORY;
    stack[0].end = index->count;
    for (;;) {
        f = stack + depth;
        if (f->pos == f->end) {
            result = 0;
            if (f->count || !depth)
                result = GSWriteTree(r, f->children, f->count, tree);
            if (!result && depth && f->count)
                result = GIChild(f - 1, f->name, strlen(f->name), 040000, tree);
            GIFrameFree(f);
            if (result || !depth)
                break;
            --depth;
            continue;
        }
        i = f->pos;
        name = index->entries[i].path + f->prefix;
        slash = strchr(name, '/');
        if (index->entries[i].extended & 0x2000U) {
            ++f->pos;
            continue;
        }
        if (!slash) {
            result =
                GIChild(f, name, strlen(name), index->entries[i].stat[6], index->entries[i].oid);
            if (result)
                break;
            ++f->pos;
            continue;
        }
        n = (size_t)(slash - name);
        end = i + 1;
        while (end < f->end &&
               !strncmp(index->entries[end].path, index->entries[i].path, f->prefix + n + 1))
            ++end;
        f->pos = end;
        child = stack + (++depth);
        child->prefix = f->prefix + n + 1;
        child->pos = i;
        child->end = end;
        child->name = GIString(name, n);
        if (!child->name) {
            result = GB_MEMORY;
            break;
        }
    }
    if (!result)
        memcpy(oid, tree, 20);
    for (j = 0; j < maxDepth; ++j)
        GIFrameFree(stack + j);
    free(stack);
    return result;
}

typedef struct {
    unsigned char *bytes;
    size_t length, pos, previous, nameLength;
    GBWord previousMode;
    char *prefix;
} GIReadFrame;
int GIReadTreeBounded(GSRepository *r, const unsigned char oid[20], GIIndex *destination,
                       const GIReadLimits *limits) {
    GIIndex index;
    GIReadFrame *stack = NULL, *f;
    size_t depth = 0, count = 0, i, start, n, prefixLength, visited = 0, common;
    char type[7], *path;
    GBWord mode;
    unsigned char childOID[20];
    int result, order, a, b;
    if (!r || !oid || !destination)
        return GB_BAD;
    if (limits && (!limits->entries || !limits->pathBytes)) return GB_BAD;
    GIInit(&index);
    stack = (GIReadFrame *)calloc(1, sizeof(*stack));
    if (!stack)
        return GB_MEMORY;
    count = 1;
    result = GSGetObject(r, oid, type, &stack[0].bytes, &stack[0].length);
    if (result)
        goto done;
    if (strcmp(type, "tree")) {
        result = GS_FORMAT;
        goto done;
    }
    stack[0].prefix = GIString("", 0);
    if (!stack[0].prefix) {
        result = GB_MEMORY;
        goto done;
    }
    for (;;) {
        f = stack + depth;
        if (f->pos == f->length) {
            free(f->bytes);
            free(f->prefix);
            memset(f, 0, sizeof(*f));
            if (!depth)
                break;
            --depth;
            continue;
        }
        if (limits) {
            if (visited == limits->entries) { result = GB_SPACE; goto done; }
            ++visited;
            if (limits->progress && (result = limits->progress(limits->context)) != 0) goto done;
        }
        mode = 0;
        i = f->pos;
        while (i < f->length && f->bytes[i] != ' ') {
            if (f->bytes[i] < '0' || f->bytes[i] > '7' || mode > 0177777U) {
                result = GS_FORMAT;
                goto done;
            }
            mode = (mode << 3) + f->bytes[i++] - '0';
        }
        if (i == f->length || i == f->pos) {
            result = GS_FORMAT;
            goto done;
        }
        start = ++i;
        if (limits && !((mode == 040000 && start - f->pos == 6 && f->bytes[f->pos] == '4') ||
                         (GIMode(mode) && start - f->pos == 7 && f->bytes[f->pos] == '1'))) {
            result = GS_FORMAT; goto done;
        }
        while (i < f->length && f->bytes[i])
            ++i;
        if (i == f->length || f->length - i - 1 < 20 || i == start ||
            memchr(f->bytes + start, '/', i - start)) {
            result = GS_FORMAT;
            goto done;
        }
        n = i - start;
        if (limits && f->nameLength) {
            common = n < f->nameLength ? n : f->nameLength;
            order = memcmp(f->bytes + f->previous, f->bytes + start, common);
            if (!order) {
                if (n == f->nameLength) { result = GS_FORMAT; goto done; }
                a = common < f->nameLength ? f->bytes[f->previous + common] : f->previousMode == 040000 ? '/' : 0;
                b = common < n ? f->bytes[start + common] : mode == 040000 ? '/' : 0;
                order = a - b;
            }
            if (order >= 0) { result = GS_FORMAT; goto done; }
        }
        f->previous = start; f->nameLength = n; f->previousMode = mode;
        prefixLength = strlen(f->prefix);
        if (prefixLength > (size_t)-1 - n - 2) {
            result = GB_SPACE;
            goto done;
        }
        if (limits && prefixLength + n > limits->pathBytes) { result = GB_SPACE; goto done; }
        path = (char *)malloc(prefixLength + n + 2);
        if (!path) {
            result = GB_MEMORY;
            goto done;
        }
        memcpy(path, f->prefix, prefixLength);
        memcpy(path + prefixLength, f->bytes + start, n);
        path[prefixLength + n] = 0;
        memcpy(childOID, f->bytes + i + 1, 20);
        f->pos = i + 21;
        if (!GIValidPath(path)) {
            free(path);
            result = GS_FORMAT;
            goto done;
        }
        if (mode == 040000) {
            if (limits && depth >= limits->depth) { free(path); result = GB_SPACE; goto done; }
            path[prefixLength + n] = '/';
            path[prefixLength + n + 1] = 0;
            if (depth + 1 == count) {
                GIReadFrame *grown;
                if (count == (size_t)-1 / sizeof(*stack)) {
                    free(path);
                    result = GB_SPACE;
                    goto done;
                }
                grown = (GIReadFrame *)realloc(stack, (count + 1) * sizeof(*stack));
                if (!grown) {
                    free(path);
                    result = GB_MEMORY;
                    goto done;
                }
                stack = grown;
                memset(stack + count, 0, sizeof(*stack));
                ++count;
            }
            f = stack + (++depth);
            f->prefix = path;
            result = GSGetObject(r, childOID, type, &f->bytes, &f->length);
            if (result)
                goto done;
            if (strcmp(type, "tree")) {
                result = GS_FORMAT;
                goto done;
            }
        } else {
            /* Duplicate tree entries must not silently replace earlier entries. */
            if (GIFind(&index, path, 0)) {
                free(path);
                result = GS_FORMAT;
                goto done;
            }
            result = GISet(&index, path, mode, childOID, 0);
            free(path);
            if (result)
                goto done;
        }
    }
    GIFree(destination);
    *destination = index;
    GIInit(&index);
    result = 0;
done:
    for (i = 0; i < count; ++i) {
        free(stack[i].bytes);
        free(stack[i].prefix);
    }
    free(stack);
    GIFree(&index);
    return result;
}
int GIReadTree(GSRepository *r, const unsigned char oid[20], GIIndex *destination) {
    return GIReadTreeBounded(r, oid, destination, NULL);
}
int GIReadHead(GSRepository *r, GIIndex *index, unsigned char tip[20], int *haveHead) {
    char *branch = NULL, type[7], hex[41];
    unsigned char *commit, tree[20];
    size_t n;
    int result;
    if (!haveHead)
        return GB_BAD;
    *haveHead = 0;
    result = GSHead(r, &branch, tip);
    free(branch);
    if (result == GS_NOT_FOUND) {
        GIFree(index);
        return 0;
    }
    if (result)
        return result;
    result = GSGetObject(r, tip, type, &commit, &n);
    if (result)
        return result;
    if (strcmp(type, "commit") || n < 46 || memcmp(commit, "tree ", 5) || commit[45] != '\n') {
        free(commit);
        return GS_FORMAT;
    }
    memcpy(hex, commit + 5, 40);
    hex[40] = 0;
    free(commit);
    result = GBOIDParse(hex, tree);
    if (!result)
        result = GIReadTree(r, tree, index);
    if (!result)
        *haveHead = 1;
    return result;
}

static const char giMacVersion[] =
    "GHClient Macintosh forks 1\nmetadata GHMETA01 + path + AppleDouble\n";
const char *GIMacVersion(size_t *length) {
    if (length) *length = sizeof(giMacVersion) - 1;
    return giMacVersion;
}
int GIMacMetadataPath(const char *path, char output[96]) {
    GBSHA1 hash;
    unsigned char digest[20];
    char hex[41];
    size_t n = strlen(GI_MAC_NAMESPACE);
    if (!GIValidPath(path) || !output || !strncmp(path, GI_MAC_NAMESPACE "/", n + 1) ||
        !strcmp(path, GI_MAC_NAMESPACE))
        return GB_BAD;
    GBSHA1Start(&hash);
    GBSHA1Update(&hash, path, strlen(path));
    GBSHA1Finish(&hash, digest);
    GBOIDFormat(digest, hex);
    memcpy(output, GI_MAC_NAMESPACE "/forks/", n + 7);
    memcpy(output + n + 7, hex, 2);
    output[n + 9] = '/';
    memcpy(output + n + 10, hex + 2, 12);
    output[n + 22] = '/';
    memcpy(output + n + 23, hex + 14, 26);
    output[n + 49] = 0;
    return 0;
}
int GIMacDecode(const void *input, size_t length, char **path, unsigned char info[32],
                const unsigned char **resource, size_t *resourceLength) {
    const unsigned char *p = (const unsigned char *)input;
    size_t n;
    char *name;
    int result;
    if (!path || !info || !resource || !resourceLength)
        return GB_BAD;
    *path = NULL;
    *resource = NULL;
    *resourceLength = 0;
    if (!p || length < 12 || memcmp(p, "GHMETA01", 8))
        return GB_BAD;
    n = GIWord(p + 8);
    if (n > length - 12 || memchr(p + 12, 0, n))
        return GB_BAD;
    name = GIString((const char *)p + 12, n);
    if (!name)
        return GB_MEMORY;
    if (!GIValidPath(name)) {
        free(name);
        return GB_BAD;
    }
    result = GBForkDecode(p + 12 + n, length - 12 - n, info, resource, resourceLength);
    if (result) {
        free(name);
        return result;
    }
    *path = name;
    return 0;
}
static int GICopy(const GIIndex *source, GIIndex *target) {
    size_t i;
    GIInit(target);
    if (source->count > (size_t)-1 / sizeof(*target->entries))
        return GB_SPACE;
    target->entries =
        (GIEntry *)calloc(source->count ? source->count : 1, sizeof(*target->entries));
    if (!target->entries)
        return GB_MEMORY;
    target->count = source->count;
    for (i = 0; i < source->count; ++i) {
        target->entries[i] = source->entries[i];
        target->entries[i].path =
            GIString(source->entries[i].path, strlen(source->entries[i].path));
        if (!target->entries[i].path) {
            GIFree(target);
            return GB_MEMORY;
        }
    }
    return 0;
}
static void GIReplaceEntries(GIIndex *target, GIIndex *source) {
    size_t i;
    for (i = 0; i < target->count; ++i)
        free(target->entries[i].path);
    free(target->entries);
    target->entries = source->entries;
    target->count = source->count;
    source->entries = NULL;
    source->count = 0;
}
int GIValidateMacNamespace(GSRepository *r, const GIIndex *index) {
    const GIEntry *version = GIFind(index, GI_MAC_NAMESPACE "/version", 0);
    size_t i, n;
    char type[7];
    unsigned char *bytes;
    int result;
    if (!version) {
        for (i = 0; i < index->count; ++i)
            if (!strncmp(index->entries[i].path, GI_MAC_NAMESPACE, strlen(GI_MAC_NAMESPACE)) &&
                (index->entries[i].path[strlen(GI_MAC_NAMESPACE)] == '/' ||
                 index->entries[i].path[strlen(GI_MAC_NAMESPACE)] == 0))
                return GS_CONFLICT;
        return 0;
    }
    result = GSGetObject(r, version->oid, type, &bytes, &n);
    if (result)
        return result;
    result = strcmp(type, "blob") || n != sizeof(giMacVersion) - 1 || memcmp(bytes, giMacVersion, n)
                 ? GS_CONFLICT
                 : 0;
    free(bytes);
    return result;
}
int GIMacEncode(const char *path, const unsigned char info[32], const void *resource,
                size_t resourceLength, unsigned char **output, size_t *outputLength) {
    unsigned char *apple, *metadata;
    size_t appleLength, pathLength, total;
    char checked[96];
    int result;
    if (!output || !outputLength || !info)
        return GB_BAD;
    *output = NULL;
    *outputLength = 0;
    result = GIMacMetadataPath(path, checked);
    if (result)
        return result;
    result = GBForkEncode(info, resource, resourceLength, &apple, &appleLength);
    if (result)
        return result;
    pathLength = strlen(path);
    if (pathLength > 0xffffffffU || pathLength > (size_t)-1 - 12 ||
        appleLength > (size_t)-1 - 12 - pathLength) {
        free(apple);
        return GB_SPACE;
    }
    total = 12 + pathLength + appleLength;
    metadata = (unsigned char *)malloc(total);
    if (!metadata) {
        free(apple);
        return GB_MEMORY;
    }
    memcpy(metadata, "GHMETA01", 8);
    GIPut(metadata + 8, (GBWord)pathLength);
    memcpy(metadata + 12, path, pathLength);
    memcpy(metadata + 12 + pathLength, apple, appleLength);
    free(apple);
    *output = metadata;
    *outputLength = total;
    return 0;
}
int GIStageMacMode(GSRepository *r, GIIndex *index, const char *path, GBWord mode, const void *data, size_t length,
               const unsigned char info[32], const void *resource, size_t resourceLength) {
    GIIndex next;
    char metadataPath[96];
    unsigned char *metadata;
    size_t total;
    unsigned char dataOID[20], metadataOID[20], versionOID[20];
    const GIEntry *old;
    char type[7], *oldPath;
    unsigned char *oldBytes, oldInfo[32];
    const unsigned char *oldResource;
    size_t oldLength, oldResourceLength;
    int result;
    if (!r || !index || !info || (!data && length) || (!resource && resourceLength) ||
        (mode != 0100644 && mode != 0100755))
        return GB_BAD;
    result = GIMacMetadataPath(path, metadataPath);
    if (result)
        return result;
    result = GIValidateMacNamespace(r, index);
    if (result)
        return result;
    old = GIFind(index, metadataPath, 0);
    if (old) {
        result = GSGetObject(r, old->oid, type, &oldBytes, &oldLength);
        if (result)
            return result;
        result =
            GIMacDecode(oldBytes, oldLength, &oldPath, oldInfo, &oldResource, &oldResourceLength);
        if (!result) {
            if (strcmp(oldPath, path))
                result = GS_CONFLICT;
            free(oldPath);
        }
        free(oldBytes);
        if (result)
            return result;
    }
    old = GIFind(index, path, 0);
    if (old) {
        if (old->stat[6] != 0100644 && old->stat[6] != 0100755)
            return GI_UNSUPPORTED;
    }
    result = GIMacEncode(path, info, resource, resourceLength, &metadata, &total);
    if (result)
        return result;
    result = GSPutObject(r, "blob", data, length, dataOID);
    if (!result)
        result = GSPutObject(r, "blob", metadata, total, metadataOID);
    free(metadata);
    if (!result)
        result = GSPutObject(r, "blob", giMacVersion, sizeof(giMacVersion) - 1, versionOID);
    if (result)
        return result;
    result = GICopy(index, &next);
    if (result)
        return result;
    result = GISet(&next, path, mode, dataOID, (GBWord)length);
    if (!result)
        result = GISet(&next, metadataPath, 0100644, metadataOID, (GBWord)total);
    if (!result)
        result = GISet(&next, GI_MAC_NAMESPACE "/version", 0100644, versionOID,
                       (GBWord)(sizeof(giMacVersion) - 1));
    if (!result)
        GIReplaceEntries(index, &next);
    GIFree(&next);
    return result;
}
int GIStageMac(GSRepository *r, GIIndex *index, const char *path, const void *data, size_t length,
               const unsigned char info[32], const void *resource, size_t resourceLength) {
    const GIEntry *old;
    if (!index || !GIValidPath(path)) return GB_BAD;
    old = GIFind(index, path, 0);
    return GIStageMacMode(r, index, path, old ? old->stat[6] : 0100644, data, length, info,
                          resource, resourceLength);
}
int GIRemoveMac(GIIndex *index, const char *path) {
    char metadata[96];
    int result = GIMacMetadataPath(path, metadata);
    if (result)
        return result;
    GIRemove(index, path);
    return GIRemove(index, metadata);
}
int GIUnstageMac(GIIndex *index, const GIIndex *head, const char *path) {
    GIIndex next;
    char metadata[96];
    const GIEntry *entry;
    size_t i;
    int haveForks = 0, result;
    if (!index || !head)
        return GB_BAD;
    result = GIMacMetadataPath(path, metadata);
    if (result)
        return result;
    result = GICopy(index, &next);
    if (result)
        return result;
    GIRemoveMac(&next, path);
    entry = GIFind(head, path, 0);
    if (entry)
        result = GISet(&next, path, entry->stat[6], entry->oid, entry->stat[9]);
    entry = GIFind(head, metadata, 0);
    if (!result && entry)
        result = GISet(&next, metadata, entry->stat[6], entry->oid, entry->stat[9]);
    if (!result) {
        for (i = 0; i < next.count; ++i)
            if (!strncmp(next.entries[i].path, GI_MAC_NAMESPACE "/forks/",
                         strlen(GI_MAC_NAMESPACE "/forks/")))
                haveForks = 1;
        if (!haveForks) {
            entry = GIFind(head, GI_MAC_NAMESPACE "/version", 0);
            if (entry)
                result = GISet(&next, entry->path, entry->stat[6], entry->oid, entry->stat[9]);
            else
                GIRemove(&next, GI_MAC_NAMESPACE "/version");
        }
    }
    if (!result)
        GIReplaceEntries(index, &next);
    GIFree(&next);
    return result;
}
