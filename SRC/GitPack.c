#include "GitPack.h"
#include <stdlib.h>
#include <string.h>

typedef struct {
    size_t offset, base, length, depth;
    unsigned char baseID[20], oid[20];
    unsigned char *body;
    int kind, resolved;
    const char *type;
} GKEntry;
static GBWord GKWord(const unsigned char *p) {
    return ((GBWord)p[0] << 24) | ((GBWord)p[1] << 16) | ((GBWord)p[2] << 8) | p[3];
}
static const char *GKType(int kind) {
    switch (kind) {
    case 1: return "commit";
    case 2: return "tree";
    case 3: return "blob";
    case 4: return "tag";
    default: return NULL;
    }
}
static int GKVar(const unsigned char *p, size_t n, size_t *at, size_t *value) {
    size_t shift = 0, x = 0, part;
    unsigned char c;
    do {
        if (*at == n || shift >= sizeof(size_t) * CHAR_BIT)
            return GB_BAD;
        c = p[(*at)++];
        part = c & 127;
        if (part > ((size_t)-1 >> shift))
            return GB_BAD;
        x |= part << shift;
        shift += 7;
    } while (c & 128);
    *value = x;
    return 0;
}
static size_t GKOffset(GKEntry *e, size_t count, size_t offset) {
    size_t lo = 0, hi = count, mid;
    while (lo < hi) {
        mid = lo + (hi - lo) / 2;
        if (e[mid].offset < offset) lo = mid + 1;
        else hi = mid;
    }
    return lo < count && e[lo].offset == offset ? lo : count;
}
static size_t GKHash(const unsigned char id[20], size_t mask) {
    GBWord h = 2166136261U;
    size_t i;
    for (i = 0; i < 20; ++i) h = (h ^ id[i]) * 16777619U;
    return (size_t)h & mask;
}
/* Zero is an empty slot; entries use index+1. Duplicate IDs share the first. */
static size_t GKFind(GKEntry *e, size_t *map, size_t slots, const unsigned char id[20]) {
    size_t at = GKHash(id, slots - 1);
    while (map[at]) {
        if (!memcmp(e[map[at] - 1].oid, id, 20)) return map[at] - 1;
        at = (at + 1) & (slots - 1);
    }
    return (size_t)-1;
}
static void GKInsert(GKEntry *e, size_t *map, size_t slots, size_t index) {
    size_t at = GKHash(e[index].oid, slots - 1);
    while (map[at]) {
        if (!memcmp(e[map[at] - 1].oid, e[index].oid, 20)) return;
        at = (at + 1) & (slots - 1);
    }
    map[at] = index + 1;
}
int GKImportPump(GSRepository *repo, const void *input, size_t length, const GKLimits *limits,
                 GKBaseReader readBase, void *context,
                 int (*progress)(void *, const char *), void *progressContext, GKResult *out) {
    const unsigned char *p = (const unsigned char *)input;
    GKEntry *entries = NULL, *e, *base;
    size_t *map = NULL;
    size_t count, at = 12, end, i, n, used, size, shift, part, distance;
    size_t total = 0, slots = 1, pending = 0, progressed, index, baseLength, depth;
    unsigned char c, digest[20], *external = NULL, *next = NULL, *baseBody;
    char externalType[7];
    const char *type;
    GBSHA1 hash;
    GKResult result;
    int error = GB_BAD;
    memset(&result, 0, sizeof(result));
    if (out) *out = result;
    if (!repo || !repo->read || !repo->replace || !limits || !p || !out)
        return GB_BAD;
    if (length > limits->packBytes) return GK_LIMIT;
    if (length < 32 || memcmp(p, "PACK", 4) || (GKWord(p + 4) != 2 && GKWord(p + 4) != 3))
        return GB_BAD;
    count = (size_t)GKWord(p + 8);
    if (count > limits->objects || count > (size_t)-1 / sizeof(GKEntry)) return GK_LIMIT;
    end = length - 20;
    if (count > (end - 12) / 2) return GB_BAD;
    GBSHA1Start(&hash); GBSHA1Update(&hash, p, end); GBSHA1Finish(&hash, digest);
    if (memcmp(digest, p + end, 20)) return GB_CHECKSUM;
    if (!count) return end == 12 ? 0 : GB_BAD;
    while (slots < count) {
        if (slots > (size_t)-1 / 2) return GK_LIMIT;
        slots *= 2;
    }
    if (slots > (size_t)-1 / 2 || slots * 2 > (size_t)-1 / sizeof(size_t)) return GK_LIMIT;
    slots *= 2;
    entries = (GKEntry *)calloc(count, sizeof(GKEntry));
    map = (size_t *)calloc(slots, sizeof(size_t));
    if (!entries || !map) { error = GB_MEMORY; goto done; }
    /* Parse every frame before any object is published. */
    for (i = 0; i < count; ++i) {
        if (progress && (error = progress(progressContext, "inflate")) != 0) goto done;
        error = GB_BAD;
        e = entries + i;
        e->offset = at;
        if (at == end) goto done;
        c = p[at++]; e->kind = (c >> 4) & 7; size = c & 15; shift = 4;
        if (!GKType(e->kind) && e->kind != 6 && e->kind != 7) goto done;
        while (c & 128) {
            if (at == end || shift >= sizeof(size_t) * CHAR_BIT) goto done;
            c = p[at++]; part = c & 127;
            if (part > ((size_t)-1 >> shift)) goto done;
            size |= part << shift; shift += 7;
        }
        if (size > limits->objectBytes || size > limits->expandedBytes - total) {
            error = GK_LIMIT; goto done;
        }
        if (e->kind == 6) {
            if (at == end) goto done;
            c = p[at++]; distance = c & 127;
            while (c & 128) {
                if (at == end) goto done;
                c = p[at++];
                if (distance == (size_t)-1 || distance + 1 > ((size_t)-1 - (c & 127)) / 128)
                    goto done;
                distance = (distance + 1) * 128 + (c & 127);
            }
            if (!distance || distance > e->offset) goto done;
            e->base = GKOffset(entries, i, e->offset - distance);
            if (e->base == i) goto done;
        } else if (e->kind == 7) {
            if (end - at < 20) goto done;
            memcpy(e->baseID, p + at, 20); at += 20;
        }
        e->body = (unsigned char *)malloc(size ? size : 1);
        if (!e->body) { error = GB_MEMORY; goto done; }
        error = GBInflate(p + at, end - at, e->body, size, &n, &used);
        if (error) goto done;
        error = GB_BAD;
        if (n != size || !used || used > end - at) goto done;
        at += used; e->length = n; total += n;
        e->type = GKType(e->kind);
        if (e->type) {
            error = GBObjectID(e->type, e->body, n, e->oid);
            if (error) goto done;
            e->resolved = 1; GKInsert(entries, map, slots, i);
        } else ++pending;
        error = GB_BAD;
    }
    if (at != end) goto done;
    while (pending) {
        progressed = 0;
        for (i = 0; i < count; ++i) {
            e = entries + i;
            if (e->resolved) continue;
            if (progress && (error = progress(progressContext, "delta")) != 0) goto done;
            index = e->kind == 6 ? e->base : GKFind(entries, map, slots, e->baseID);
            base = index == (size_t)-1 ? NULL : entries + index;
            if (base && !base->resolved) continue;
            if (!base) {
                if (!readBase) continue;
                external = NULL; baseLength = 0; memset(externalType, 0, sizeof(externalType));
                error = readBase(context, e->baseID, limits->objectBytes,
                                 externalType, &external, &baseLength);
                if (error == GS_NOT_FOUND) { free(external); external = NULL; continue; }
                if (error) goto done;
                if (!external || baseLength > limits->objectBytes ||
                    !memchr(externalType, 0, sizeof(externalType))) { error = GB_BAD; goto done; }
                error = GBObjectID(externalType, external, baseLength, digest);
                if (error) goto done;
                if (memcmp(digest, e->baseID, 20)) { error = GB_CHECKSUM; goto done; }
                type = externalType; baseBody = external; depth = 1;
            } else {
                baseBody = base->body; baseLength = base->length; type = base->type;
                depth = base->depth + 1;
            }
            if (depth > limits->deltaDepth) { error = GK_LIMIT; goto done; }
            at = 0;
            error = GKVar(e->body, e->length, &at, &size);
            if (error) goto done;
            if (size != baseLength) { error = GB_BAD; goto done; }
            error = GKVar(e->body, e->length, &at, &size);
            if (error) goto done;
            if (size > limits->objectBytes || size > limits->expandedBytes - total) {
                error = GK_LIMIT; goto done;
            }
            next = (unsigned char *)malloc(size ? size : 1);
            if (!next) { error = GB_MEMORY; goto done; }
            error = GBApplyDelta(baseBody, baseLength, e->body, e->length, next, size, &n);
            if (error) goto done;
            if (n != size) { error = GB_BAD; goto done; }
            /* Own the type independently of the external callback's stack text. */
            e->type = !strcmp(type, "commit") ? "commit" : !strcmp(type, "tree") ? "tree" :
                      !strcmp(type, "blob") ? "blob" : !strcmp(type, "tag") ? "tag" : NULL;
            if (!e->type) { error = GB_BAD; goto done; }
            error = GBObjectID(e->type, next, n, e->oid);
            if (error) goto done;
            free(e->body); e->body = next; next = NULL; e->length = n;
            free(external); external = NULL;
            total += n; e->depth = depth; e->resolved = 1;
            GKInsert(entries, map, slots, i);
            ++result.deltas;
            if (depth > result.deepestDelta) result.deepestDelta = depth;
            --pending; ++progressed;
        }
        if (!progressed) { error = GK_BASE_MISSING; goto done; }
    }
    for (i = 0; i < count; ++i) {
        if (progress && (error = progress(progressContext, "write")) != 0) goto done;
        e = entries + i;
        error = GSPutObject(repo, e->type, e->body, e->length, digest);
        if (error) goto done;
        if (memcmp(digest, e->oid, 20)) { error = GB_CHECKSUM; goto done; }
        ++result.objectsWritten;
    }
    error = 0;
done:
    free(next); free(external);
    if (entries) for (i = 0; i < count; ++i) free(entries[i].body);
    free(entries); free(map);
    *out = result;
    return error;
}
int GKImport(GSRepository *repo, const void *input, size_t length, const GKLimits *limits,
             GKBaseReader readBase, void *context, GKResult *out) {
    return GKImportPump(repo, input, length, limits, readBase, context, NULL, NULL, out);
}
