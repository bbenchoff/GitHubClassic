#include "GitHistory.h"
#include <string.h>

static void GHCommitText(char *out, size_t capacity, const unsigned char *p, size_t n) {
    size_t i;
    if (n >= capacity)
        n = capacity - 1;
    for (i = 0; i < n; ++i)
        out[i] = p[i] < 32 || p[i] == 127 ? ' ' : (char)p[i];
    out[n] = 0;
}
int GHCommitParse(const unsigned char *bytes, size_t length, GHCommitInfo *info) {
    GHCommitInfo result;
    size_t at = 0, end, n, value;
    int tree = 0, author = 0, committer = 0, previous = 0, continuation = 0;
    char hex[41];
    unsigned char oid[20];
    if (!bytes || !info || !length || memchr(bytes, 0, length))
        return GB_BAD;
    memset(info, 0, sizeof(*info));
    memset(&result, 0, sizeof(result));
    while (at < length) {
        end = at;
        while (end < length && bytes[end] != '\n')
            ++end;
        if (end == length)
            return GB_BAD;
        n = end - at;
        if (!n) {
            if (!tree || !author || !committer)
                return GB_BAD;
            result.messageOffset = end + 1;
            at = end + 1;
            end = at;
            while (end < length && bytes[end] != '\n' && bytes[end] != '\r')
                ++end;
            GHCommitText(result.summary, sizeof(result.summary), bytes + at, end - at);
            *info = result;
            return 0;
        }
        if (bytes[at] == ' ') {
            if (!previous || !continuation)
                return GB_BAD;
            at = end + 1;
            continue;
        }
        value = at;
        while (value < end && bytes[value] != ' ') {
            if (bytes[value] < 33 || bytes[value] > 126)
                return GB_BAD;
            ++value;
        }
        if (value == at || value == end)
            return GB_BAD;
        previous = 1;
        continuation = 0;
        if ((value - at == 4 && !memcmp(bytes + at, "tree", 4)) ||
            (value - at == 6 && !memcmp(bytes + at, "parent", 6))) {
            if (end - value - 1 != 40)
                return GB_BAD;
            memcpy(hex, bytes + value + 1, 40);
            hex[40] = 0;
            if (GBOIDParse(hex, oid))
                return GB_BAD;
            if (value - at == 4) {
                if (tree || at)
                    return GB_BAD;
                memcpy(result.tree, oid, 20);
                tree = 1;
            } else {
                if (!tree || author || committer || result.parents == (unsigned long)-1)
                    return GB_BAD;
                if (!result.parents)
                    memcpy(result.parent, oid, 20);
                ++result.parents;
            }
        } else if (value - at == 6 && !memcmp(bytes + at, "author", 6)) {
            if (!tree || author || committer)
                return GB_BAD;
            GHCommitText(result.author, sizeof(result.author), bytes + value + 1, end - value - 1);
            author = 1;
        } else if (value - at == 9 && !memcmp(bytes + at, "committer", 9)) {
            if (!author || committer)
                return GB_BAD;
            GHCommitText(result.committer, sizeof(result.committer), bytes + value + 1,
                         end - value - 1);
            committer = 1;
        } else {
            if (!tree)
                return GB_BAD;
            continuation = 1;
        }
        at = end + 1;
    }
    return GB_BAD;
}
