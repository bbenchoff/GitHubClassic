#include "GHWindowLayout.h"
int GHFitWindowBounds(GHWindowBounds *bounds,const GHWindowBounds *available,short minimumWidth,short minimumHeight) {
    long width,height,aw,ah,left,top;
    GHWindowBounds next;
    if(!bounds || !available || minimumWidth<1 || minimumHeight<1)return 0;
    aw=(long)available->right-available->left;ah=(long)available->bottom-available->top;
    if(aw<1 || ah<1)return 0;
    width=(long)bounds->right-bounds->left;height=(long)bounds->bottom-bounds->top;
    if(width<minimumWidth)width=minimumWidth;
    if(height<minimumHeight)height=minimumHeight;
    if(width>aw)width=aw;
    if(height>ah)height=ah;
    if(width>32767)width=32767;
    if(height>32767)height=32767;
    left=bounds->left;top=bounds->top;
    if(left<available->left)left=available->left;
    if(top<available->top)top=available->top;
    if(left+width>available->right)left=available->right-width;
    if(top+height>available->bottom)top=available->bottom-height;
    next.left=(short)left;next.top=(short)top;next.right=(short)(left+width);next.bottom=(short)(top+height);
    *bounds=next;return 1;
}
void GHLayout(GHWindowLayout *ui,short width,short height) {
    if(width<620)width=620;
    if(height<420)height=420;
    ui->width=width;ui->height=height;
    ui->listBottom=(short)(height-168);
    ui->rows=(short)((ui->listBottom-134)/28);
    if(ui->rows>GH_HISTORY_CAPACITY)ui->rows=GH_HISTORY_CAPACITY;
    ui->authorY=(short)(height-150);ui->summaryLabel=(short)(height-129);
    ui->summaryTop=(short)(height-121);ui->descriptionLabel=(short)(height-87);
    ui->descriptionTop=(short)(height-79);ui->commitTop=(short)(height-53);
}
int GHVisibleOffset(int offset,int selection,int count,int rows) {
    if(rows<1 || count<1)return 0;
    if(offset<0)offset=0;
    if(offset>=count)offset=((count-1)/rows)*rows;
    if(selection>=0 && selection<count &&
       (selection<offset || selection>=offset+rows))offset=(selection/rows)*rows;
    return offset;
}
/* Return 1 for a move inside the loaded page, 2 for a backing-page change.
   Every earlier backing page is full; `more` describes the following page. */
int GHPageMove(int direction,int rows,int count,int more,int *page,int *offset) {
    if(rows<1 || rows>GH_HISTORY_CAPACITY || count<0 || count>GH_HISTORY_CAPACITY)return 0;
    if(direction<0 && *offset>0) {*offset=*offset>rows?*offset-rows:0;return 1;}
    if(direction>0 && *offset+rows<count) {*offset+=rows;return 1;}
    if(direction<0 && *page>0) {--*page;*offset=((GH_HISTORY_CAPACITY-1)/rows)*rows;return 2;}
    if(direction>0 && more) {++*page;*offset=0;return 2;}
    return 0;
}
