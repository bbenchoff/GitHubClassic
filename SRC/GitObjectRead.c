#include "GitObjectRead.h"
#include <stdlib.h>
#include <string.h>
static int GONoWrite(void *context, const char *key, const void *a, size_t an, const void *b, size_t bn) {
    (void)context; (void)key; (void)a; (void)an; (void)b; (void)bn; return GB_BAD;
}
static int GORead(void *context, const char *key, unsigned char **bytes, size_t *length) {
    GOReader *r = (GOReader *)context;
    unsigned char header[64];
    size_t n, used, at, value = 0, start;
    int error;
    *bytes = NULL; *length = 0;
    if (strncmp(key, "objects/", 8)) return GB_BAD;
    if (r->reads == r->limits.reads) return GB_SPACE;
    if (r->progress && (error = r->progress(r->context)) != 0) return error;
    ++r->reads;
    error = r->source->read(r->source->context, key, bytes, length);
    if (error) goto done;
    if (*length > r->limits.encodedBytes || *length > r->limits.readBytes - r->bytes) {
        error = GB_SPACE; goto done;
    }
    r->bytes += *length;
    memset(header, 0, sizeof(header));
    error = GBInflate(*bytes, *length, header, sizeof(header), &n, &used);
    if (error && error != GB_SPACE) goto done;
    for (at = 0; at < 6 && header[at] != ' '; ++at) { }
    if (header[at] != ' ') { error = GS_FORMAT; goto done; }
    start = ++at;
    while (at < sizeof(header) && header[at]) {
        if (header[at] < '0' || header[at] > '9' || value > ((size_t)-1 - (header[at] - '0')) / 10) {
            error = GS_FORMAT; goto done;
        }
        value = value * 10 + header[at++] - '0';
    }
    if (at == sizeof(header) || at == start || (at - start > 1 && header[start] == '0')) error = GS_FORMAT;
    else error = value > r->limits.objectBytes || value > r->limits.readBytes - r->expanded ? GB_SPACE : 0;
    if (!error) r->expanded += value;
done:
    if (error) { free(*bytes); *bytes = NULL; *length = 0; }
    return error;
}
int GOReadStart(GSRepository *source, const GOLimits *limits, GOProgress progress,
                  void *context, GOReader *state, GSRepository *reader) {
    if (!source || !source->read || !limits || !limits->objectBytes || !limits->encodedBytes ||
        !limits->readBytes || !limits->reads || !state || !reader || source == reader ||
        (source->read == GORead && source->context == state)) return GB_BAD;
    memset(state, 0, sizeof(*state)); state->source = source; state->limits = *limits;
    state->progress = progress; state->context = context;
    reader->context = state; reader->read = GORead; reader->replace = GONoWrite;
    return 0;
}
