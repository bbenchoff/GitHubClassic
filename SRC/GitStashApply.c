#include "GitStashApply.h"
#include "GitCheckoutSession.h"
#include "GitHistory.h"
#include <stdlib.h>
#include <string.h>

void SAInit(SAReview *p){memset(p,0,sizeof(*p));GCInit(&p->removal);TMInit(&p->working);TMInit(&p->staged);GRInit(&p->untracked);}
void SAFree(SAReview *p){GCFree(&p->removal);TMFree(&p->working);TMFree(&p->staged);GRFree(&p->untracked);SAInit(p);}
typedef struct {GSRepository *source,*objects;size_t stateBytes,logBytes;} SAReader;
static int SANoWrite(void *c,const char *key,const void *a,size_t an,const void *b,size_t bn){
    (void)c;(void)key;(void)a;(void)an;(void)b;(void)bn;return GS_FORMAT;
}
static int SARead(void *context,const char *key,unsigned char **p,size_t *n){
    SAReader *r=context;size_t cap;int result;char ref[64];
    if(!strncmp(key,"objects/",8))return r->objects->read(r->objects->context,key,p,n);
    cap=!strcmp(key,SP_LOG_KEY)?r->logBytes:r->stateBytes;
    result=GSRefKey("refs/stash",ref);if(result)return result;if(!strcmp(key,ref))cap=52;
    result=r->source->read(r->source->context,key,p,n);
    if(!result && *n>cap)return GB_SPACE;
    if(!result && !*p)return GS_FORMAT;
    return result;
}
static const GCMetadata *SAMeta(const GCTransaction *t,const char *path){
    size_t i;for(i=0;i<t->metadataCount;++i)if(!strcmp(t->metadata[i].path,path))return t->metadata+i;return NULL;
}
static int SACommit(GSRepository *r,const unsigned char id[20],size_t cap,unsigned char tree[20],unsigned char *parents,size_t *count){
    unsigned char *p=NULL;size_t n=0,at,end,k=0;char type[7],hex[41];GHCommitInfo info;int result;
    result=GSGetObjectLimit(r,id,type,&p,&n,cap);
    if(!result)result=strcmp(type,"commit")?GS_FORMAT:GHCommitParse(p,n,&info);
    if(!result && parents){
        if(info.parents<2 || info.parents>3)result=GS_FORMAT;
        for(at=46;!result && at<info.messageOffset-1;at=end+1){
            for(end=at;end<n && p[end]!='\n';++end){}
            if(end-at>=7 && !memcmp(p+at,"parent ",7)){
                if(k>=3 || end-at!=47){result=GS_FORMAT;break;}
                memcpy(hex,p+at+7,40);hex[40]=0;result=GBOIDParse(hex,parents+20*k);++k;
            }
        }
        if(!result && k!=(size_t)info.parents)result=GS_FORMAT;
        if(!result)*count=k;
    }
    if(!result)memcpy(tree,info.tree,20);free(p);return result;
}
/* Sorted logical snapshot lookup. Detect an exact match, any parent file or
   a descendant without a whole-list scan per untracked file. */
static int SAOverlap(const GRSnapshot *s,const char *path){
    size_t lo=0,hi=s->count,m,n=strlen(path),i;int order;
    while(lo<hi){m=lo+(hi-lo)/2;order=strcmp(s->files[m].path,path);if(order<0)lo=m+1;else hi=m;}
    if(lo<s->count && !strncmp(s->files[lo].path,path,n) && (!s->files[lo].path[n] || s->files[lo].path[n]=='/'))return 1;
    for(i=0;i<n;++i)if(path[i]=='/'){
        lo=0;hi=s->count;
        while(lo<hi){size_t length;m=lo+(hi-lo)/2;length=strlen(s->files[m].path);
            order=memcmp(s->files[m].path,path,length<i?length:i);
            if(!order)order=length<i?-1:length>i?1:0;
            if(!order)return 1;if(order<0)lo=m+1;else hi=m;
        }
    }
    return 0;
}
static int SAFresh(GSRepository *r,const GCTransaction *t){
    unsigned char *p=NULL;size_t i,n=0;GBWord generation;int result,present;
    result=GTNormalWriteAllowed(r);if(!result)result=GTNextGeneration(r,&generation);
    if(!result && generation!=t->generation)result=GS_CONFLICT;
    for(i=0;!result && i<t->metadataCount;++i){const GCMetadata *m=t->metadata+i;
        result=r->read(r->context,m->path,&p,&n);present=!result;if(result==GS_NOT_FOUND)result=0;
        if(!result && (present!=m->beforePresent || n!=m->beforeLength || (n && memcmp(p,m->before,n))))result=GS_CONFLICT;
        free(p);p=NULL;n=0;
    }
    return result;
}
int SAPrepare(GSRepository *source,const SPState *shown,size_t selected,const unsigned char stash[20],
    const char *branch,const unsigned char tip[20],const SLLimits *logs,const WSLimits *saved,
    const TMLimits *limits,char newline,GPEqual eq,void *eqContext,GDProgress progress,void *context,SAReview *out){
    SAReview next;SAReader mux;GOReader budget;GSRepository reader,objects;WSRecord record;
    const GCMetadata *head,*ref;unsigned char baseTree[20],indexTree[20],workingTree[20],currentTree[20];
    size_t bn,i;char key[64],hex[41];int result;
    if(!source || !source->read || !shown || !stash || !branch || !GSValidRef(branch) || !tip || !logs ||
       !saved || saved->stateBytes<160 || !saved->files || saved->files>(size_t)-1/4 || !saved->paths || !saved->pathBytes ||
       !saved->forkBytes || !saved->workBytes || !saved->entries || !limits || !eq || !out || (newline!='\r' && newline!='\n'))return GB_BAD;
    bn=strlen(branch);if(bn>1024)return GB_BAD;
    SAInit(&next);WSInit(&record);
    result=GOReadStart(source,&limits->read,progress,context,&budget,&objects);
    mux.source=source;mux.objects=&objects;mux.stateBytes=saved->stateBytes;mux.logBytes=logs->bytes;
    reader.context=&mux;reader.read=SARead;reader.replace=SANoWrite;
    if(!result)result=SDPrepareDrop(&reader,shown,selected,stash,logs,saved->stateBytes,eq,eqContext,&next.removal);
    if(!result)result=GSRefKey(branch,key);
    head=!result?SAMeta(&next.removal,"HEAD"):NULL;ref=!result?SAMeta(&next.removal,key):NULL;
    if(!result && (!head || !ref || !head->beforePresent || head->beforeLength!=bn+6 || memcmp(head->before,"ref: ",5) ||
       memcmp(head->before+5,branch,bn) || head->before[bn+5]!='\n' || !ref->beforePresent || ref->beforeLength!=bn+42))result=GS_CONFLICT;
    if(!result){GBOIDFormat(tip,hex);if(memcmp(ref->before,branch,bn+1) || memcmp(ref->before+bn+1,hex,40) || ref->before[bn+41]!='\n')result=GS_CONFLICT;}
    if(!result)result=SACommit(&reader,stash,saved->stateBytes,workingTree,next.parents,&next.parentCount);
    if(!result)result=SACommit(&reader,next.parents,saved->stateBytes,baseTree,NULL,NULL);
    if(!result)result=SACommit(&reader,next.parents+20,saved->stateBytes,indexTree,NULL,NULL);
    if(!result)result=SACommit(&reader,tip,saved->stateBytes,currentTree,NULL,NULL);
    if(!result)result=TMFromTrees(&reader,baseTree,currentTree,workingTree,newline,limits,progress,context,&next.working);
    if(!result)result=TMFromTrees(&reader,baseTree,currentTree,indexTree,newline,limits,progress,context,&next.staged);
    if(!result){
        memcpy(record.working,stash,20);record.haveUntracked=next.parentCount==3;
        if(record.haveUntracked)memcpy(record.untracked,next.parents+40,20);
        result=WSReadUntracked(&reader,&record,saved,&next.untracked);
    }
    for(i=0;!result && i<next.untracked.count;++i)
        if(SAOverlap(&next.working.snapshots[2],next.untracked.files[i].path) ||
           SAOverlap(&next.staged.snapshots[2],next.untracked.files[i].path))result=GS_FORMAT;
    if(!result && progress)result=progress(context);
    if(!result)result=SAFresh(&reader,&next.removal);
    if(!result){
        memcpy(next.stash,stash,20);memcpy(next.current,tip,20);
        next.encodedReadBytes=budget.bytes;next.expandedReadBytes=budget.expanded;next.readCount=budget.reads;
        SAFree(out);*out=next;SAInit(&next);
    }
    WSFree(&record);SAFree(&next);return result;
}
