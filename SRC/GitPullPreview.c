#include "GitPullPreview.h"
#include <stdlib.h>
#include <string.h>

void PVInit(PVPreview *preview) {memset(preview,0,sizeof(*preview));}
void PVFree(PVPreview *preview) {
    BCFree(&preview->graph);HCFree(&preview->files);PVInit(preview);
}
static int PVTree(GSRepository *source,const unsigned char tip[20],const GOLimits *limits,
                  GDProgress progress,void *context,unsigned char tree[20]) {
    GOReader state;GSRepository reader;GHCommitInfo commit;unsigned char *raw=NULL;size_t n=0;char type[7];int result;
    result=GOReadStart(source,limits,progress,context,&state,&reader);
    if(!result)result=GSGetObject(&reader,tip,type,&raw,&n);
    if(!result)result=strcmp(type,"commit")?GS_FORMAT:GHCommitParse(raw,n,&commit);
    if(!result)memcpy(tree,commit.tree,20);
    free(raw);return result;
}
int PVBuild(GSRepository *source,const unsigned char head[20],const unsigned char target[20],char newline,
               const PVLimits *limits,GDProgress progress,void *context,PVPreview *destination) {
    PVPreview *next;TMPlan *merge=NULL;const BCNode *basis;unsigned char baseTree[20];int result;
    if(!source || !source->read || !head || !target || !limits || !destination || (newline!='\r' && newline!='\n'))return GB_BAD;
    next=(PVPreview *)calloc(1,sizeof(*next));if(!next)return GB_MEMORY;
    result=BCBuild(source,head,target,&limits->graph,progress,context,&next->graph);
    if(!result) {
        if(!next->graph.bases)next->kind=PV_UNRELATED;
        else if(next->graph.bases>1)next->kind=PV_MULTIPLE_BASES;
        else {
            basis=BCBaseAt(&next->graph,0);
            result=HCBetweenCommits(source,basis->oid,head,&limits->files,progress,context,&next->files);
            if(!result && !next->graph.onlyLeft)next->kind=PV_EMPTY;
            else if(!result && !next->graph.onlyRight)next->kind=PV_CLEAN;
            else if(!result) {
                merge=(TMPlan *)calloc(1,sizeof(*merge));if(!merge)result=GB_MEMORY;
                if(!result)result=PVTree(source,target,&limits->merge.read,progress,context,baseTree);
                if(!result)result=TMFromTrees(source,next->files.before.tree,baseTree,next->files.after.tree,
                    newline,&limits->merge,progress,context,merge);
                if(!result){next->conflicts=merge->conflicts;next->kind=merge->conflicts?PV_CONFLICT:PV_CLEAN;}
            }
        }
    }
    if(!result && progress)result=progress(context);
    if(!result){PVFree(destination);*destination=*next;PVInit(next);}
    if(merge){TMFree(merge);free(merge);}PVFree(next);free(next);return result;
}
