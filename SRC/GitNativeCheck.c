/* Portable journal wire format/ABI diagnostic. This does not execute native
   checkout moves, recovery, metadata publication or working-tree planning. */
static int TestCheckoutCodec(void) {
    GCTransaction input, parsed;
    GCOperation operation;
    GCMetadata records[3];
    GCMetadata *accepted;
    unsigned char *bytes = NULL, *again = NULL;
    const unsigned char oldData[] = {'o','l','d',13,0,255};
    const unsigned char newData[] = {'n','e','w',10,13,0,254};
    const unsigned char oldRF[] = {0,1,2,255}, newRF[] = {3,4,5,0,254};
    unsigned char oldIndex[] = {'D','I','R','C',0,1,2,3};
    unsigned char newIndex[] = {'D','I','R','C',0,4,5,6};
    unsigned char map[] = {'G','H','M','A','P',0,255};
    char oldHead[] = "ref: refs/heads/main\n", newHead[] = "ref: refs/heads/next\n";
    const char *disk = "GH Patch";
    char path[128];
    size_t n = 0, an = 0;
    int result;
    FILE *file;
    GCInit(&input);GCInit(&parsed);memset(&operation,0,sizeof(operation));memset(records,0,sizeof(records));
    input.generation=7;input.phase=GC_PREPARE;input.fileCount=1;input.files=&operation;
    input.metadataCount=3;input.metadata=records;
    operation.oldPath=operation.newPath="Codec File";operation.oldFile.present=operation.newFile.present=1;
    operation.mode=0100755;
    memcpy(operation.oldFile.finderInfo,"TEXTCWIE",8);operation.oldFile.finderInfo[8]=4;
    memcpy(operation.newFile.finderInfo,"TEXTttxt",8);operation.newFile.finderInfo[8]=8;
    result=GBObjectID("blob",oldData,sizeof(oldData),operation.oldFile.dataOID);
    if(!result)result=GBObjectID("blob",oldRF,sizeof(oldRF),operation.oldFile.resourceOID);
    if(!result)result=GBObjectID("blob",newData,sizeof(newData),operation.newFile.dataOID);
    if(!result)result=GBObjectID("blob",newRF,sizeof(newRF),operation.newFile.resourceOID);
    if(!result)result=GBObjectID("blob","codec source fork",17,operation.metadataOID);
    records[0].path="ghclient-map";records[0].afterPresent=1;records[0].after=map;records[0].afterLength=sizeof(map);
    records[1].path="index";records[1].beforePresent=records[1].afterPresent=1;
    records[1].before=oldIndex;records[1].beforeLength=sizeof(oldIndex);records[1].after=newIndex;records[1].afterLength=sizeof(newIndex);
    records[2].path="HEAD";records[2].beforePresent=records[2].afterPresent=1;
    records[2].before=(unsigned char *)oldHead;records[2].beforeLength=strlen(oldHead);
    records[2].after=(unsigned char *)newHead;records[2].afterLength=strlen(newHead);
    if(!result && (sizeof(int)!=4 || sizeof(size_t)!=4))result=GS_FORMAT;
    if(!result)result=GCEncode(&input,GWMacNameEqual,NULL,&bytes,&n);
    if(!result)result=GCParse(bytes,n,GWMacNameEqual,NULL,&parsed);
    if(!result)result=GCEncode(&parsed,GWMacNameEqual,NULL,&again,&an);
    if(!result && (an!=n || memcmp(bytes,again,n)))result=GS_FORMAT;
    if(!result) {
        accepted=parsed.metadata;
        if(GCParse(bytes,n-1,GWMacNameEqual,NULL,&parsed)==0 || parsed.metadata!=accepted)result=GS_FORMAT;
        bytes[n-1]^=1;
        if(GCParse(bytes,n,GWMacNameEqual,NULL,&parsed)!=GB_CHECKSUM || parsed.metadata!=accepted)result=GS_FORMAT;
        bytes[n-1]^=1;
    }
    if(!result) {
        sprintf(path,"%s:Journal Codec",disk);file=fopen(path,"wb");
        if(!file){disk="GH Fat";sprintf(path,"%s:Journal Codec",disk);file=fopen(path,"wb");}
        if(file){if(fwrite(bytes,1,n,file)!=n)result=GS_IO;if(fclose(file))result=GS_IO;}
    }
    sprintf(path,"%s:Journal Codec.txt",disk);file=fopen(path,"wb");
    if(file){fprintf(file,"GHClient native journal codec v1\rresult=%d\rsizeof_int=%lu\rsizeof_size_t=%lu\rbytes=%lu\r",result,(unsigned long)sizeof(int),(unsigned long)sizeof(size_t),(unsigned long)n);fclose(file);}
    free(bytes);free(again);GCFree(&parsed);return result;
}
/* Native planner/ABI diagnostic in the isolated Local Git Test store. Its
   inventory is synthetic; this does not execute File Manager checkout moves. */
static int TestCheckoutPlanner(GSRepository *repository, const unsigned char sourceBlob[20]) {
    GIIndex index;
    GQPlan plan;
    GQWork working;
    GQError error;
    GCOperation *accepted;
    unsigned char targetTree[20], targetCommit[20], previous[20], info[32], *bytes = NULL;
    const unsigned char *parent = NULL;
    const char *disk = "GH Patch";
    char path[80], treeHex[41];
    size_t n = 0;
    int result;
    FILE *file;
    GIInit(&index);GQInit(&plan);memset(&working,0,sizeof(working));memset(info,0,32);memset(targetTree,0,20);
    memcpy(info,"TEXTttxt",8);
    result=GILoad(repository,&index);
    if(!result)result=GIStageBlob(repository,&index,"hello.txt",0100644,"Hello from classic Macintosh Git.\n",34);
    if(!result)result=GISave(repository,&index);
    if(!result)result=GIStageMac(repository,&index,"hello.txt","Target\r",7,info,"NativeRF",8);
    if(!result)result=GIWriteTree(repository,&index,targetTree);
    if(!result) {
        result=GSReadRef(repository,"refs/heads/checkout-test",previous);
        if(!result)parent=previous;else if(result==GS_NOT_FOUND)result=0;
    }
    if(!result)result=GSCommit(repository,"refs/heads/checkout-test",targetTree,parent,
        "GHClient Test <test@example.invalid>","GHClient Test <test@example.invalid>",
        "1792018801","-0700","Native checkout planner target",targetCommit);
    working.path="hello.txt";working.native="hello.txt";working.file.present=1;
    memcpy(working.file.dataOID,sourceBlob,20);memcpy(working.file.finderInfo,"????????",8);
    if(!result)result=GBObjectID("blob",NULL,0,working.file.resourceOID);
    if(!result)result=GQToBranch(repository,"refs/heads/checkout-test",&working,1,
                                 GWMacNameEqual,NULL,&plan,&error);
    if(!result && (plan.transaction.fileCount!=1 || plan.transaction.metadataCount!=5 ||
        strcmp(plan.transaction.files[0].oldPath,"hello.txt") ||
        strcmp(plan.transaction.files[0].newPath,"hello.txt") || plan.mapping.count!=1 ||
        plan.mapping.entries[0].flags!=GP_FORKS))result=GS_FORMAT;
    if(!result) {
        accepted=plan.transaction.files;
        result=GBObjectID("blob","dirty",5,working.file.resourceOID);
        if(!result && (GQToBranch(repository,"refs/heads/checkout-test",&working,1,
            GWMacNameEqual,NULL,&plan,&error)!=GS_CONFLICT || error.reason!=GQ_DIRTY ||
            plan.transaction.files!=accepted))result=GS_FORMAT;
    }
    if(!result)result=GCEncode(&plan.transaction,GWMacNameEqual,NULL,&bytes,&n);
    if(!result) {
        sprintf(path,"%s:Planner Plan",disk);file=fopen(path,"wb");
        if(!file){disk="GH Fat";sprintf(path,"%s:Planner Plan",disk);file=fopen(path,"wb");}
        if(!file)result=GS_IO;
        else {if(fwrite(bytes,1,n,file)!=n)result=GS_IO;if(fclose(file))result=GS_IO;}
    }
    sprintf(path,"%s:Planner Check.txt",disk);file=fopen(path,"wb");
    if(file) {
        GBOIDFormat(targetTree,treeHex);
        fprintf(file,"GHClient native checkout planner v1\rresult=%d\rinventory=synthetic\rsizeof_int=%lu\rsizeof_size_t=%lu\roperations=%lu\rmetadata_records=%lu\rbytes=%lu\rtarget_tree=%s\r",
            result,(unsigned long)sizeof(int),(unsigned long)sizeof(size_t),
            (unsigned long)plan.transaction.fileCount,(unsigned long)plan.transaction.metadataCount,
            (unsigned long)n,treeHex);fclose(file);
    }
    free(bytes);GIFree(&index);GQFree(&plan);return result;
}
/* Immutable commit diagnostic in the isolated developer store. Capture exact
   mutable bytes under the native writer lease; export bodies for an independent
   Git oracle. This is not a working-tree merge/session diagnostic. */
static int TestImmutableCommits(GSRepository *r, GSMacStore *store,
                                const unsigned char tree[20], const unsigned char blob[20]) {
    const char *identity = "GHClient Test <test@example.invalid>";
    const char *paths[4], *names[3];
    unsigned char *before[4], *after = NULL, *body = NULL;
    unsigned char roots[40], merge[20], alias[20], unchanged[20], duplicate[40];
    int present[4], result, code, closed, i;
    size_t lengths[4], n = 0;
    char key[64], type[7], first[41], second[41], treeHex[41], mergeHex[41], expected[512], path[96];
    FILE *file;
    memset(before,0,sizeof(before));memset(lengths,0,sizeof(lengths));memset(present,0,sizeof(present));
    memset(roots,0,sizeof(roots));memset(merge,0,sizeof(merge));
    names[0]="Commit Root A";names[1]="Commit Root B";names[2]="Commit Merge";
    paths[0]="HEAD";paths[1]="index";paths[2]="ghclient-map";paths[3]=key;
    result=GSRefKey("refs/heads/main",key);
    if(!result)result=GSMacEnter(store,0);
    if(result)return result;
    for(i=0;!result && i<4;++i) {
        code=r->read(r->context,paths[i],before+i,lengths+i);
        present[i]=!code;if(code && code!=GS_NOT_FOUND)result=code;
    }
    if(!result)result=GSWriteCommitObject(r,tree,NULL,0,identity,identity,"1792018800","-0700","Immutable root A",roots);
    if(!result)result=GSWriteCommitObject(r,tree,NULL,0,identity,identity,"1792018801","-0700","Immutable root B",roots+20);
    if(!result)result=GSWriteCommitObject(r,tree,roots,2,identity,identity,"1792018802","-0700","Immutable native merge",merge);
    if(!result) {
        GBOIDFormat(tree,treeHex);GBOIDFormat(roots,first);GBOIDFormat(roots+20,second);
        sprintf(expected,"tree %s\nparent %s\nparent %s\nauthor %s 1792018802 -0700\ncommitter %s 1792018802 -0700\n\nImmutable native merge\n",
            treeHex,first,second,identity,identity);
        result=GSGetObject(r,merge,type,&body,&n);
        if(!result && (strcmp(type,"commit") || n!=strlen(expected) || memcmp(body,expected,n)))result=GS_FORMAT;
        free(body);body=NULL;
    }
    if(!result) {
        memcpy(alias,tree,20);
        result=GSWriteCommitObject(r,alias,roots,2,identity,identity,"1792018802","-0700","Immutable native merge",alias);
        if(!result && memcmp(alias,merge,20))result=GS_FORMAT;
    }
    if(!result) {
        memcpy(unchanged,merge,20);memcpy(alias,merge,20);
        /* A tree ID has the wrong parent type, while a duplicate pair is bad input. */
        code=GSWriteCommitObject(r,tree,tree,1,identity,identity,"1792018802","-0700","wrong parent type",alias);
        if(!result && (code!=GS_FORMAT || memcmp(alias,unchanged,20)))result=GS_FORMAT;
        code=GSWriteCommitObject(r,blob,roots,2,identity,identity,"1792018802","-0700","wrong tree type",alias);
        if(!result && (code!=GS_FORMAT || memcmp(alias,unchanged,20)))result=GS_FORMAT;
        memcpy(duplicate,roots,20);memcpy(duplicate+20,roots,20);
        code=GSWriteCommitObject(r,tree,duplicate,2,identity,identity,"1792018802","-0700","duplicate parents",alias);
        if(!result && (code!=GB_BAD || memcmp(alias,unchanged,20)))result=GS_FORMAT;
    }
    for(i=0;!result && i<4;++i) {
        code=r->read(r->context,paths[i],&after,&n);
        if(code!=0 && code!=GS_NOT_FOUND)result=code;
        if(!result && ((!code)!=present[i] || (!code && (n!=lengths[i] || memcmp(after,before[i],n)))))result=GS_CONFLICT;
        free(after);after=NULL;
    }
    for(i=0;!result && i<3;++i) {
        result=GSGetObject(r,i==2?merge:roots+i*20,type,&body,&n);
        if(!result) {
            sprintf(path,"GH Fat:%s",names[i]);file=fopen(path,"wb");
            if(!file)result=GS_IO;
            else {if(fwrite(body,1,n,file)!=n)result=GS_IO;if(fclose(file))result=GS_IO;}
        }
        free(body);body=NULL;
    }
    closed=GSMacLeave(store);if(!result)result=closed;
    GBOIDFormat(tree,treeHex);GBOIDFormat(roots,first);GBOIDFormat(roots+20,second);GBOIDFormat(merge,mergeHex);
    file=fopen("GH Fat:Commit Object Check.txt","wb");
    if(file) {
        fprintf(file,"GHClient immutable commit diagnostic v1\rresult=%d\rtree=%s\rfirst=%s\rsecond=%s\rmerge=%s\rmutable_guards=4\r",
            result,treeHex,first,second,mergeHex);
        if(fclose(file) && !result)result=GS_IO;
    } else if(!result)result=GS_IO;
    for(i=0;i<4;++i)free(before[i]);return result;
}
/* Developer diagnostic; does not change any selected working repository. */
static void TestLocalGit(void) {
    GSRepository repository;
    GSMacStore store;
    FSSpec folder;
    GSTreeEntry entry;
    unsigned char blob[20], tree[20], commit[20], parent[20], tip[20], *body;
    const unsigned char *previous = NULL;
    char *branch = NULL, type[7], hex[41], status[256];
    size_t n;
    OSErr error;
    int result;
    FILE *log;
    if(TestSavedCatalogControl()) return;
    if(TestCheckoutControl()) return;
    if(TestCheckoutCodec()) { SetStatus("Journal codec/ABI diagnostic failed; native checkout remains disabled."); return; }
    memset(&store, 0, sizeof(store));
    error = FSMakeFSSpec(0, 0, "\pMacintosh HD:Projects:GitHubClient:Local Git Test", &folder);
    result = error && error != fnfErr ? GS_IO : GSMacAttach(&repository, &store, &folder, 1);
    if (!result)
        result = GSInit(&repository, "refs/heads/main");
    if (!result) {
        result = GSHead(&repository, &branch, parent);
        if (!result)
            previous = parent;
        else if (result == GS_NOT_FOUND)
            result = 0;
        free(branch);
    }
    if (!result)
        result = GSPutObject(&repository, "blob", "Hello from classic Macintosh Git.\n", 34, blob);
    if (!result)
        result = GSGetObject(&repository, blob, type, &body, &n);
    if (!result) {
        if (strcmp(type, "blob") || n != 34 ||
            memcmp(body, "Hello from classic Macintosh Git.\n", 34))
            result = GS_FORMAT;
        free(body);
    }
    if (!result) {
        entry.name = "hello.txt";
        entry.mode = 0100644;
        memcpy(entry.oid, blob, 20);
        result = GSWriteTree(&repository, &entry, 1, tree);
    }
    if (!result)
        result =
            GSCommit(&repository, "refs/heads/main", tree, previous,
                     "GHClient Test <test@example.invalid>", "GHClient Test <test@example.invalid>",
                     "1792018800", "-0700", "Native HFS repository check", commit);
    if (!result && GSUpdateRef(&repository, "refs/heads/main", NULL, commit) != GS_CONFLICT)
        result = GS_FORMAT;
    if (!result)
        result = GSReadRef(&repository, "refs/heads/main", tip);
    if (!result && memcmp(tip, commit, 20))
        result = GS_FORMAT;
    if (!result)
        result = TestImmutableCommits(&repository, &store, tree, blob);
    if (!result)
        result = TestCheckoutPlanner(&repository, blob);
    if (!result)
        result = TestNativeFiles();
    if (!result)
        GBOIDFormat(commit, hex);
    log = fopen("Macintosh HD:Projects:GitHubClient:Local Git Test.txt", "wb");
    if (log) {
        fprintf(log, "Native HFS Git check result %d; File Manager %d\r", result,
                (int)store.lastError);
        if (!result) {
            GBOIDFormat(blob, hex);
            fprintf(log, "blob %s\r", hex);
            GBOIDFormat(tree, hex);
            fprintf(log, "tree %s\r", hex);
            GBOIDFormat(commit, hex);
            fprintf(log, "commit %s\r", hex);
        }
        fclose(log);
    }
    if (result)
        snprintf(status, sizeof(status), "Local Git check failed: %d (File Manager %d).", result,
                 (int)store.lastError);
    else
        snprintf(
            status, sizeof(status),
            "Native HFS Git check passed. Commit %.7s; planner, catalog inventory, directory CAS and writer lease passed.",
            hex);
    SetStatus(status);
}
/* Prepare on disposable development media, never inside the selected worktree.
   This exercises the backend, not a branch-changing checkout command. */
static void TestRestoreGit(void) {
    GRSnapshot snapshot;
    FSSpec destination;
    char **paths = NULL, *beforeBranch = NULL, *afterBranch = NULL;
    unsigned char *before = NULL, *after = NULL, oldTip[20], newTip[20];
    size_t beforeLength = 0, afterLength = 0, i;
    int result, firstIndex, secondIndex, occupied = 0;
    OSErr nativeError = noErr, error;
    FILE *log;
    char status[256], hex[41];
    const char *logPath = "GH Patch:Restore Check.txt";
    if (!gLocal || !gWork.haveHead) return;
    GRInit(&snapshot);
    result = GSHead(&gWork.repository, &beforeBranch, oldTip);
    firstIndex = gWork.repository.read(gWork.repository.context, "index", &before, &beforeLength);
    if (!result && firstIndex && firstIndex != GS_NOT_FOUND) result = firstIndex;
    if (!result) result = GRFromCommit(&gWork.repository, gWork.tip, &snapshot);
    if (!result) {
        paths = (char **)calloc(snapshot.count ? snapshot.count : 1, sizeof(*paths));
        if (!paths) result = GB_MEMORY;
    }
    for (i = 0; !result && i < snapshot.count; ++i)
        result = GWNativePath(snapshot.files[i].path, paths + i);
    if (!result) {
        error = FSMakeFSSpec(0, 0, "\pGH Patch:Restore Target", &destination);
        if (error) {
            error = FSMakeFSSpec(0, 0, "\pGH Fat:Restore Target", &destination);
            logPath = "GH Fat:Restore Check.txt";
        }
        if (error) { nativeError = error; result = GS_IO; }
    }
    if (!result) result = GRMacPrepare(&gWork.repository, &snapshot, &destination,
                                       (const char *const *)paths, &nativeError);
    if (!result && snapshot.count) {
        occupied = GRMacPrepare(&gWork.repository, &snapshot, &destination,
                                 (const char *const *)paths, &nativeError);
        if (occupied != GS_CONFLICT) result = GS_FORMAT;
    }
    if (!result) {
        result = GSHead(&gWork.repository, &afterBranch, newTip);
        secondIndex = gWork.repository.read(gWork.repository.context, "index", &after, &afterLength);
        if (!result && (secondIndex != firstIndex || strcmp(beforeBranch, afterBranch) ||
                        memcmp(oldTip, newTip, 20) || beforeLength != afterLength ||
                        (!firstIndex && memcmp(before, after, beforeLength)))) result = GS_CONFLICT;
    }
    log = fopen(logPath, "wb");
    if (log) {
        GBOIDFormat(gWork.tip, hex);
        fprintf(log, "GHClient native restoration check v1\rresult=%d\rfile_manager=%d\rcommit=%s\rfiles=%lu\roccupied_result=%d\r",
                 result, (int)nativeError, hex, (unsigned long)snapshot.count, occupied);
        fclose(log);
    }
    if (result)
        snprintf(status, sizeof(status), "Fork restoration test failed: %d, File Manager %d. Use fresh GH Patch media; partial scratch output is retained.", result, (int)nativeError);
    else
        snprintf(status, sizeof(status), "Fork restoration verified: %lu files, both forks and Finder attributes. HEAD/index unchanged; existing destination rejected.", (unsigned long)snapshot.count);
    SetStatus(status);
    if (paths) for (i = 0; i < snapshot.count; ++i) free(paths[i]);
    free(paths); free(before); free(after); free(beforeBranch); free(afterBranch); GRFree(&snapshot);
}
/* Native foreign-name fixture lives only on removable development media. */
static OSErr MapTestSpec(const char *disk, const char *leaf, FSSpec *spec) {
    char text[256]; Str255 path; size_t n;
    sprintf(text, "%s:%s", disk, leaf); n = strlen(text);
    path[0] = (unsigned char)n; memcpy(path+1, text, n);
    return FSMakeFSSpec(0, 0, path, spec);
}
static size_t MapTestFile(const GWWorkspace *w, const char *path) {
    size_t i;
    for (i = 0; i < w->count; ++i) if (!strcmp(w->files[i].path,path)) return i;
    return w->count;
}
static void TestPathMapGit(void) {
    const char *disk = "GH Patch";
    char path[256], treeHex[41], initialHex[41], finalHex[41], status[256], type[7];
    FSSpec source, destination, database, newFile;
    GSMacStore sourceStore, destinationStore, rootStore;
    GSRepository input, output, root;
    GRSnapshot snapshot;
    GPMap mapping;
    GIIndex index;
    GWWorkspace workspace;
    const GPEntry *entry;
    const char **paths = NULL;
    unsigned char tree[20] = {0}, checkTree[20], initial[20] = {0}, final[20] = {0}, oid[20], *body = NULL;
    size_t i, j, n, cleanBefore = 0, cleanAfter = 0, aliases = 0;
    long count;
    short ref;
    OSErr nativeError = noErr, closed;
    int result = 0;
    FILE *file;
    memset(&sourceStore,0,sizeof(sourceStore));memset(&destinationStore,0,sizeof(destinationStore));
    GRInit(&snapshot);GPInit(&mapping);GIInit(&index);GWInit(&workspace);
    sprintf(path,"%s:Map Tree.txt",disk);file=fopen(path,"rb");
    if (!file) { disk="GH Fat";sprintf(path,"%s:Map Tree.txt",disk);file=fopen(path,"rb"); }
    if (!file) { result=GS_NOT_FOUND;goto done; }
    n=fread(treeHex,1,40,file);fclose(file);treeHex[40]=0;
    if(n!=40 || GBOIDParse(treeHex,tree)) { result=GS_FORMAT;goto done; }
    nativeError=MapTestSpec(disk,"Map Objects",&source);
    if(nativeError) { result=GS_IO;goto done; }
    result=GSMacAttach(&input,&sourceStore,&source,0);
    if(!result) result=GRFromTree(&input,tree,&snapshot);
    if(!result) result=GPBuild(&snapshot,NULL,GWMacNameEqual,NULL,&mapping);
    if(result)goto done;
    paths=(const char **)calloc(snapshot.count?snapshot.count:1,sizeof(*paths));
    if(!paths) { result=GB_MEMORY;goto done; }
    for(i=0;i<snapshot.count;++i) {
        entry=GPFind(&mapping,snapshot.files[i].path);
        if(!entry) { result=GS_FORMAT;goto done; }
        paths[i]=entry->native;
        if(strchr(entry->native,'~'))++aliases;
    }
    nativeError=MapTestSpec(disk,"Map Demo",&destination);
    if(nativeError) { result=GS_IO;goto done; }
    result=GRMacPrepare(&input,&snapshot,&destination,paths,&nativeError);
    if(result)goto done;
    /* Initialize only after successful empty-folder preparation. This fixture
       is not publication into a user's existing working repository. */
    result=GSMacAttach(&root,&rootStore,&destination,0);
    if(result)goto done;
    nativeError=FSMakeFSSpec(rootStore.volume,rootStore.directory,"\p.git",&database);
    if(nativeError && nativeError!=fnfErr) { result=GS_IO;goto done; }
    result=GSMacAttach(&output,&destinationStore,&database,1);
    if(!result)result=GSInit(&output,"refs/heads/main");
    for(i=0;!result && i<snapshot.index.count;++i) {
        const GIEntry *item=snapshot.index.entries+i;
        result=GSGetObject(&input,item->oid,type,&body,&n);
        if(!result && strcmp(type,"blob"))result=GS_FORMAT;
        if(!result)result=GSPutObject(&output,"blob",body,n,oid);
        free(body);body=NULL;
        if(!result && memcmp(oid,item->oid,20))result=GS_FORMAT;
        if(!result)result=GISet(&index,item->path,item->stat[6],oid,(GBWord)n);
    }
    if(!result)result=GIWriteTree(&output,&index,checkTree);
    if(!result && memcmp(checkTree,tree,20))result=GS_FORMAT;
    if(!result)result=GSCommit(&output,"refs/heads/main",tree,NULL,
        "Path Map Test <test@example.invalid>","Path Map Test <test@example.invalid>",
        "1792087200","+0000","Native mapped foreign tree",initial);
    if(!result)result=GISave(&output,&index);
    if(!result)result=GPSave(&output,GWMacNameEqual,NULL,&mapping);
    if(!result)result=GWOpen(&workspace,&destination,0);
    if(result)goto done;
    if(workspace.count!=snapshot.count) { result=GS_FORMAT;goto done; }
    for(i=0;i<workspace.count;++i) {
        if(workspace.files[i].staged || workspace.files[i].unstaged || workspace.files[i].untracked ||
           workspace.files[i].deleted) { result=GS_FORMAT;goto done; }
        ++cleanBefore;
    }
    /* A literal executable edit must keep 100755 and must not invent forks. */
    i=MapTestFile(&workspace,"executable");
    if(i==workspace.count) { result=GS_FORMAT;goto done; }
    nativeError=FSpOpenDF(&workspace.files[i].file,fsWrPerm,&ref);
    if(!nativeError) {
        nativeError=SetFPos(ref,fsFromLEOF,0);count=12;
        if(!nativeError)nativeError=FSWrite(ref,&count,"native edit\r");
        closed=FSClose(ref);if(!nativeError)nativeError=closed;
    }
    if(nativeError) { result=GS_IO;goto done; }
    result=GWRefresh(&workspace);
    if(result)goto done;
    i=MapTestFile(&workspace,"executable");
    if(i==workspace.count || !workspace.files[i].unstaged || workspace.files[i].hasMetadata ||
       workspace.files[i].mode!=0100755) { result=GS_FORMAT;goto done; }
    result=GWStage(&workspace,i);
    if(result)goto done;
    /* New native files within an aliased directory inherit its exact Git prefix. */
    for(i=0;i<workspace.count;++i)
        if(!strncmp(workspace.files[i].path,"long-directory-",15))break;
    if(i==workspace.count) { result=GS_FORMAT;goto done; }
    newFile=workspace.files[i].file;
    memcpy(newFile.name,"\pNew File",9);
    nativeError=FSpCreate(&newFile,'ttxt','TEXT',smSystemScript);
    if(!nativeError)nativeError=FSpOpenDF(&newFile,fsWrPerm,&ref);
    if(!nativeError) {
        count=16;nativeError=FSWrite(ref,&count,"New native file\r");
        closed=FSClose(ref);if(!nativeError)nativeError=closed;
    }
    if(nativeError) { result=GS_IO;goto done; }
    result=GWRefresh(&workspace);
    if(result)goto done;
    j=workspace.count;
    for(i=0;i<workspace.count;++i)
        if(workspace.files[i].untracked && !strncmp(workspace.files[i].path,"long-directory-",15) &&
           strstr(workspace.files[i].path,"/nested/New File"))j=i;
    if(j==workspace.count) { result=GS_FORMAT;goto done; }
    result=GWStage(&workspace,j);
    if(!result)result=GWCommit(&workspace,"Path Map Test <test@example.invalid>",
        "Path Map Test <test@example.invalid>","1792087201","+0000",
        "Edit executable and add file inside aliased directory",final);
    if(result)goto done;
    for(i=0;i<workspace.count;++i) {
        if(workspace.files[i].staged || workspace.files[i].unstaged) { result=GS_FORMAT;goto done; }
        ++cleanAfter;
    }
    if(cleanAfter!=cleanBefore+1)result=GS_FORMAT;
done:
    if(result && !nativeError)nativeError=sourceStore.lastError?sourceStore.lastError:destinationStore.lastError;
    sprintf(path,"%s:Map Check.txt",disk);file=fopen(path,"wb");
    if(file) {
        GBOIDFormat(tree,treeHex);GBOIDFormat(initial,initialHex);GBOIDFormat(final,finalHex);
        fprintf(file,"GHClient native path map check v1\rresult=%d\rfile_manager=%d\rtree=%s\rinitial=%s\rfinal=%s\rclean_before=%lu\rclean_after=%lu\raliases=%lu\r",
            result,(int)nativeError,treeHex,initialHex,finalHex,(unsigned long)cleanBefore,
            (unsigned long)cleanAfter,(unsigned long)aliases);fclose(file);
    }
    if(result)snprintf(status,sizeof(status),"Path mapping test failed: %d, File Manager %d. Partial development fixture retained.",result,(int)nativeError);
    else snprintf(status,sizeof(status),"Mapped HFS check passed: %lu clean foreign files, %lu aliases; executable edit and new nested file committed, clean again.",(unsigned long)cleanBefore,(unsigned long)aliases);
    SetStatus(status);free(paths);free(body);GWClose(&workspace);GIFree(&index);GPFree(&mapping);GRFree(&snapshot);
}
