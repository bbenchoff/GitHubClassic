#include "GitDiff.h"
#include <stdlib.h>
#include <string.h>
#include <stdio.h>

typedef struct {
    const unsigned char *text;
    size_t body, length;
    GBWord hash;
} GDLine;
typedef struct {
    char *text;
    size_t used, size;
    char newline;
    int truncated;
} GDOutput;
static void GDWrite(GDOutput *out, const void *data, size_t n) {
    size_t left = out->size - out->used - 1;
    if (n > left) { n = left; out->truncated = 1; }
    if (n) memcpy(out->text + out->used, data, n);
    out->used += n; out->text[out->used] = 0;
}
static void GDText(GDOutput *out, const char *s) { GDWrite(out, s, strlen(s)); }
static void GDEnd(GDOutput *out) { GDWrite(out, &out->newline, 1); }
static int GDLines(const unsigned char *bytes, size_t n, GDLine **result,
                   size_t *count, int *endings) {
    size_t i, start, total = 0, k;
    GDLine *lines;
    GBWord hash;
    *result = NULL; *count = 0; *endings = 0;
    for (i = 0; i < n; ++i) {
        if (bytes[i] == '\r' || bytes[i] == '\n') {
            if (++total > 8192) return GB_SPACE;
            if (bytes[i] == '\r' && i + 1 < n && bytes[i + 1] == '\n') ++i;
        } else if (i + 1 == n && ++total > 8192) return GB_SPACE;
    }
    if (!total) return 0;
    lines = (GDLine *)malloc(total * sizeof(*lines));
    if (!lines) return GB_MEMORY;
    i = 0; total = 0;
    while (i < n) {
        start = i;
        while (i < n && bytes[i] != '\r' && bytes[i] != '\n') ++i;
        lines[total].text = bytes + start; lines[total].body = i - start;
        if (i == n) *endings |= GD_UNTERMINATED;
        else if (bytes[i++] == '\r') {
            if (i < n && bytes[i] == '\n') { ++i; *endings |= GD_CRLF; }
            else *endings |= GD_CR;
        } else *endings |= GD_LF;
        lines[total].length = i - start;
        hash = 2166136261U;
        for (k = start; k < i; ++k) hash = (hash ^ bytes[k]) * 16777619U;
        lines[total++].hash = hash;
    }
    *result = lines; *count = total; return 0;
}
static int GDSame(const GDLine *a, const GDLine *b) {
    return a->hash == b->hash && a->length == b->length &&
           !memcmp(a->text, b->text, a->length);
}
/* Myers shortest edit path, with a bounded triangular trace. Matching is byte
   exact even when hashes collide. Unrelated large middles have an explicit
   coarse fallback, so time/memory bounds never hide changed content. */
static int GDOps(const GDLine *a, size_t an, const GDLine *b, size_t bn,
                 char **result, size_t *count, int *coarse,
                 GDProgress progress, void *context) {
    int *trace[257], *row, *prev, d, k, x, y, pk, px, py, distance = -1, error = 0;
    size_t prefix = 0, suffix = 0, n, m, cap, pos, i, steps = 0;
    char *ops;
    memset(trace, 0, sizeof(trace)); *result = NULL; *count = 0; *coarse = 0;
    while (prefix < an && prefix < bn && GDSame(a + prefix, b + prefix)) ++prefix;
    while (suffix < an - prefix && suffix < bn - prefix &&
           GDSame(a + an - suffix - 1, b + bn - suffix - 1)) ++suffix;
    n = an - prefix - suffix; m = bn - prefix - suffix;
    cap = an + bn + 1; ops = (char *)malloc(cap);
    if (!ops) return GB_MEMORY;
    if (n && m) for (d = 0; d <= 256; ++d) {
        if (progress) { error = progress(context); if (error) goto done; }
        row = trace[d] = (int *)malloc((size_t)(2 * d + 1) * sizeof(int));
        if (!row) { error = GB_MEMORY; goto done; }
        prev = d ? trace[d - 1] : NULL;
        for (k = -d; k <= d; k += 2) {
            if (++steps > 4000000UL) goto fallback;
            if (!d) x = 0;
            else if (k == -d || (k != d && prev[k - 1 + d - 1] < prev[k + 1 + d - 1]))
                x = prev[k + 1 + d - 1];
            else x = prev[k - 1 + d - 1] + 1;
            y = x - k;
            while (x < (int)n && y < (int)m &&
                   GDSame(a + prefix + x, b + prefix + y)) {
                ++x; ++y;
                if (++steps > 4000000UL) goto fallback;
            }
            row[k + d] = x;
            if (x >= (int)n && y >= (int)m) { distance = d; goto found; }
        }
    }
fallback:
    *coarse = n && m;
    pos = 0;
    for (i = 0; i < prefix; ++i) ops[pos++] = ' ';
    for (i = 0; i < n; ++i) ops[pos++] = '-';
    for (i = 0; i < m; ++i) ops[pos++] = '+';
    for (i = 0; i < suffix; ++i) ops[pos++] = ' ';
    *result = ops; *count = pos; ops = NULL; goto done;
found:
    pos = cap;
    for (i = 0; i < suffix; ++i) ops[--pos] = ' ';
    x = (int)n; y = (int)m;
    for (d = distance; d > 0; --d) {
        prev = trace[d - 1]; k = x - y;
        if (k == -d || (k != d && prev[k - 1 + d - 1] < prev[k + 1 + d - 1])) pk = k + 1;
        else pk = k - 1;
        px = prev[pk + d - 1]; py = px - pk;
        while (x > px && y > py) { ops[--pos] = ' '; --x; --y; }
        if (x == px) { ops[--pos] = '+'; --y; }
        else { ops[--pos] = '-'; --x; }
    }
    while (x > 0 && y > 0) { ops[--pos] = ' '; --x; --y; }
    for (i = 0; i < prefix; ++i) ops[--pos] = ' ';
    *count = cap - pos; memmove(ops, ops + pos, *count); *result = ops; ops = NULL;
done:
    for (d = 0; d <= 256; ++d) free(trace[d]);
    free(ops); return error;
}
static void GDDisplayLine(GDOutput *out, char prefix, const GDLine *line) {
    size_t i;
    unsigned char c;
    char escape[5];
    GDWrite(out, &prefix, 1);
    for (i = 0; i < line->body && !out->truncated; ++i) {
        c = line->text[i];
        if ((c < 32 && c != '\t') || c == 127) {
            sprintf(escape, "\\x%02x", (unsigned)c); GDText(out, escape);
        } else GDWrite(out, &c, 1);
    }
    GDEnd(out);
    if (line->body == line->length) { GDText(out, "\\ No newline at end of file"); GDEnd(out); }
}
int GDRender(const void *old, size_t oldSize, const void *now, size_t nowSize,
             unsigned contextLines, char newline, char *output, size_t capacity,
             GDProgress progress, void *context, GDResult *result) {
    GDLine *a = NULL, *b = NULL;
    GDOutput out;
    GDResult next;
    char *ops = NULL, header[128];
    size_t count, i, j, start, end, last, cur = 0, ai = 0, bi = 0, ac, bc;
    int error = 0;
    if (output && capacity) output[0] = 0;
    if (result) memset(result, 0, sizeof(*result));
    if (!result || !output || !capacity || (!old && oldSize) || (!now && nowSize) ||
        (newline != '\r' && newline != '\n') || contextLines > 32 ||
        oldSize > 2UL * 1024UL * 1024UL || nowSize > 2UL * 1024UL * 1024UL) return GB_BAD;
    memset(&next, 0, sizeof(next));
    out.text = output; out.used = 0; out.size = capacity; out.newline = newline; out.truncated = 0;
    if (progress) { error = progress(context); if (error) goto done; }
    if ((oldSize && memchr(old, 0, oldSize)) || (nowSize && memchr(now, 0, nowSize))) {
        next.binary = 1;
        if (oldSize != nowSize || (oldSize && memcmp(old, now, oldSize))) {
            sprintf(header, "Binary data differs: %lu -> %lu bytes.", (unsigned long)oldSize, (unsigned long)nowSize);
            GDText(&out, header); GDEnd(&out);
        } else { GDText(&out, "Binary data unchanged."); GDEnd(&out); }
        goto done;
    }
    error = GDLines((const unsigned char *)old, oldSize, &a, &next.oldLines, &next.oldEndings);
    if (!error) error = GDLines((const unsigned char *)now, nowSize, &b, &next.newLines, &next.newEndings);
    if (error) goto done;
    error = GDOps(a, next.oldLines, b, next.newLines, &ops, &count, &next.coarse, progress, context);
    if (error) goto done;
    for (i = 0; i < count; ++i) {
        if (ops[i] == '-') ++next.removed;
        if (ops[i] == '+') ++next.added;
    }
    if (!next.added && !next.removed) { GDText(&out, "Data fork unchanged."); GDEnd(&out); goto done; }
    if (next.coarse) { GDText(&out, "Large edit: displaying the changed middle as one replacement."); GDEnd(&out); }
    GDText(&out, "--- Before"); GDEnd(&out); GDText(&out, "+++ After"); GDEnd(&out);
    i = 0;
    while (i < count) {
        while (i < count && ops[i] == ' ') ++i;
        if (i == count) break;
        if (progress) { error = progress(context); if (error) goto done; }
        start = i > contextLines ? i - contextLines : 0;
        last = i;
        for (j = i; j < count; ++j) {
            if (ops[j] != ' ') last = j;
            if (j - last > (size_t)contextLines * 2) break;
        }
        end = last + contextLines + 1;
        if (end > count) end = count;
        while (cur < start) { if (ops[cur] != '+') ++ai; if (ops[cur++] != '-') ++bi; }
        ac = bc = 0;
        for (j = start; j < end; ++j) { if (ops[j] != '+') ++ac; if (ops[j] != '-') ++bc; }
        sprintf(header, "@@ -%lu,%lu +%lu,%lu @@", (unsigned long)(ac ? ai + 1 : ai),
                (unsigned long)ac, (unsigned long)(bc ? bi + 1 : bi), (unsigned long)bc);
        GDText(&out, header); GDEnd(&out); ++next.hunks;
        while (cur < end) {
            if (ops[cur] == '+') GDDisplayLine(&out, '+', b + bi++);
            else { GDDisplayLine(&out, ops[cur], a + ai++); if (ops[cur] == ' ') ++bi; }
            ++cur;
        }
        i = end;
    }
done:
    free(a); free(b); free(ops);
    if (error) { output[0] = 0; return error; }
    next.truncated = out.truncated; *result = next; return 0;
}

void GDEditsInit(GDEditScript *s) { memset(s, 0, sizeof(*s)); }
void GDEditsFree(GDEditScript *s) { free(s->edits); GDEditsInit(s); }
int GDComputeEdits(const void *old, size_t oldSize, const void *now, size_t nowSize,
                    GDProgress progress, void *context, GDEditScript *destination) {
    GDLine *a = NULL, *b = NULL;
    GDEditScript next;
    GDEdit *edit;
    char *ops = NULL;
    size_t an, bn, count, i, ai = 0, bi = 0, changes = 0;
    int endings, error = 0;
    if (!destination || (!old && oldSize) || (!now && nowSize) ||
        oldSize > 2UL * 1024UL * 1024UL || nowSize > 2UL * 1024UL * 1024UL ||
        (oldSize && memchr(old, 0, oldSize)) || (nowSize && memchr(now, 0, nowSize))) return GB_BAD;
    GDEditsInit(&next);
    if (progress) error = progress(context);
    if (!error) error = GDLines((const unsigned char *)old, oldSize, &a, &an, &endings);
    if (!error) error = GDLines((const unsigned char *)now, nowSize, &b, &bn, &endings);
    if (!error) error = GDOps(a, an, b, bn, &ops, &count, &next.coarse, progress, context);
    if (error) goto done;
    for (i = 0; i < count; ++i)
        if (ops[i] != ' ' && (!i || ops[i - 1] == ' ')) ++changes;
    if (changes) {
        next.edits = (GDEdit *)malloc(changes * sizeof(*next.edits));
        if (!next.edits) { error = GB_MEMORY; goto done; }
    }
    i = 0;
    while (i < count) {
        if (progress) { error = progress(context); if (error) goto done; }
        if (ops[i] == ' ') { ++ai; ++bi; ++i; continue; }
        edit = next.edits + next.count++;
        edit->oldStart = ai < an ? (size_t)(a[ai].text - (const unsigned char *)old) : oldSize;
        edit->newStart = bi < bn ? (size_t)(b[bi].text - (const unsigned char *)now) : nowSize;
        while (i < count && ops[i] != ' ') {
            if (ops[i++] == '-') ++ai; else ++bi;
        }
        edit->oldEnd = ai < an ? (size_t)(a[ai].text - (const unsigned char *)old) : oldSize;
        edit->newEnd = bi < bn ? (size_t)(b[bi].text - (const unsigned char *)now) : nowSize;
    }
    GDEditsFree(destination); *destination = next; GDEditsInit(&next);
done:
    free(a); free(b); free(ops); GDEditsFree(&next); return error;
}
