/* System 7 Window Manager workspace behavior. No Carbon window APIs. */
#include <Folders.h>
#include <Script.h>
static int gWindowZoomed;
static Rect WindowBounds(void) {
    Rect r=gWindow->portRect;Point p;
    SetPort(gWindow);p.h=r.left;p.v=r.top;LocalToGlobal(&p);
    OffsetRect(&r,p.h-r.left,p.v-r.top);return r;
}
static Rect WindowAvailable(const Rect *bounds) {
    GDHandle device=GetMaxDevice(bounds);Rect r;
    if(!device)device=GetMainDevice();
    r=device?(*device)->gdRect:qd.screenBits.bounds;
    r.left+=8;r.right-=8;r.bottom-=8;r.top+=25;
    if(device==GetMainDevice())r.top+=GetMBarHeight();
    return r;
}
static Rect WindowDialogAvailable(DialogPtr dialog,const Rect *bounds) {
    Rect r=WindowAvailable(bounds);
    /* dBoxProc has a five-pixel border and no document title bar. Reserve
       eight pixels, retaining the menu bar. Movable dialogs keep title room. */
    if(GetWVariant((WindowPtr)dialog)==dBoxProc)r.top-=17;
    return r;
}
static Rect WindowFit(Rect r) {
    Rect available=WindowAvailable(&r);
    return WindowConstrain(r,&available,620,420);
}
static Rect WindowConstrain(Rect r,const Rect *available,short minWidth,short minHeight) {
    GHWindowBounds bounds,area;
    bounds.left=r.left;bounds.top=r.top;bounds.right=r.right;bounds.bottom=r.bottom;
    area.left=available->left;area.top=available->top;area.right=available->right;area.bottom=available->bottom;
    if(GHFitWindowBounds(&bounds,&area,minWidth,minHeight))SetRect(&r,bounds.left,bounds.top,bounds.right,bounds.bottom);
    return r;
}
static Rect WindowDefault(void) {
    GDHandle device=GetMainDevice();Rect anchor=device?(*device)->gdRect:qd.screenBits.bounds,area=WindowAvailable(&anchor),r;
    short width=(short)((long)(area.right-area.left)*85/100),height=(short)((long)(area.bottom-area.top)*85/100);
    short left,top;
    if(width<620)width=620;if(height<420)height=420;if(height>1204)height=1204;
    left=(short)(area.left+(area.right-area.left-width)/2);top=(short)(area.top+(area.bottom-area.top-height)/3);
    SetRect(&r,left,top,(short)(left+width),(short)(top+height));return WindowConstrain(r,&area,620,420);
}
static void WindowStandard(void) {
    Rect bounds=WindowBounds(),available=WindowAvailable(&bounds);
    WStateDataHandle state=(WStateDataHandle)((WindowPeek)gWindow)->dataHandle;
    /* A useful diff workspace, bounded to a readable 32-row file list. */
    if(available.bottom-available.top>1204)available.bottom=(short)(available.top+1204);
    if(state)(**state).stdState=available;
}
static void WindowChrome(void) {
    Rect corner;RgnHandle saved=NewRgn();
    if(!saved)return;
    GetClip(saved);SetRect(&corner,gUI.width-15,gUI.height-15,gUI.width,gUI.height);
    ClipRect(&corner);Color(0,0,0);DrawGrowIcon(gWindow);SetClip(saved);DisposeRgn(saved);
}
static void WindowMoveControl(ControlHandle c,short x,short y,short width,short height) {
    MoveControl(c,x,y);SizeControl(c,width,height);
}
static void WindowMoveEdit(TEHandle edit,short top) {
    Rect r;short delta=(short)(top+3-(*edit)->viewRect.top);
    SetRect(&r,20,top+3,220,top+20);(*edit)->viewRect=r;
    OffsetRect(&(*edit)->destRect,0,delta);TECalText(edit);
}
static void WindowRelayout(void) {
    int oldRows=gUI.rows,first=gLocalPage*gUI.rows;
    SetPort(gWindow);
    GHLayout(&gUI,(short)(gWindow->portRect.right-gWindow->portRect.left),
                   (short)(gWindow->portRect.bottom-gWindow->portRect.top));
    /* Reflow never reads repositories or makes a network request. Loaded
       history pages have a fixed capacity independent of visible row count. */
    if(gLocalSelection>=first && gLocalSelection<first+oldRows)first=gLocalSelection;
    gLocalPage=first/gUI.rows;
    if(gLocalRowCount && (size_t)gLocalPage*gUI.rows>=gLocalRowCount)
        gLocalPage=(int)((gLocalRowCount-1)/gUI.rows);
    gHistoryOffset=GHVisibleOffset(gHistoryOffset,gRevisionIndex,gRevisionCount,gUI.rows);
    gLocalHistoryOffset=GHVisibleOffset(gLocalHistoryOffset,gLocalHistorySelection,gLocalHistoryCount,gUI.rows);
    if(BCUIActive()) {
        int count=(int)(BCUITotal()-gBranchCompare.page*GH_HISTORY_CAPACITY);
        int selected=gBranchCompare.selected-(int)(gBranchCompare.page*GH_HISTORY_CAPACITY);
        if(count>GH_HISTORY_CAPACITY)count=GH_HISTORY_CAPACITY;
        gBranchCompare.offset=(size_t)GHVisibleOffset((int)gBranchCompare.offset,selected,count,gUI.rows);
    }
    WindowMoveControl(gSignIn,PaneCenter()-108,WelcomeY(278),220,26);
    WindowMoveControl(gBrowse,PaneCenter()-108,WelcomeY(278),220,26);
    WindowMoveControl(gFetch,RightEdge(612),15,156,24);
    WindowMoveControl(gCommit,14,gUI.commitTop,211,24);
    WindowMoveControl(gDiffScroll,RightEdge(775),153,14,BottomEdge(451)-17-153);
    WindowMoveControl(gDiffHorizontal,251,BottomEdge(451)-15,RightEdge(772)-251,14);
    WindowMoveEdit(gSummaryEdit,gUI.summaryTop);WindowMoveEdit(gDescriptionEdit,gUI.descriptionTop);
    DiffScroll();InvalRect(&gWindow->portRect);
}
/* Display mode/hot-plug changes do not imply repository refresh or networking.
   Preserve the user's geometry when it still fits. A zoomed window follows the
   work area; its stored user rectangle is fitted before a later zoom-back. */
static void WindowCheckDisplay(void) {
    static Rect lastArea;
    static int haveArea;
    static unsigned long checked;
    unsigned long now=TickCount();Rect bounds,area,next;WStateDataHandle state;
    if(!gWindow || (unsigned long)(now-checked)<30UL)return;
    checked=now;bounds=WindowBounds();area=WindowAvailable(&bounds);
    if(haveArea && EqualRect(&area,&lastArea))return;
    lastArea=area;haveArea=1;state=(WStateDataHandle)((WindowPeek)gWindow)->dataHandle;
    if(gWindowZoomed && state) {
        (**state).userState=WindowFit((**state).userState);WindowStandard();next=(**state).stdState;
    } else next=WindowConstrain(bounds,&area,620,420);
    if(EqualRect(&bounds,&next))return;
    SetPort(gWindow);EraseRect(&gWindow->portRect);
    SizeWindow(gWindow,(short)(next.right-next.left),(short)(next.bottom-next.top),true);
    MoveWindow(gWindow,next.left,next.top,false);WindowRelayout();
}
static void WindowResize(Point where) {
    Rect bounds=WindowBounds(),available=WindowAvailable(&bounds),limits;
    long result;short width,height;
    SetRect(&limits,620,420,(short)(available.right-bounds.left+1),
                           (short)(available.bottom-bounds.top+1));
    if(limits.right<621)limits.right=621;if(limits.bottom<421)limits.bottom=421;
    result=GrowWindow(gWindow,where,&limits);if(!result)return;
    width=(short)(result&0xffff);height=(short)((unsigned long)result>>16);
    SetPort(gWindow);EraseRect(&gWindow->portRect);SizeWindow(gWindow,width,height,true);
    gWindowZoomed=0;WindowRelayout();
}
static void WindowZoom(Point where,short part) {
    WStateDataHandle state=(WStateDataHandle)((WindowPeek)gWindow)->dataHandle;
    if(!TrackBox(gWindow,where,part))return;
    SetPort(gWindow);EraseRect(&gWindow->portRect);
    if(part==inZoomOut)WindowStandard();
    else if(state)(**state).userState=WindowFit((**state).userState);
    ZoomWindow(gWindow,part,true);gWindowZoomed=part==inZoomOut;WindowRelayout();
}
static void ShowWorkspace(void) {ShowWindow(gWindow);SelectWindow(gWindow);}
static void CloseWorkspace(void) {
    if(CloseRepository()){WindowRemember();HideWindow(gWindow);}
}
static OSErr WindowPreferenceSpec(FSSpec *spec) {
    short volume;long directory;OSErr error;
    error=FindFolder(kOnSystemDisk,kPreferencesFolderType,true,&volume,&directory);
    if(error)return error;
    return FSMakeFSSpec(volume,directory,"\pGitHub Classic Window",spec);
}
static OSErr WindowPreferenceOpen(short permission,short *ref) {
    FSSpec spec;CInfoPBRec info;OSErr error=WindowPreferenceSpec(&spec);
    if(error==fnfErr && permission==fsWrPerm)error=FSpCreate(&spec,'GHCl','GHWP',smSystemScript);
    if(error)return error;
    memset(&info,0,sizeof(info));info.hFileInfo.ioNamePtr=spec.name;
    info.hFileInfo.ioVRefNum=spec.vRefNum;info.hFileInfo.ioDirID=spec.parID;
    error=PBGetCatInfoSync(&info);if(error)return error;
    if((info.hFileInfo.ioFlAttrib&16) || (info.hFileInfo.ioFlFndrInfo.fdFlags&0x8000) ||
       info.hFileInfo.ioFlFndrInfo.fdCreator!='GHCl' || info.hFileInfo.ioFlFndrInfo.fdType!='GHWP' ||
       info.hFileInfo.ioFlRLgLen)return paramErr;
    return FSpOpenDF(&spec,permission,ref);
}
static unsigned short WindowCheck(const unsigned char bytes[20]) {
    unsigned short sum=0;int i;for(i=0;i<18;++i)sum=(unsigned short)(sum+bytes[i]);return sum;
}
static void WindowPutShort(unsigned char *p,short n) {p[0]=(unsigned char)((unsigned short)n>>8);p[1]=(unsigned char)n;}
static short WindowGetShort(const unsigned char *p) {return (short)(((unsigned short)p[0]<<8)|p[1]);}
static void WindowRemember(void) {
    Rect bounds=WindowBounds();short ref;long count=20;unsigned char bytes[20];
    WStateDataHandle state=(WStateDataHandle)((WindowPeek)gWindow)->dataHandle;
    gWindowZoomed=state && EqualRect(&bounds,&(**state).stdState);
    if(gWindowZoomed && state)bounds=(**state).userState;
    memcpy(bytes,"GHWIN001",8);WindowPutShort(bytes+8,bounds.top);WindowPutShort(bytes+10,bounds.left);
    WindowPutShort(bytes+12,bounds.bottom);WindowPutShort(bytes+14,bounds.right);
    bytes[16]=(unsigned char)gWindowZoomed;bytes[17]=0;WindowPutShort(bytes+18,(short)WindowCheck(bytes));
    if(WindowPreferenceOpen(fsWrPerm,&ref))return;
    if(!FSWrite(ref,&count,bytes) && count==20)SetEOF(ref,20);
    FSClose(ref);
}
static void WindowRestore(void) {
    Rect bounds;unsigned char bytes[20];long count=20,length=0;short ref;int zoom=0;
    OSErr error=WindowPreferenceOpen(fsRdPerm,&ref);
    bounds=WindowDefault();
    if(!error) {
        error=GetEOF(ref,&length);if(!error && length==20)error=FSRead(ref,&count,bytes);else error=paramErr;
        FSClose(ref);
        if(!error && count==20 && !memcmp(bytes,"GHWIN001",8) && bytes[16]<=1 && !bytes[17] &&
           (unsigned short)WindowGetShort(bytes+18)==WindowCheck(bytes)) {
            Rect candidate;
            SetRect(&candidate,WindowGetShort(bytes+10),WindowGetShort(bytes+8),WindowGetShort(bytes+14),WindowGetShort(bytes+12));
            if((long)candidate.right-candidate.left>=620 && (long)candidate.bottom-candidate.top>=420 &&
               (long)candidate.right-candidate.left<16000 && (long)candidate.bottom-candidate.top<16000) {
                bounds=candidate;zoom=bytes[16];
            }
        }
    }
    bounds=WindowFit(bounds);SizeWindow(gWindow,bounds.right-bounds.left,bounds.bottom-bounds.top,false);
    MoveWindow(gWindow,bounds.left,bounds.top,false);
    if(zoom){WindowStandard();ZoomWindow(gWindow,inZoomOut,false);gWindowZoomed=1;}
    WindowRelayout();
}
