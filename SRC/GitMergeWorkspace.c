#include "GitMergeWorkspace.h"
#include <stdlib.h>
#include <string.h>

void MWInit(MWPlan *p) { memset(p,0,sizeof(*p)); }
void MWFree(MWPlan *p) { GQFree(&p->checkout);MSFree(&p->session);MWInit(p); }
void MWSessionInit(MWSession *s) { memset(s,0,sizeof(*s)); }
void MWSessionFree(MWSession *s) {
    MSFree(&s->state);MMFree(&s->review);MSWorkspaceFree(&s->drafts);
    GIFree(&s->workIndex);GIFree(&s->index);GPFree(&s->mapping);MWSessionInit(s);
}
static void *MWCopy(const void *p,size_t n) {
    void *out=malloc(n?n:1);if(out && n)memcpy(out,p,n);return out;
}
static char *MWString(const char *p) { return (char *)MWCopy(p,strlen(p)+1); }
static int MWTick(GDProgress fn,void *ctx) { return fn?fn(ctx):0; }
typedef struct {
    GSRepository *source,objects;
    GOReader bounds;
    size_t stateBytes;
    GDProgress progress;void *context;
} MWIO;
static int MWRead(void *context,const char *key,unsigned char **p,size_t *n) {
    MWIO *io=context;int result;
    *p=NULL;*n=0;
    if(!strncmp(key,"objects/",8))return io->objects.read(io->objects.context,key,p,n);
    result=MWTick(io->progress,io->context);
    if(!result)result=io->source->read(io->source->context,key,p,n);
    if(!result && *n>io->stateBytes)result=GB_SPACE;
    if(!result)result=MWTick(io->progress,io->context);
    if(result){free(*p);*p=NULL;*n=0;}return result;
}
static int MWReplace(void *context,const char *key,const void *a,size_t an,const void *b,size_t bn) {
    MWIO *io=context;int result;
    if(strncmp(key,"objects/",8) || a || an)return GS_FORMAT;
    result=MWTick(io->progress,io->context);
    if(!result)result=io->source->replace(io->source->context,key,NULL,0,b,bn);
    if(!result)result=MWTick(io->progress,io->context);
    return result;
}
static int MWIOStart(GSRepository *source,const MMLimits *limits,GDProgress fn,void *ctx,MWIO *io,GSRepository *r) {
    int result;
    if(!source || !source->read || !source->replace || !limits || !limits->stateBytes)return GB_BAD;
    memset(io,0,sizeof(*io));io->source=source;io->stateBytes=limits->stateBytes;io->progress=fn;io->context=ctx;
    result=GOReadStart(source,&limits->tree.read,fn,ctx,&io->bounds,&io->objects);
    if(!result){r->context=io;r->read=MWRead;r->replace=MWReplace;}return result;
}
static int MWRecheck(GSRepository *r,const MMPlan *p,GBWord generation) {
    unsigned char *bytes=NULL;size_t i,n=0;GBWord next;int result=GTNormalWriteAllowed(r);
    for(i=0;!result && i<5;++i) {
        result=r->read(r->context,p->guards[i].key,&bytes,&n);
        if(result==GS_NOT_FOUND){result=p->guards[i].present?GS_CONFLICT:0;}
        else if(!result && (!p->guards[i].present || n!=p->guards[i].length ||
            (n && memcmp(bytes,p->guards[i].bytes,n))))result=GS_CONFLICT;
        free(bytes);bytes=NULL;
    }
    if(!result)result=GTNextGeneration(r,&next);
    if(!result && generation && generation!=next)result=GS_CONFLICT;
    return result;
}
static int MWPathAdd(MSState *s,const MSLimits *limits,const char *path) {
    char **items,*copy;size_t low=0,high=s->affectedCount,middle,n;int order;
    if(!GIValidPath(path))return GB_BAD;
    n=strlen(path);if(n>limits->pathBytes)return GB_SPACE;
    while(low<high){middle=low+(high-low)/2;order=strcmp(path,s->affected[middle]);
        if(!order)return 0;
        if(order<0)high=middle;else low=middle+1;}
    if(s->affectedCount>=limits->paths || s->affectedCount>=(size_t)-1/sizeof(*items))return GB_SPACE;
    copy=MWString(path);if(!copy)return GB_MEMORY;
    items=(char **)realloc(s->affected,(s->affectedCount+1)*sizeof(*items));
    if(!items){free(copy);return GB_MEMORY;}s->affected=items;
    memmove(items+low+1,items+low,(s->affectedCount-low)*sizeof(*items));items[low]=copy;++s->affectedCount;return 0;
}
static int MWEntrySame(const GIEntry *a,const GIEntry *b) {
    return (!a && !b) || (a && b && a->stat[6]==b->stat[6] &&
        (a->flags & 0xf000U)==(b->flags & 0xf000U) && a->extended==b->extended && !memcmp(a->oid,b->oid,20));
}
static int MWFileSame(const GRSnapshot *a,const GRFile *af,const GRSnapshot *b,const GRFile *bf) {
    if(!af || !bf)return !af && !bf;
    return MWEntrySame(a->index.entries+af->entry,b->index.entries+bf->entry) &&
        af->hasFinderInfo==bf->hasFinderInfo && (!af->hasFinderInfo ||
        MWEntrySame(a->index.entries+af->metadataEntry,b->index.entries+bf->metadataEntry));
}
static int MWAffected(MSState *s,const MMPlan *p,const MSChoices *choices,const GRSnapshot *preview,const MSLimits *limits) {
    const TMNode *node;const GRSnapshot *current=p->files.snapshots+1;
    size_t i,j,a=0,b=0;int result=0,order;
    for(i=0;!result && i<p->files.count;++i) {
        node=p->files.files+i;if(!node->conflicts)continue;
        result=MWPathAdd(s,limits,node->path);
        for(j=0;!result && j<3;++j)if(node->source[j]!=TM_NONE)
            result=MWPathAdd(s,limits,p->files.snapshots[j].files[node->source[j]].path);
    }
    for(i=0;!result && i<choices->count;++i)for(j=0;!result && j<choices->items[i].count;++j)
        result=MWPathAdd(s,limits,choices->items[i].files[j].path);
    while(!result && (a<current->count || b<preview->count)) {
        order=a==current->count?1:b==preview->count?-1:strcmp(current->files[a].path,preview->files[b].path);
        if(order<0)result=MWPathAdd(s,limits,current->files[a++].path);
        else if(order>0)result=MWPathAdd(s,limits,preview->files[b++].path);
        else {if(!MWFileSame(current,current->files+a,preview,preview->files+b))result=MWPathAdd(s,limits,current->files[a].path);++a;++b;}
    }
    return result;
}
typedef struct { char **paths;size_t count; } MWKeys;
static int MWStringOrder(const void *a,const void *b) { return strcmp(*(const char *const *)a,*(const char *const *)b); }
static void MWKeysFree(MWKeys *k) { size_t i;for(i=0;i<k->count;++i)free(k->paths[i]);free(k->paths);memset(k,0,sizeof(*k)); }
static int MWKeysMake(const MSState *s,MWKeys *k) {
    char key[96];size_t i;int result;
    if(s->affectedCount>(size_t)-1/2/sizeof(*k->paths))return GB_SPACE;
    k->paths=(char **)calloc(s->affectedCount?s->affectedCount*2:1,sizeof(*k->paths));if(!k->paths)return GB_MEMORY;
    for(i=0;i<s->affectedCount;++i) {
        k->paths[k->count]=MWString(s->affected[i]);if(!k->paths[k->count])return GB_MEMORY;++k->count;
        result=GIMacMetadataPath(s->affected[i],key);if(result)return result;
        k->paths[k->count]=MWString(key);if(!k->paths[k->count])return GB_MEMORY;++k->count;
    }
    qsort(k->paths,k->count,sizeof(*k->paths),MWStringOrder);return 0;
}
static int MWOwns(const MWKeys *k,const char *path) {
    size_t low=0,high=k->count,middle;int order;
    while(low<high){middle=low+(high-low)/2;order=strcmp(path,k->paths[middle]);
        if(!order)return 1;
        if(order<0)high=middle;else low=middle+1;}return 0;
}
static int MWIndexOrder(const void *a,const void *b) {
    const GIEntry *x=a,*y=b;int order=strcmp(x->path,y->path);
    return order?order:(int)((x->flags>>12)&3)-(int)((y->flags>>12)&3);
}
static int MWIndexSame(const GIIndex *a,const GIIndex *b) {
    size_t i;if(a->count!=b->count)return 0;
    for(i=0;i<a->count;++i)if(strcmp(a->entries[i].path,b->entries[i].path) || !MWEntrySame(a->entries+i,b->entries+i))return 0;
    return 1;
}
static int MWCompose(const GIIndex *head,const GIIndex *original,const GIIndex *target,const MWKeys *keys,GIIndex *out) {
    GIIndex next;const GIIndex *s;const GIEntry *e,*h,*i,*t,*version;size_t n,side,count=0;int result=0,forks=0;
    GIInit(&next);h=GIFind(head,GI_MAC_NAMESPACE "/version",0);i=GIFind(original,GI_MAC_NAMESPACE "/version",0);t=GIFind(target,GI_MAC_NAMESPACE "/version",0);
    if(MWEntrySame(t,h))version=i;else if(MWEntrySame(i,h) || MWEntrySame(i,t))version=t;else return GS_CONFLICT;
    for(side=0;side<2;++side) {
        s=side?target:original;
        for(n=0;n<s->count;++n) {
            e=s->entries+n;if(!strcmp(e->path,GI_MAC_NAMESPACE "/version"))continue;
            if(MWOwns(keys,e->path)!=(int)side)continue;
            if(++count>65535UL)return GB_SPACE;
            if(!strncmp(e->path,GI_MAC_NAMESPACE "/forks/",sizeof(GI_MAC_NAMESPACE "/forks/")-1))forks=1;
        }
    }
    if(forks && !version)version=i?i:t;
    if(forks && !version)return GS_FORMAT;
    if(version)++count;
    next.entries=(GIEntry *)calloc(count?count:1,sizeof(*next.entries));if(!next.entries)return GB_MEMORY;
    for(side=0;side<3 && !result;++side) {
        s=side?target:original;
        for(n=0;n<(side==2?(version?1:0):s->count);++n) {
            e=side==2?version:s->entries+n;
            if(side!=2 && (!strcmp(e->path,GI_MAC_NAMESPACE "/version") || MWOwns(keys,e->path)!=(int)side))continue;
            next.entries[next.count]=*e;next.entries[next.count].path=MWString(e->path);
            if(!next.entries[next.count].path){result=GB_MEMORY;break;}++next.count;
        }
    }
    if(!result){qsort(next.entries,next.count,sizeof(*next.entries),MWIndexOrder);GIFree(out);*out=next;GIInit(&next);}
    GIFree(&next);return result;
}
static int MWBytesSet(MSBytes *out,const void *p,size_t n,int present) {
    unsigned char *bytes=NULL;if(present){bytes=MWCopy(p,n);if(!bytes)return GB_MEMORY;}
    free(out->bytes);out->bytes=bytes;out->length=n;out->present=present;return 0;
}
static int MWMetaSet(GCTransaction *tx,const char *key,const void *before,size_t bn,int bp,const void *after,size_t an,int ap) {
    GCMetadata *m,*items;char *path;unsigned char *a=NULL,*b=NULL;size_t i;
    path=MWString(key);if(!path)return GB_MEMORY;
    if(bp)a=MWCopy(before,bn);
    if(ap)b=MWCopy(after,an);
    if((bp && !a) || (ap && !b)){free(path);free(a);free(b);return GB_MEMORY;}
    for(i=0;i<tx->metadataCount;++i)if(!strcmp(tx->metadata[i].path,key))break;
    if(i==tx->metadataCount) {
        if(i>=(size_t)-1/sizeof(*m)){free(path);free(a);free(b);return GB_SPACE;}
        items=(GCMetadata *)realloc(tx->metadata,(i+1)*sizeof(*m));
        if(!items){free(path);free(a);free(b);return GB_MEMORY;}tx->metadata=items;m=items+i;memset(m,0,sizeof(*m));++tx->metadataCount;
    }
    m=tx->metadata+i;free(m->path);free(m->before);free(m->after);
    m->path=path;m->before=a;m->beforeLength=bn;m->beforePresent=bp;m->after=b;m->afterLength=an;m->afterPresent=ap;return 0;
}
static const GCMetadata *MWMeta(const GCTransaction *t,const char *key) {
    size_t i;for(i=0;i<t->metadataCount;++i)if(!strcmp(t->metadata[i].path,key))return t->metadata+i;return NULL;
}
/* GSPutObject validates existing bytes after this private refusal. It must never
   fall through to the actual store when rederiving a read-only checkpoint. */
static int MWReadOnly(void *ctx,const char *key,const void *a,size_t an,const void *b,size_t bn) {
    (void)ctx;(void)key;(void)a;(void)an;(void)b;(void)bn;return GS_CONFLICT;
}
static int MWMatch(GSRepository *r,const char *key,const MSBytes *expected) {
    unsigned char *p=NULL;size_t n=0;int result=r->read(r->context,key,&p,&n);
    if(result==GS_NOT_FOUND)result=expected->present?GS_CONFLICT:0;
    else if(!result && (!expected->present || n!=expected->length || (n && memcmp(p,expected->bytes,n))))result=GS_CONFLICT;
    free(p);return result;
}
static int MWLive(GSRepository *r,const MSState *s,GBWord *generation) {
    char key[64];MSBytes marker;GBWord next=0;int result=GTNextGeneration(r,&next);
    if(!result && (s->generation>=next || s->revision>=next))result=GS_CONFLICT;
    if(!result && *generation && *generation!=next)result=GS_CONFLICT;
    if(!result)result=MWMatch(r,"HEAD",s->before);
    if(!result)result=GSRefKey(s->branch,key);
    if(!result)result=MWMatch(r,key,s->before+1);
    if(!result)result=MWMatch(r,"index",&s->index);
    if(!result)result=MWMatch(r,"ghclient-map",&s->mapping);
    marker.bytes=s->original;marker.length=s->originalLength;marker.present=1;
    if(!result)result=MWMatch(r,"ghclient-merge",&marker);
    if(!result)*generation=next;
    return result;
}
static int MWMapEntrySame(const GPEntry *a,const GPEntry *b) {
    return a && b && !strcmp(a->path,b->path) && !strcmp(a->native,b->native) &&
        a->mode==b->mode && a->flags==b->flags && !memcmp(a->dataOID,b->dataOID,20) &&
        !memcmp(a->metadataOID,b->metadataOID,20) && !memcmp(a->finderInfo,b->finderInfo,32);
}
static int MWMapCheck(const GRSnapshot *work,const GPMap *map,const GPMap *original,
    const MWKeys *keys,GPEqual eq,void *ctx) {
    GPMap expected;const GPEntry *e;size_t i;int result;
    GPInit(&expected);result=GPBuild(work,map,eq,ctx,&expected);
    if(!result && memcmp(work->tree,map->tree,20))result=GS_CONFLICT;
    for(i=0;!result && i<expected.count;++i)
        if(!MWMapEntrySame(expected.entries+i,GPFind(map,expected.entries[i].path)))result=GS_CONFLICT;
    for(i=0;!result && i<map->count;++i) {
        e=map->entries+i;if(GPFind(&expected,e->path))continue;
        /* Empty retained directories and local reservations have no baseline.
           Other retained identities must originate in the captured old map,
           outside the session's affected set. GPParse checked shape/aliases. */
        if(e->mode==GP_DIRECTORY || e->flags==GP_LOCAL)continue;
        if(MWOwns(keys,e->path) || !MWMapEntrySame(e,GPFind(original,e->path)))result=GS_CONFLICT;
    }
    GPFree(&expected);return result;
}
int MWOpen(GSRepository *source,const MMLimits *limits,const MSLimits *sl,const unsigned char binding[32],
    GPEqual eq,void *eqCtx,GDProgress fn,void *ctx,MWSession *out) {
    MWSession next;MWIO io;GSRepository r;MSState required;MWKeys keys;
    GIIndex original,expected;GPMap oldMap;GRSnapshot preview,work;GIReadLimits readLimits;
    unsigned char *wire=NULL,commit[20],tree[20];size_t n=0,i;GBWord generation=0;int result;
    if(!out || !binding || !eq || !sl)return GB_BAD;
    MWSessionInit(&next);MSInit(&required);memset(&keys,0,sizeof(keys));
    GIInit(&original);GIInit(&expected);GPInit(&oldMap);GRInit(&preview);GRInit(&work);
    result=MWIOStart(source,limits,fn,ctx,&io,&r);r.replace=MWReadOnly;
    if(!result)result=GTWriteAllowed(&r);
    if(!result)result=r.read(r.context,"ghclient-merge",&wire,&n);
    if(!result)result=MSParse(wire,n,sl,eq,eqCtx,&next.state);
    if(!result && memcmp(binding,next.state.binding,32))result=GS_CONFLICT;
    if(!result)result=MWLive(&r,&next.state,&generation);
    if(!result)result=MSRestorePlan(&r,&next.state,limits,fn,ctx,&next.review);
    if(!result)result=MSBuildWorkspace(&r,&next.review,&next.state.choices,fn,ctx,&next.drafts);
    if(!result)result=TMStoreObjects(&r,&next.drafts.preview,fn,ctx);
    if(!result)result=TMStoreObjects(&r,&next.drafts.index,fn,ctx);
    if(!result)result=GIWriteTree(&r,&next.drafts.preview.index,next.tree);
    if(!result)result=GSWriteCommitObject(&r,next.tree,next.review.tips,2,
        "GHClient Merge <merge@localhost>","GHClient Merge <merge@localhost>","0","+0000","GHClient merge workspace",commit);
    if(!result && memcmp(commit,next.state.workspace,20))result=GS_CONFLICT;
    memset(&readLimits,0,sizeof(readLimits));
    if(limits){readLimits.entries=limits->tree.entries;readLimits.depth=limits->tree.depth;readLimits.pathBytes=limits->tree.pathBytes;}
    readLimits.progress=fn;readLimits.context=ctx;
    if(!result)result=GRFromTreeBounded(&r,next.tree,&preview,&readLimits);
    if(!result)result=MWAffected(&required,&next.review,&next.state.choices,&preview,sl);
    if(!result)result=MWKeysMake(&next.state,&keys);
    for(i=0;!result && i<required.affectedCount;++i)if(!MWOwns(&keys,required.affected[i]))result=GS_CONFLICT;
    if(!result && next.state.before[2].present)result=GIParse(next.state.before[2].bytes,next.state.before[2].length,&original);
    for(i=0;!result && i<keys.count;++i)
        if(!MWEntrySame(GIFind(&original,keys.paths[i],0),GIFind(&next.review.files.snapshots[1].index,keys.paths[i],0)))result=GS_CONFLICT;
    if(!result)result=GIParse(next.state.workIndex.bytes,next.state.workIndex.length,&next.workIndex);
    if(!result)result=GIParse(next.state.index.bytes,next.state.index.length,&next.index);
    if(!result)result=MWCompose(&next.review.files.snapshots[1].index,&original,&next.drafts.preview.index,&keys,&expected);
    if(!result && !MWIndexSame(&expected,&next.workIndex))result=GS_CONFLICT;
    if(!result)result=MWCompose(&next.review.files.snapshots[1].index,&original,&next.drafts.index.index,&keys,&expected);
    if(!result && !MWIndexSame(&expected,&next.index))result=GS_CONFLICT;
    if(!result)result=GIWriteTree(&r,&next.workIndex,tree);
    if(!result)result=GRFromTreeBounded(&r,tree,&work,&readLimits);
    if(!result)result=GPParse(next.state.mapping.bytes,next.state.mapping.length,eq,eqCtx,&next.mapping);
    if(!result && next.state.before[3].present)result=GPParse(next.state.before[3].bytes,next.state.before[3].length,eq,eqCtx,&oldMap);
    if(!result)result=MWMapCheck(&work,&next.mapping,&oldMap,&keys,eq,eqCtx);
    if(!result)result=MWLive(&r,&next.state,&generation);
    if(!result)result=MWTick(fn,ctx);
    if(!result){MWSessionFree(out);*out=next;MWSessionInit(&next);}
    free(wire);MWKeysFree(&keys);MSFree(&required);GIFree(&original);GIFree(&expected);
    GPFree(&oldMap);GRFree(&preview);GRFree(&work);MWSessionFree(&next);return result;
}
int MWBegin(GSRepository *source,const MMPlan *p,const MSChoices *choices,const MSLimits *limits,
    const unsigned char binding[32],const GQWork *work,size_t count,GPEqual eq,void *eqCtx,GDProgress fn,void *ctx,MWPlan *out,GQError *why) {
    MWPlan next;MSWorkspace drafts;MSState parsed;MWIO io;GSRepository r;
    GRSnapshot preview;GIIndex original,expected,actual;MWKeys keys;GIReadLimits readLimits;GQProtection protection;
    const GCMetadata *map,*index;unsigned char *bytes=NULL,*wire=NULL;size_t n=0,wn=0,i;GBWord generation=0;int result;
    if(!p || p->kind!=MM_CONFLICT || !choices || !limits || !binding || !out || !eq || (count && !work))return GB_BAD;
    if(why)memset(why,0,sizeof(*why));
    MWInit(&next);MSWorkspaceInit(&drafts);MSInit(&parsed);GRInit(&preview);GIInit(&original);GIInit(&expected);GIInit(&actual);memset(&keys,0,sizeof(keys));
    result=MWIOStart(source,&p->limits,fn,ctx,&io,&r);
    if(!result)result=MWRecheck(&r,p,0);
    if(!result)result=GTNextGeneration(&r,&generation);
    if(!result && generation==0xffffffffU)result=GB_SPACE; /* Reserve an exit. */
    if(!result)result=MSCapture(p,&next.session);
    if(!result)result=MSBuildWorkspace(&r,p,choices,fn,ctx,&drafts);
    if(!result)result=TMStoreObjects(&r,&drafts.preview,fn,ctx);
    if(!result)result=GIWriteTree(&r,&drafts.preview.index,next.tree);
    if(!result)result=GSWriteCommitObject(&r,next.tree,p->tips,2,"GHClient Merge <merge@localhost>","GHClient Merge <merge@localhost>",
        "0","+0000","GHClient merge workspace",next.session.workspace);
    memset(&readLimits,0,sizeof(readLimits));readLimits.entries=p->limits.tree.entries;readLimits.depth=p->limits.tree.depth;
    readLimits.pathBytes=p->limits.tree.pathBytes;readLimits.progress=fn;readLimits.context=ctx;
    if(!result)result=GRFromTreeBounded(&r,next.tree,&preview,&readLimits);
    if(!result)result=MWAffected(&next.session,p,choices,&preview,limits);
    if(!result)result=MWKeysMake(&next.session,&keys);
    protection.paths=(const char *const *)next.session.affected;protection.count=next.session.affectedCount;protection.changed=1;
    if(!result)result=GQToCommitProtected(&r,p->branch,p->tips,next.session.workspace,work,count,&protection,eq,eqCtx,&next.checkout,why);
    if(!result && p->guards[2].present)result=GIParse(p->guards[2].bytes,p->guards[2].length,&original);
    if(!result)result=MWCompose(&p->files.snapshots[1].index,&original,&drafts.preview.index,&keys,&expected);
    if(!result && !MWIndexSame(&expected,&next.checkout.index))result=GS_CONFLICT;
    if(!result)result=MWCompose(&p->files.snapshots[1].index,&original,&drafts.index.index,&keys,&actual);
    if(!result)result=TMStoreObjects(&r,&drafts.index,fn,ctx);
    if(!result)result=GIEncode(&actual,&bytes,&n);
    if(!result)result=MWBytesSet(&next.session.index,bytes,n,1);
    free(bytes);bytes=NULL;
    index=MWMeta(&next.checkout.transaction,"index");map=MWMeta(&next.checkout.transaction,"ghclient-map");
    if(!result && (!index || !map))result=GS_FORMAT;
    if(!result)result=MWBytesSet(&next.session.workIndex,index->after,index->afterLength,index->afterPresent);
    if(!result)result=MWBytesSet(&next.session.mapping,map->after,map->afterLength,map->afterPresent);
    if(!result) {
        MSChoicesFree(&next.session.choices);next.session.choices=*choices;
        next.session.generation=generation;next.session.revision=generation;memcpy(next.session.binding,binding,32);
        result=MSEncode(&next.session,limits,eq,eqCtx,&wire,&wn);
        MSChoicesInit(&next.session.choices); /* Borrowed descriptors, even on error. */
    }
    if(!result)result=MSParse(wire,wn,limits,eq,eqCtx,&parsed);
    if(!result){MSFree(&next.session);next.session=parsed;MSInit(&parsed);}
    for(i=0;!result && i<5;++i) {
        const MMGuard *g=p->guards+i;
        if(i==2)result=MWMetaSet(&next.checkout.transaction,g->key,g->bytes,g->length,g->present,
            next.session.index.bytes,next.session.index.length,next.session.index.present);
        else if(i!=3)result=MWMetaSet(&next.checkout.transaction,g->key,g->bytes,g->length,g->present,g->bytes,g->length,g->present);
    }
    if(!result)result=MWMetaSet(&next.checkout.transaction,"ghclient-merge",NULL,0,0,wire,wn,1);
    next.checkout.transaction.generation=generation;next.unresolved=drafts.index.unresolved;
    if(!result)result=GCEncode(&next.checkout.transaction,eq,eqCtx,&bytes,&n);
    if(!result)result=MWRecheck(&r,p,generation);
    if(!result)result=MWTick(fn,ctx);
    if(!result){MWFree(out);*out=next;MWInit(&next);}
    free(bytes);free(wire);MWKeysFree(&keys);
    GIFree(&original);GIFree(&expected);GIFree(&actual);GRFree(&preview);MSFree(&parsed);MSWorkspaceFree(&drafts);MWFree(&next);return result;
}
int MWStart(GSRepository *r,GCBackend *b,GTControl *c,const unsigned char binding[32],GPEqual eq,void *ctx,const MWPlan *p) {
    const GCMetadata *m;
    if(!p || !binding || memcmp(binding,p->session.binding,32) || !p->session.original ||
       p->session.generation!=p->checkout.transaction.generation || p->session.revision!=p->session.generation)return GS_CONFLICT;
    m=MWMeta(&p->checkout.transaction,"ghclient-merge");
    if(!m || m->beforePresent || !m->afterPresent || m->afterLength!=p->session.originalLength ||
        memcmp(m->after,p->session.original,m->afterLength))return GS_CONFLICT;
    return GTStartAtGeneration(r,b,c,binding,eq,ctx,p->session.generation,&p->checkout.transaction);
}
typedef struct {
    GSRepository *source;const MSState *state;MSBytes ref;char key[64];
} MWView;
static int MWViewRead(void *context,const char *key,unsigned char **p,size_t *n) {
    MWView *v=context;const MSBytes *b=NULL;
    if(!strcmp(key,v->key))b=&v->ref;
    else if(!strcmp(key,"HEAD"))b=v->state->before;
    else if(!strcmp(key,"index"))b=&v->state->workIndex;
    else if(!strcmp(key,"ghclient-map"))b=&v->state->mapping;
    if(!b)return v->source->read(v->source->context,key,p,n);
    *p=NULL;*n=0;if(!b->present)return GS_NOT_FOUND;
    *p=MWCopy(b->bytes,b->length);if(!*p)return GB_MEMORY;*n=b->length;return 0;
}
static int MWViewReplace(void *context,const char *key,const void *a,size_t an,const void *b,size_t bn) {
    MWView *v=context;
    if(strncmp(key,"objects/",8) || a || an)return GS_FORMAT;
    return v->source->replace(v->source->context,key,NULL,0,b,bn);
}
static int MWViewStart(GSRepository *source,const MSState *s,MWView *v,GSRepository *r) {
    char hex[41];int result;memset(v,0,sizeof(*v));v->source=source;v->state=s;
    result=GSRefKey(s->branch,v->key);
    if(!result)result=MWBytesSet(&v->ref,s->before[1].bytes,s->before[1].length,1);
    if(!result) {
        GBOIDFormat(s->workspace,hex);memcpy(v->ref.bytes+strlen(s->branch)+1,hex,40);
        r->context=v;r->read=MWViewRead;r->replace=MWViewReplace;
    }
    return result;
}
static const GRFile *MWFileAt(const GRSnapshot *s,const char *path) {
    size_t low=0,high=s->count,middle;
    while(low<high){middle=low+(high-low)/2;if(strcmp(s->files[middle].path,path)<0)low=middle+1;else high=middle;}
    return low<s->count && !strcmp(s->files[low].path,path)?s->files+low:NULL;
}
static int MWTake(GSRepository *r,const char *key,MSBytes *b) {
    unsigned char *p=NULL;size_t n=0;int result=r->read(r->context,key,&p,&n);
    if(result==GS_NOT_FOUND)return MWBytesSet(b,NULL,0,0);
    if(!result)result=MWBytesSet(b,p,n,1);
    free(p);return result;
}
static int MWRefShape(const MSBytes *b,const char *name) {
    char hex[41];unsigned char oid[20];size_t n=strlen(name);
    if(!b->present)return 0;
    if(b->length!=n+42 || memcmp(b->bytes,name,n+1) || b->bytes[n+41]!='\n')return GS_FORMAT;
    memcpy(hex,b->bytes+n+1,40);hex[40]=0;return GBOIDParse(hex,oid);
}
int MWUpdate(GSRepository *source,const void *expectedWire,size_t expectedLength,const MMLimits *limits,const MSLimits *sl,
    const unsigned char binding[32],const MSChoices *choices,const GQWork *work,size_t count,GPEqual eq,void *eqCtx,
    GDProgress fn,void *ctx,MWPlan *out,GQError *why) {
    MWSession old;MWPlan next;MSWorkspace drafts;MSState parsed,strict;MSBytes incoming;
    MWIO io;MWView view;GSRepository r,virtualRepo;MWKeys keys,oldKeys;GIIndex original,composed;
    GRSnapshot before,after;GIReadLimits readLimits;GQProtection protection,owned;
    const GCMetadata *map,*index;unsigned char *bytes=NULL,*wire=NULL;size_t n=0,wn=0,i;GBWord generation=0;
    char incomingKey[64],branchKey[64];int result;
    if(!expectedWire || !expectedLength || !limits || !sl || !binding || !choices || !out || !eq || (count && !work))return GB_BAD;
    if(why)memset(why,0,sizeof(*why));
    MWSessionInit(&old);MWInit(&next);MSWorkspaceInit(&drafts);MSInit(&parsed);MSInit(&strict);
    memset(&incoming,0,sizeof(incoming));memset(&view,0,sizeof(view));memset(&keys,0,sizeof(keys));memset(&oldKeys,0,sizeof(oldKeys));
    GIInit(&original);GIInit(&composed);GRInit(&before);GRInit(&after);
    result=MWOpen(source,limits,sl,binding,eq,eqCtx,fn,ctx,&old);
    if(!result && (expectedLength!=old.state.originalLength || memcmp(expectedWire,old.state.original,expectedLength)))result=GS_CONFLICT;
    if(!result)result=MWIOStart(source,limits,fn,ctx,&io,&r);
    if(!result)result=MWLive(&r,&old.state,&generation);
    if(!result && generation==0xffffffffU)result=GB_SPACE; /* Reserve an exit. */
    if(!result)result=GSRefKey(old.state.otherRef,incomingKey);
    if(!result)result=MWTake(&r,incomingKey,&incoming);
    if(!result)result=MWRefShape(&incoming,old.state.otherRef);
    if(!result)result=MSParse(old.state.original,old.state.originalLength,sl,eq,eqCtx,&next.session);
    if(!result)result=MSBuildWorkspace(&r,&old.review,choices,fn,ctx,&drafts);
    if(!result)result=TMStoreObjects(&r,&drafts.preview,fn,ctx);
    if(!result)result=TMStoreObjects(&r,&drafts.index,fn,ctx);
    if(!result)result=GIWriteTree(&r,&drafts.preview.index,next.tree);
    if(!result)result=GSWriteCommitObject(&r,next.tree,old.review.tips,2,"GHClient Merge <merge@localhost>",
        "GHClient Merge <merge@localhost>","0","+0000","GHClient merge workspace",next.session.workspace);
    memset(&readLimits,0,sizeof(readLimits));readLimits.entries=limits->tree.entries;readLimits.depth=limits->tree.depth;
    readLimits.pathBytes=limits->tree.pathBytes;readLimits.progress=fn;readLimits.context=ctx;
    if(!result)result=GRFromTreeBounded(&r,old.tree,&before,&readLimits);
    if(!result)result=GRFromTreeBounded(&r,next.tree,&after,&readLimits);
    if(!result)result=MWAffected(&next.session,&old.review,choices,&after,sl);
    if(!result)result=MWKeysMake(&old.state,&oldKeys);
    if(!result)result=MWKeysMake(&next.session,&keys);
    for(i=0;!result && i<next.session.affectedCount;++i) {
        const char *path=next.session.affected[i];
        if(!MWOwns(&oldKeys,path) || MWFileSame(&before,MWFileAt(&before,path),&after,MWFileAt(&after,path)))
            result=MWPathAdd(&strict,sl,path);
    }
    protection.paths=(const char *const *)strict.affected;protection.count=strict.affectedCount;protection.changed=0;
    owned.paths=(const char *const *)old.state.affected;owned.count=old.state.affectedCount;owned.changed=0;
    if(!result)result=MWViewStart(&r,&old.state,&view,&virtualRepo);
    if(!result)result=GQToCommitOwned(&virtualRepo,old.state.branch,old.state.workspace,next.session.workspace,
        work,count,&protection,&owned,eq,eqCtx,&next.checkout,why);
    if(!result && old.state.before[2].present)result=GIParse(old.state.before[2].bytes,old.state.before[2].length,&original);
    if(!result)result=MWCompose(&old.review.files.snapshots[1].index,&original,&drafts.preview.index,&keys,&composed);
    if(!result && !MWIndexSame(&composed,&next.checkout.index))result=GS_CONFLICT;
    if(!result)result=MWCompose(&old.review.files.snapshots[1].index,&original,&drafts.index.index,&keys,&composed);
    if(!result)result=GIEncode(&composed,&bytes,&n);
    if(!result)result=MWBytesSet(&next.session.index,bytes,n,1);
    free(bytes);bytes=NULL;
    index=MWMeta(&next.checkout.transaction,"index");map=MWMeta(&next.checkout.transaction,"ghclient-map");
    if(!result && (!index || !map))result=GS_FORMAT;
    if(!result)result=MWBytesSet(&next.session.workIndex,index->after,index->afterLength,index->afterPresent);
    if(!result)result=MWBytesSet(&next.session.mapping,map->after,map->afterLength,map->afterPresent);
    if(!result) {
        MSChoicesFree(&next.session.choices);next.session.choices=*choices;
        next.session.revision=generation;
        result=MSEncode(&next.session,sl,eq,eqCtx,&wire,&wn);MSChoicesInit(&next.session.choices);
    }
    if(!result)result=MSParse(wire,wn,sl,eq,eqCtx,&parsed);
    if(!result){MSFree(&next.session);next.session=parsed;MSInit(&parsed);}
    if(!result)result=GSRefKey(old.state.branch,branchKey);
    if(!result)result=MWMetaSet(&next.checkout.transaction,"HEAD",old.state.before[0].bytes,old.state.before[0].length,1,
        old.state.before[0].bytes,old.state.before[0].length,1);
    if(!result)result=MWMetaSet(&next.checkout.transaction,branchKey,old.state.before[1].bytes,old.state.before[1].length,1,
        old.state.before[1].bytes,old.state.before[1].length,1);
    if(!result)result=MWMetaSet(&next.checkout.transaction,"index",old.state.index.bytes,old.state.index.length,1,
        next.session.index.bytes,next.session.index.length,1);
    if(!result)result=MWMetaSet(&next.checkout.transaction,incomingKey,incoming.bytes,incoming.length,incoming.present,
        incoming.bytes,incoming.length,incoming.present);
    if(!result)result=MWMetaSet(&next.checkout.transaction,"ghclient-merge",old.state.original,old.state.originalLength,1,wire,wn,1);
    next.checkout.transaction.generation=generation;next.unresolved=drafts.index.unresolved;
    if(!result)result=GCEncode(&next.checkout.transaction,eq,eqCtx,&bytes,&n);
    if(!result)result=MWLive(&r,&old.state,&generation);
    if(!result)result=MWMatch(&r,incomingKey,&incoming);
    if(!result)result=MWTick(fn,ctx);
    if(!result){MWFree(out);*out=next;MWInit(&next);}
    free(bytes);free(wire);free(view.ref.bytes);free(incoming.bytes);MWKeysFree(&keys);MWKeysFree(&oldKeys);
    GIFree(&original);GIFree(&composed);GRFree(&before);GRFree(&after);MSFree(&strict);MSFree(&parsed);
    MSWorkspaceFree(&drafts);MWSessionFree(&old);MWFree(&next);return result;
}
int MWUpdateStart(GSRepository *r,GCBackend *b,GTControl *c,const unsigned char binding[32],GPEqual eq,void *ctx,const MWPlan *p) {
    const GCMetadata *m;
    if(!p || !binding || memcmp(binding,p->session.binding,32) || !p->session.original || !p->session.generation ||
        p->session.generation>=p->checkout.transaction.generation || p->session.revision!=p->checkout.transaction.generation)return GS_CONFLICT;
    m=MWMeta(&p->checkout.transaction,"ghclient-merge");
    if(!m || !m->beforePresent || !m->beforeLength || !m->afterPresent || m->afterLength!=p->session.originalLength ||
        memcmp(m->after,p->session.original,m->afterLength))return GS_CONFLICT;
    return GTStartAtGeneration(r,b,c,binding,eq,ctx,p->checkout.transaction.generation,&p->checkout.transaction);
}

int MWContinue(GSRepository *source,const void *expectedWire,size_t expectedLength,const MMLimits *limits,const MSLimits *sl,
    const unsigned char binding[32],const GQWork *work,size_t count,GPEqual eq,void *eqCtx,
    const char *author,const char *committer,const char *seconds,const char *zone,const char *message,
    GDProgress fn,void *ctx,MWPlan *out,GQError *why) {
    MWSession old;MWPlan next;MWIO io;MWView view;GSRepository r,virtualRepo;MSBytes incoming;
    GQProtection protection;const GCMetadata *index;unsigned char *bytes=NULL;size_t n=0,i;
    GBWord generation=0;char incomingKey[64],branchKey[64];int result;
    if(!expectedWire || !expectedLength || !limits || !sl || !binding || !out || !eq || (count && !work))return GB_BAD;
    if(why)memset(why,0,sizeof(*why));
    MWSessionInit(&old);MWInit(&next);memset(&view,0,sizeof(view));memset(&incoming,0,sizeof(incoming));
    result=MWOpen(source,limits,sl,binding,eq,eqCtx,fn,ctx,&old);
    if(!result && (expectedLength!=old.state.originalLength || memcmp(expectedWire,old.state.original,expectedLength)))result=GS_CONFLICT;
    if(!result && old.drafts.index.unresolved)result=GI_UNMERGED;
    for(i=0;!result && i<old.index.count;++i)if(old.index.entries[i].flags & 0x3000U)result=GI_UNMERGED;
    if(!result && !MWIndexSame(&old.index,&old.workIndex))result=GS_CONFLICT;
    if(!result)result=MWIOStart(source,limits,fn,ctx,&io,&r);
    if(!result)result=MWLive(&r,&old.state,&generation);
    if(!result)result=GSRefKey(old.state.otherRef,incomingKey);
    if(!result)result=MWTake(&r,incomingKey,&incoming);
    if(!result)result=MWRefShape(&incoming,old.state.otherRef);
    if(!result) {
        memcpy(next.tree,old.tree,20);
        if((old.state.options & MM_SQUASH) && !memcmp(next.tree,old.review.trees[1],20))
            memcpy(next.commit,old.state.tips,20); /* Complete a no-net-change session without an empty commit. */
        else result=GSWriteCommitObject(&r,next.tree,old.state.tips,(old.state.options & MM_SQUASH)?1:2,
            author,committer,seconds,zone,message,next.commit);
    }
    protection.paths=(const char *const *)old.state.affected;protection.count=old.state.affectedCount;protection.changed=0;
    if(!result)result=MWViewStart(&r,&old.state,&view,&virtualRepo);
    if(!result)result=GQToCommitProtected(&virtualRepo,old.state.branch,old.state.workspace,next.commit,
        work,count,&protection,eq,eqCtx,&next.checkout,why);
    if(!result && !MWIndexSame(&next.checkout.index,&old.workIndex))result=GS_CONFLICT;
    index=MWMeta(&next.checkout.transaction,"index");
    if(!result && !index)result=GS_FORMAT;
    if(!result)result=GSRefKey(old.state.branch,branchKey);
    if(!result)result=MWMetaSet(&next.checkout.transaction,"HEAD",old.state.before[0].bytes,old.state.before[0].length,1,
        old.state.before[0].bytes,old.state.before[0].length,1);
    if(!result) {
        /* The after ref already names the final commit. Replace only its
           virtual before bytes, retaining the real original branch tip. */
        const GCMetadata *ref=MWMeta(&next.checkout.transaction,branchKey);
        if(!ref)result=GS_FORMAT;
        else result=MWMetaSet(&next.checkout.transaction,branchKey,old.state.before[1].bytes,old.state.before[1].length,1,
            ref->after,ref->afterLength,ref->afterPresent);
    }
    if(!result)result=MWMetaSet(&next.checkout.transaction,"index",old.state.index.bytes,old.state.index.length,1,
        index->after,index->afterLength,index->afterPresent);
    if(!result)result=MWMetaSet(&next.checkout.transaction,incomingKey,incoming.bytes,incoming.length,incoming.present,
        incoming.bytes,incoming.length,incoming.present);
    if(!result)result=MWMetaSet(&next.checkout.transaction,"ghclient-merge",old.state.original,old.state.originalLength,1,NULL,0,0);
    next.checkout.transaction.generation=generation;next.exitAction=1;
    if(!result)result=GCEncode(&next.checkout.transaction,eq,eqCtx,&bytes,&n);
    if(!result)result=MWLive(&r,&old.state,&generation);
    if(!result)result=MWMatch(&r,incomingKey,&incoming);
    if(!result)result=MWTick(fn,ctx);
    if(!result) {
        next.session=old.state;MSInit(&old.state);
        MWFree(out);*out=next;MWInit(&next);
    }
    free(bytes);free(view.ref.bytes);free(incoming.bytes);MWSessionFree(&old);MWFree(&next);return result;
}
static int MWExitStart(GSRepository *r,GCBackend *b,GTControl *c,const unsigned char binding[32],GPEqual eq,void *ctx,const MWPlan *p,int action) {
    const GCMetadata *m;
    if(!p || !binding || memcmp(binding,p->session.binding,32) || !p->session.original || !p->session.revision ||
        p->session.revision>=p->checkout.transaction.generation || p->unresolved || p->exitAction!=action)return GS_CONFLICT;
    m=MWMeta(&p->checkout.transaction,"ghclient-merge");
    if(!m || !m->beforePresent || m->afterPresent || m->beforeLength!=p->session.originalLength ||
        memcmp(m->before,p->session.original,m->beforeLength))return GS_CONFLICT;
    return GTStartAtGeneration(r,b,c,binding,eq,ctx,p->checkout.transaction.generation,&p->checkout.transaction);
}
int MWContinueStart(GSRepository *r,GCBackend *b,GTControl *c,const unsigned char binding[32],GPEqual eq,void *ctx,const MWPlan *p) {
    return MWExitStart(r,b,c,binding,eq,ctx,p,1);
}
int MWAbortStart(GSRepository *r,GCBackend *b,GTControl *c,const unsigned char binding[32],GPEqual eq,void *ctx,const MWPlan *p) {
    return MWExitStart(r,b,c,binding,eq,ctx,p,2);
}
static int MWBinding(GPEqual eq,void *ctx,const GPMap *map,const char *native,const char *path,GQError *why) {
    char *logical=NULL;size_t n;int result=GPResolve(map,native,eq,ctx,&logical);
    if(!result && strcmp(logical,path))result=GS_CONFLICT;
    free(logical);
    if(result && why) {
        why->reason=GQ_INVENTORY;n=strlen(path);if(n>=sizeof(why->path))n=sizeof(why->path)-1;
        memcpy(why->path,path,n);why->path[n]=0;
    }
    return result;
}
static int MWAbortBindings(const GQPlan *p,const GPMap *original,const GQWork *work,size_t count,GPEqual eq,void *ctx,GQError *why) {
    size_t i,j;const GCOperation *op;const GPEntry *entry;int result=0;
    for(i=0;!result && i<count;++i) {
        if(work[i].file.present!=1)continue;
        for(j=0;j<p->transaction.fileCount;++j)if(p->transaction.files[j].oldPath && !strcmp(work[i].native,p->transaction.files[j].oldPath))break;
        if(j==p->transaction.fileCount)result=MWBinding(eq,ctx,original,work[i].native,work[i].path,why);
    }
    for(i=0;!result && i<p->transaction.fileCount;++i) {
        op=p->transaction.files+i;if(!op->newFile.present)continue;
        entry=NULL;
        for(j=0;j<p->mapping.count;++j)if(!strcmp(p->mapping.entries[j].native,op->newPath)){entry=p->mapping.entries+j;break;}
        if(!entry)result=GS_FORMAT;
        else result=MWBinding(eq,ctx,original,op->newPath,entry->path,why);
    }
    return result;
}
int MWAbort(GSRepository *source,const void *expectedWire,size_t expectedLength,const MMLimits *limits,const MSLimits *sl,
    const unsigned char binding[32],const GQWork *work,size_t count,GPEqual eq,void *eqCtx,GDProgress fn,void *ctx,MWPlan *out,GQError *why) {
    MWSession old;MWPlan next;MWIO io;MWView view;GSRepository r,virtualRepo;MSBytes incoming;
    GIIndex original;GPMap mapping;GQProtection protection;unsigned char *bytes=NULL;size_t n=0;
    GBWord generation=0;char incomingKey[64],branchKey[64];int result;
    if(!expectedWire || !expectedLength || !limits || !sl || !binding || !out || !eq || (count && !work))return GB_BAD;
    if(why)memset(why,0,sizeof(*why));
    MWSessionInit(&old);MWInit(&next);memset(&view,0,sizeof(view));memset(&incoming,0,sizeof(incoming));GIInit(&original);GPInit(&mapping);
    result=MWOpen(source,limits,sl,binding,eq,eqCtx,fn,ctx,&old);
    if(!result && (expectedLength!=old.state.originalLength || memcmp(expectedWire,old.state.original,expectedLength)))result=GS_CONFLICT;
    if(!result)result=MWIOStart(source,limits,fn,ctx,&io,&r);
    if(!result)result=MWLive(&r,&old.state,&generation);
    if(!result)result=GSRefKey(old.state.otherRef,incomingKey);
    if(!result)result=MWTake(&r,incomingKey,&incoming);
    if(!result)result=MWRefShape(&incoming,old.state.otherRef);
    if(!result && old.state.before[2].present)result=GIParse(old.state.before[2].bytes,old.state.before[2].length,&original);
    if(!result && old.state.before[3].present)result=GPParse(old.state.before[3].bytes,old.state.before[3].length,eq,eqCtx,&mapping);
    protection.paths=(const char *const *)old.state.affected;protection.count=old.state.affectedCount;protection.changed=0;
    if(!result)result=MWViewStart(&r,&old.state,&view,&virtualRepo);
    if(!result)result=GQToCommitRestored(&virtualRepo,old.state.branch,old.state.workspace,old.state.tips,
        work,count,&protection,&mapping,eq,eqCtx,&next.checkout,why);
    if(!result && !MWIndexSame(&next.checkout.index,&original))result=GS_CONFLICT;
    if(!result)result=MWAbortBindings(&next.checkout,&mapping,work,count,eq,eqCtx,why);
    if(!result)result=GSRefKey(old.state.branch,branchKey);
    if(!result)result=MWMetaSet(&next.checkout.transaction,"HEAD",old.state.before[0].bytes,old.state.before[0].length,1,
        old.state.before[0].bytes,old.state.before[0].length,1);
    if(!result)result=MWMetaSet(&next.checkout.transaction,branchKey,old.state.before[1].bytes,old.state.before[1].length,1,
        old.state.before[1].bytes,old.state.before[1].length,1);
    if(!result)result=MWMetaSet(&next.checkout.transaction,"index",old.state.index.bytes,old.state.index.length,1,
        old.state.before[2].bytes,old.state.before[2].length,old.state.before[2].present);
    if(!result)result=MWMetaSet(&next.checkout.transaction,"ghclient-map",old.state.mapping.bytes,old.state.mapping.length,1,
        old.state.before[3].bytes,old.state.before[3].length,old.state.before[3].present);
    if(!result)result=MWMetaSet(&next.checkout.transaction,incomingKey,incoming.bytes,incoming.length,incoming.present,
        incoming.bytes,incoming.length,incoming.present);
    if(!result)result=MWMetaSet(&next.checkout.transaction,"ghclient-merge",old.state.original,old.state.originalLength,1,NULL,0,0);
    next.checkout.transaction.generation=generation;next.exitAction=2;
    if(!result)result=GCEncode(&next.checkout.transaction,eq,eqCtx,&bytes,&n);
    if(!result)result=MWLive(&r,&old.state,&generation);
    if(!result)result=MWMatch(&r,incomingKey,&incoming);
    if(!result)result=MWTick(fn,ctx);
    if(!result) {
        memcpy(next.commit,old.state.tips,20);memcpy(next.tree,old.state.trees[1],20);
        next.session=old.state;MSInit(&old.state);MWFree(out);*out=next;MWInit(&next);
    }
    free(bytes);free(view.ref.bytes);free(incoming.bytes);GIFree(&original);GPFree(&mapping);MWSessionFree(&old);MWFree(&next);return result;
}
