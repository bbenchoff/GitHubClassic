#include "GitCheckoutPlan.h"
#include <stdlib.h>
#include <string.h>

typedef struct {
    const char *path;
    const GRFile *h, *i, *t, *selected;
    const GRSnapshot *source;
    const GQWork *w;
    GCFile hf, inf, tf;
    int retain, change;
} GQNode;

void GQInit(GQPlan *p) { memset(p, 0, sizeof(*p)); }
void GQFree(GQPlan *p) {
    GCFree(&p->transaction);
    GIFree(&p->index);
    GPFree(&p->mapping);
    GQInit(p);
}
static void *GQCopy(const void *bytes, size_t n) {
    void *p = malloc(n ? n : 1);
    if (p && n)
        memcpy(p, bytes, n);
    return p;
}
static char *GQString(const char *s) { return (char *)GQCopy(s, strlen(s) + 1); }
static int GQFail(GQError *e, int reason, const char *path) {
    size_t n;
    if (e) {
        e->reason = reason;
        n = strlen(path);
        if (n >= sizeof(e->path))
            n = sizeof(e->path) - 1;
        memcpy(e->path, path, n);
        e->path[n] = 0;
    }
    return GS_CONFLICT;
}
static int GQBelow(const char *parent, const char *child) {
    size_t n = strlen(parent);
    return !strncmp(parent, child, n) && child[n] == '/';
}
static void GQNormalize(unsigned char info[32]) {
    info[8] &= (unsigned char)~1U;
    memset(info + 10, 0, 6);
    memset(info + 28, 0, 4);
}
static int GQEntryEqual(const GIEntry *a, const GIEntry *b) {
    return (!a && !b) || (a && b && a->stat[6] == b->stat[6] && !memcmp(a->oid, b->oid, 20));
}
static int GQLogical(const GRSnapshot *a, const GRFile *af, const GRSnapshot *b, const GRFile *bf) {
    if (!af || !bf)
        return !af && !bf;
    if (!GQEntryEqual(a->index.entries + af->entry, b->index.entries + bf->entry) ||
        af->hasFinderInfo != bf->hasFinderInfo)
        return 0;
    return !af->hasFinderInfo ||
           GQEntryEqual(a->index.entries + af->metadataEntry, b->index.entries + bf->metadataEntry);
}
static int GQIdentity(GSRepository *r, const GRSnapshot *s, const GRFile *f, const GPMap *defaults, GCFile *out) {
    GRContents c;
    int result;
    memset(out, 0, sizeof(*out));
    if (!f)
        return 0;
    if (f->mode == 0160000)
        return GI_UNSUPPORTED;
    GRContentsInit(&c);
    result = GRReadFile(r, s, (size_t)(f - s->files), &c);
    if (!result) {
        out->present = 1;
        memcpy(out->dataOID, s->index.entries[f->entry].oid, 20);
        result = GBObjectID("blob", c.resource, c.resourceLength, out->resourceOID);
        if (c.hasFinderInfo)
            memcpy(out->finderInfo, c.finderInfo, 32);
        else
            GPDefaultFinderInfo(defaults, f->path, out->finderInfo);
        GQNormalize(out->finderInfo);
    }
    GRContentsFree(&c);
    return result;
}
static int GQNativeEqual(const char *a, const char *b, GPEqual eq, void *ctx) {
    char ac[32], bc[32];
    const char *x, *y;
    size_t an, bn;
    for (;;) {
        x = strchr(a, ':');
        y = strchr(b, ':');
        an = x ? (size_t)(x - a) : strlen(a);
        bn = y ? (size_t)(y - b) : strlen(b);
        if (an > 31 || bn > 31)
            return 0;
        memcpy(ac, a, an);
        ac[an] = 0;
        memcpy(bc, b, bn);
        bc[bn] = 0;
        if (!eq(ctx, ac, bc) || !!x != !!y)
            return 0;
        if (!x)
            return 1;
        a = x + 1;
        b = y + 1;
    }
}
static int GQInventory(const GPMap *map, const GQWork *w, size_t count, GPEqual eq, void *ctx,
                       GQError *error,int transitions) {
    size_t i, j, n, pn;
    const char *slash, *colon;
    char *resolved;
    unsigned char info[32], zero[72];
    int result;
    memset(zero, 0, sizeof(zero));
    for (i = 0; i < count; ++i) {
        if (!GIValidPath(w[i].path) || !w[i].native ||
            (w[i].file.present != 1 && w[i].file.present != 2))
            return GB_BAD;
        result = transitions?GPResolveWork(map,w[i].native,eq,ctx,&resolved):GPResolve(map,w[i].native,eq,ctx,&resolved);
        if (result) {
            /* A resolver allocation/size failure is not an alias obstruction.
               Callers may try another map only for an actual conflict. */
            if(result==GB_MEMORY || result==GB_SPACE)return result;
            return GQFail(error, GQ_INVENTORY, w[i].path);
        }
        result = strcmp(resolved, w[i].path);
        free(resolved);
        if (result)
            return GQFail(error, GQ_INVENTORY, w[i].path);
        memcpy(info, w[i].file.finderInfo, 32);
        GQNormalize(info);
        if (memcmp(info, w[i].file.finderInfo, 32))
            return GS_FORMAT;
        if (w[i].file.present == 2 &&
            (memcmp(w[i].file.dataOID, zero, 20) || memcmp(w[i].file.resourceOID, zero, 20) ||
             memcmp(info, zero, 32)))
            return GS_FORMAT;
        for (j = 0; j < i; ++j)
            if (!strcmp(w[i].path, w[j].path) || GQNativeEqual(w[i].native, w[j].native, eq, ctx))
                return GQFail(error, GQ_INVENTORY, w[i].path);
        slash = strrchr(w[i].path, '/');
        colon = strrchr(w[i].native, ':');
        if (!!slash != !!colon)
            return GQFail(error, GQ_INVENTORY, w[i].path);
        if (!slash)
            continue;
        n = (size_t)(slash - w[i].path);
        pn = (size_t)(colon - w[i].native);
        for (j = 0; j < count; ++j)
            if (strlen(w[j].path) == n && !memcmp(w[j].path, w[i].path, n))
                break;
        if (j == count || w[j].file.present != 2 || strlen(w[j].native) != pn ||
            memcmp(w[j].native, w[i].native, pn))
            return GQFail(error, GQ_INVENTORY, w[i].path);
    }
    return 0;
}
static int GQOrder(const void *a, const void *b) {
    return strcmp(((const GQNode *)a)->path, ((const GQNode *)b)->path);
}
static int GQNodes(const GRSnapshot *h, const GRSnapshot *in, const GRSnapshot *t, const GQWork *w,
                   size_t wn, GQNode **out, size_t *count) {
    GQNode *nodes, *d, *s;
    const GRSnapshot *sets[3];
    size_t total = wn, i, j, n = 0, used = 0;
    sets[0] = h;
    sets[1] = in;
    sets[2] = t;
    for (i = 0; i < 3; ++i) {
        if (sets[i]->count > (size_t)-1 - total)
            return GB_SPACE;
        total += sets[i]->count;
    }
    if (total > (size_t)-1 / sizeof(*nodes))
        return GB_SPACE;
    nodes = (GQNode *)calloc(total ? total : 1, sizeof(*nodes));
    if (!nodes)
        return GB_MEMORY;
    for (i = 0; i < 3; ++i)
        for (j = 0; j < sets[i]->count; ++j) {
            d = nodes + n++;
            d->path = sets[i]->files[j].path;
            if (!i)
                d->h = sets[i]->files + j;
            else if (i == 1)
                d->i = sets[i]->files + j;
            else
                d->t = sets[i]->files + j;
        }
    for (i = 0; i < wn; ++i) {
        nodes[n].path = w[i].path;
        nodes[n++].w = w + i;
    }
    qsort(nodes, n, sizeof(*nodes), GQOrder);
    for (i = 0; i < n; ++i) {
        s = nodes + i;
        if (used && !strcmp(nodes[used - 1].path, s->path)) {
            d = nodes + used - 1;
            if (s->h)
                d->h = s->h;
            if (s->i)
                d->i = s->i;
            if (s->t)
                d->t = s->t;
            if (s->w)
                d->w = s->w;
        } else
            nodes[used++] = *s;
    }
    *out = nodes;
    *count = used;
    return 0;
}
static int GQSetGroup(GIIndex *index, const GRSnapshot *s, const GRFile *f) {
    const GIEntry *e;
    int result;
    if (!f)
        return 0;
    e = s->index.entries + f->entry;
    result = GISet(index, e->path, e->stat[6], e->oid, e->stat[9]);
    if (!result && f->hasFinderInfo) {
        e = s->index.entries + f->metadataEntry;
        result = GISet(index, e->path, e->stat[6], e->oid, e->stat[9]);
    }
    return result;
}
static int GQProtects(const GQProtection *p, const char *path) {
    size_t low = 0, high, middle;
    int order;
    if (!p) return 0;
    high = p->count;
    while (low < high) {
        middle = low + (high - low) / 2;
        order = strcmp(path, p->paths[middle]);
        if (!order) return 1;
        if (order < 0) high = middle;
        else low = middle + 1;
    }
    return 0;
}
static int GQSelect(GSRepository *r, const GRSnapshot *h, const GRSnapshot *in, const GRSnapshot *t,
                    const GPMap *previous,const GPMap *targetDefaults,GQNode *nodes, size_t count, const GQProtection *protection,const GQProtection *owned,
                    const GQProtection *discard,GIIndex *index, GQError *error) {
    GQNode *n;
    const GIEntry *hv, *iv, *tv, *version;
    GCFile absent;
    const GCFile *working;
    size_t j;
    int result, forks = 0;
    memset(&absent, 0, sizeof(absent));
    for (j = 0; j < count; ++j) {
        n = nodes + j;
        n->retain = n->w != NULL;
        result = GQIdentity(r, h, n->h, previous, &n->hf);
        if (!result)
            result = GQIdentity(r, in, n->i, previous, &n->inf);
        if (!result)
            result = GQIdentity(r, t, n->t, targetDefaults, &n->tf);
        if (result)
            return result;
        if (GQProtects(protection, n->path) ||
            (protection && protection->changed && !GQLogical(h, n->h, t, n->t))) {
            if (!GQLogical(h, n->h, in, n->i))
                return GQFail(error, GQ_STAGED, n->path);
            working = n->w && n->w->file.present == 1 ? &n->w->file : &absent;
            if (!GCFileEqual(working, &n->hf))
                return GQFail(error, n->h ? GQ_DIRTY : GQ_UNTRACKED, n->path);
        }
        if(discard) {
            if(!GQProtects(discard,n->path) && !GQLogical(h,n->h,in,n->i))
                return GQFail(error,GQ_STAGED,n->path);
            n->selected=n->t;n->source=t;
            if(GQProtects(discard,n->path)) {
                working=n->w && n->w->file.present==1?&n->w->file:&absent;
                n->change=!GCFileEqual(working,&n->tf);
                if(n->change && working->present)n->retain=0;
            }
        } else if (GQLogical(h, n->h, t, n->t)) {
            n->selected = n->i;
            n->source = in;
        } else {
            if (!GQLogical(in, n->i, h, n->h) && !GQLogical(in, n->i, t, n->t))
                return GQFail(error, GQ_STAGED, n->path);
            n->selected = n->t;
            n->source = t;
            if (!n->i && !n->t)
                continue;
            working = n->w && n->w->file.present == 1 ? &n->w->file : &absent;
            if (!n->h && !n->i && n->t && working->present &&
                !(GQProtects(owned,n->path) && GCFileEqual(working,&n->tf)))
                return GQFail(error, GQ_UNTRACKED, n->path);
            if (!GCFileEqual(working, &n->inf) && !GCFileEqual(working, &n->tf))
                return GQFail(error, GQ_DIRTY, n->path);
            n->change = !GCFileEqual(working, &n->tf);
            if (n->change && working->present)
                n->retain = 0;
        }
        result = GQSetGroup(index, n->source, n->selected);
        if (result)
            return result == GS_CONFLICT ? GQFail(error, GQ_STAGED, n->path) : result;
        if (n->selected && n->selected->hasFinderInfo)
            forks = 1;
    }
    hv = GIFind(&h->index, GI_MAC_NAMESPACE "/version", 0);
    iv = GIFind(&in->index, GI_MAC_NAMESPACE "/version", 0);
    tv = GIFind(&t->index, GI_MAC_NAMESPACE "/version", 0);
    if(discard)
        version=tv;
    else if (GQEntryEqual(tv, hv))
        version = iv;
    else if (GQEntryEqual(iv, hv) || GQEntryEqual(iv, tv))
        version = tv;
    else
        return GQFail(error, GQ_STAGED, GI_MAC_NAMESPACE "/version");
    if (forks && !version)
        version = iv ? iv : tv;
    if (version)
        return GISet(index, version->path, version->stat[6], version->oid, version->stat[9]);
    return forks ? GS_FORMAT : 0;
}
static int GQDirectories(GQNode *nodes,size_t count,GQError *error,const GQProtection *discard) {
    size_t i, j, k;
    GQNode *n;
    int tracked;
    for (i = 0; i < count; ++i) {
        n = nodes + i;
        if (!n->w || n->w->file.present != 2)
            continue;
        for (j = 0; j < count; ++j)
            if (nodes[j].change && nodes[j].t &&
                (!strcmp(nodes[j].path, n->path) || GQBelow(nodes[j].path, n->path)))
                break;
        if (j == count)
            continue;
        tracked = 0;
        for (k = 0; k < count; ++k)
            if ((nodes[k].h || nodes[k].i) && GQBelow(n->path, nodes[k].path))
                tracked = 1;
        /* Discard has explicit, durable original-directory witnesses. Each
           displaced untracked directory still needs review; all retained
           children below it must be rejected before emitting the plan. */
        if(discard && GQProtects(discard,n->path))tracked=1;
        if(!tracked && discard && GQProtects(discard,n->path))
            for(k=0;k<count;++k)
                if(nodes[k].change && nodes[k].w && nodes[k].w->file.present==1 &&
                    GQBelow(n->path,nodes[k].path))tracked=1;
        if (!tracked)
            return GQFail(error, GQ_DIRECTORY, n->path);
        n->retain = 0;
    }
    for (i = 0; i < count; ++i)
        if (nodes[i].w && nodes[i].w->file.present == 2 && !nodes[i].retain)
            for (j = 0; j < count; ++j)
                if (nodes[j].retain && nodes[j].w && GQBelow(nodes[i].path, nodes[j].path))
                    return GQFail(error, GQ_UNTRACKED, nodes[j].path);
    return 0;
}
static int GQRestoreAliases(GQNode *nodes,size_t count,const GPMap *desired,const GQProtection *owned) {
    size_t i,j;GQNode *n;const GPEntry *e;
    for(i=0;i<count;++i) {
        n=nodes+i;
        if(!n->t || !n->w || n->w->file.present!=1 || !GQProtects(owned,n->path))continue;
        e=GPFind(desired,n->path);if(!e)return GS_FORMAT;
        if(strcmp(n->w->native,e->native) || !GCFileEqual(&n->w->file,&n->tf)){n->change=1;n->retain=0;}
    }
    for(i=0;i<count;++i) {
        n=nodes+i;if(!n->w || n->w->file.present!=2)continue;
        e=GPFind(desired,n->path);
        if(!e || e->mode!=GP_DIRECTORY || !strcmp(e->native,n->w->native))continue;
        for(j=0;j<count;++j)if(nodes[j].change && nodes[j].t && GQProtects(owned,nodes[j].path) && GQBelow(n->path,nodes[j].path))break;
        if(j<count)n->retain=0;
    }
    return 0;
}
/* An inverse-session map supplies restored aliases for owned paths. Retained
   unrelated plain files keep their live synthetic baseline, including the
   legacy default, rather than silently becoming Finder-only modifications. */
static void GQRetainPlainDefaults(const GQNode *nodes,size_t count,const GPMap *previous,
                                 const GQProtection *protectedPaths,GPMap *mapping) {
    size_t i,j;const GPEntry *old;GPEntry *e;
    for(i=0;i<count;++i) {
        if(!nodes[i].retain || !nodes[i].w || nodes[i].w->file.present!=1 ||
           GQProtects(protectedPaths,nodes[i].path))continue;
        old=GPFind(previous,nodes[i].path);
        if(!old || old->flags || old->mode==GP_DIRECTORY || !GPPlainFinderInfo(old->finderInfo))continue;
        for(j=0;j<mapping->count;++j)if(!strcmp(mapping->entries[j].path,nodes[i].path)) {
            e=mapping->entries+j;
            if(!e->flags && e->mode!=GP_DIRECTORY)memcpy(e->finderInfo,old->finderInfo,32);
            break;
        }
    }
}
int GQCheckInventory(const GPMap *map,const GQWork *work,size_t count,GPEqual eq,void *ctx,int transitions) {
    if(!map || !eq || (count && !work) || (transitions!=0 && transitions!=1))return GB_BAD;
    return GQInventory(map,work,count,eq,ctx,NULL,transitions);
}
static int GQOperations(GQNode *nodes, size_t count, const GPMap *map, GCTransaction *tx,int discard) {
    size_t i;
    GCOperation *op;
    const GPEntry *e;
    GQNode *n;
    if (count > (size_t)-1 / sizeof(*op))
        return GB_SPACE;
    tx->files = (GCOperation *)calloc(count ? count : 1, sizeof(*op));
    if (!tx->files)
        return GB_MEMORY;
    if(discard) {
        if(count>(size_t)-1/sizeof(*tx->directories))return GB_SPACE;
        tx->directories=(char **)calloc(count?count:1,sizeof(*tx->directories));
        if(!tx->directories)return GB_MEMORY;
        for(i=0;i<count;++i)
            if(nodes[i].w && nodes[i].w->file.present==2 && !nodes[i].retain) {
                char *path=GQString(nodes[i].w->native);
                if(!path)return GB_MEMORY;
                tx->directories[tx->directoryCount++]=path;
            }
    }
    for (i = 0; i < count; ++i) {
        n = nodes + i;
        if (!n->change)
            continue;
        op = tx->files + tx->fileCount++;
        if (n->w && n->w->file.present == 1) {
            op->oldPath = GQString(n->w->native);
            op->oldFile = n->w->file;
            if (!op->oldPath)
                return GB_MEMORY;
        }
        if (n->t) {
            e = GPFind(map, n->path);
            if (!e)
                return GS_FORMAT;
            op->newPath = GQString(e->native);
            op->newFile = n->tf;
            op->mode = n->t->mode;
            if (!op->newPath)
                return GB_MEMORY;
            if (n->t->hasFinderInfo)
                memcpy(op->metadataOID, e->metadataOID, 20);
        }
    }
    return 0;
}
static int GQMeta(GCTransaction *t, const char *key, const void *before, size_t bn, int bp,
                  const void *after, size_t an, int ap) {
    GCMetadata *m;
    size_t i;
    for (i = 0; i < t->metadataCount; ++i)
        if (!strcmp(t->metadata[i].path, key))
            return GS_CONFLICT;
    if (t->metadataCount >= (size_t)-1 / sizeof(*m))
        return GB_SPACE;
    m = (GCMetadata *)realloc(t->metadata, (t->metadataCount + 1) * sizeof(*m));
    if (!m)
        return GB_MEMORY;
    t->metadata = m;
    m += t->metadataCount++;
    memset(m, 0, sizeof(*m));
    m->path = GQString(key);
    m->beforePresent = bp;
    m->afterPresent = ap;
    m->beforeLength = bn;
    m->afterLength = an;
    if (bp)
        m->before = (unsigned char *)GQCopy(before, bn);
    if (ap)
        m->after = (unsigned char *)GQCopy(after, an);
    return !m->path || (bp && !m->before) || (ap && !m->after) ? GB_MEMORY : 0;
}
static int GQRef(GSRepository *r, GCTransaction *t, const char *branch, unsigned char oid[20],
                 int *present) {
    unsigned char *bytes = NULL;
    char key[64], hex[41];
    size_t n = 0, len = strlen(branch);
    int result, found;
    result = GSReadRef(r, branch, oid);
    *present = result != GS_NOT_FOUND;
    if (result && result != GS_NOT_FOUND)
        return result;
    result = GSRefKey(branch, key);
    if (result)
        return result;
    result = r->read(r->context, key, &bytes, &n);
    found = result != GS_NOT_FOUND;
    if (result && result != GS_NOT_FOUND)
        return result;
    result = 0;
    if (found != *present)
        result = GS_CONFLICT;
    if (!result && found) {
        GBOIDFormat(oid, hex);
        if (n != len + 42 || memcmp(bytes, branch, len + 1) || memcmp(bytes + len + 1, hex, 40) ||
            bytes[n - 1] != '\n')
            result = GS_CONFLICT;
    }
    if (!result)
        result = GQMeta(t, key, bytes, n, found, bytes, n, found);
    free(bytes);
    return result;
}
static int GQSetRef(GCTransaction *t, const char *branch, const unsigned char tip[20]) {
    char key[64], hex[41];
    unsigned char *bytes;
    size_t i, n = strlen(branch);
    int result = GSRefKey(branch, key);
    if (result) return result;
    if (n > (size_t)-1 - 42) return GB_SPACE;
    for (i = 0; i < t->metadataCount; ++i)
        if (!strcmp(t->metadata[i].path, key)) break;
    if (i == t->metadataCount) return GS_FORMAT;
    bytes = (unsigned char *)malloc(n + 42);
    if (!bytes) return GB_MEMORY;
    GBOIDFormat(tip, hex);
    memcpy(bytes, branch, n + 1);
    memcpy(bytes + n + 1, hex, 40);
    bytes[n + 41] = '\n';
    free(t->metadata[i].after);
    t->metadata[i].after = bytes;
    t->metadata[i].afterLength = n + 42;
    t->metadata[i].afterPresent = 1;
    return 0;
}
static int GQPlanTo(GSRepository *r, const char *branch, const unsigned char *expectedTip,
                    const unsigned char *targetTip, const GQWork *work, size_t wn, GPEqual eq,
                    void *ctx, const GQProtection *protection,const GQProtection *owned,const GPMap *restore,
                    const GQProtection *discard,GQPlan *out, GQError *error) {
    GQPlan next;
    GRSnapshot h, in, t, selected;
    GIIndex saved;
    GPMap previous,desired;
    GQNode *nodes = NULL;
    GPReservation *reservations = NULL;
    unsigned char tip[20], source[20], check[20], tree[20], *head = NULL, *after = NULL,
                                                            *bytes = NULL;
    char *current = NULL;
    size_t hn = 0, an = 0, bn = 0, count = 0, rn = 0, i, len;
    int result, haveSource, found,side;const GQProtection *policy;
    if (!r || !r->read || !r->replace || !GSValidRef(branch) || !eq || !out || (wn && !work))
        return GB_BAD;
    if (error)
        memset(error, 0, sizeof(*error));
    for(side=0;side<3;++side) {
        policy=side==2?discard:side?owned:protection;if(!policy)continue;
        if ((policy->count && !policy->paths) ||
            (policy->changed != 0 && policy->changed != 1) || (side && policy->changed)) return GB_BAD;
        for (i = 0; i < policy->count; ++i)
            if (!GIValidPath(policy->paths[i]) ||
                (!strncmp(policy->paths[i], GI_MAC_NAMESPACE,
                         sizeof(GI_MAC_NAMESPACE) - 1) &&
                 (!policy->paths[i][sizeof(GI_MAC_NAMESPACE) - 1] ||
                  policy->paths[i][sizeof(GI_MAC_NAMESPACE) - 1] == '/')) ||
                (i && strcmp(policy->paths[i - 1], policy->paths[i]) >= 0))
                return GB_BAD;
    }
    GQInit(&next);
    GRInit(&h);
    GRInit(&in);
    GRInit(&t);
    GRInit(&selected);
    GIInit(&saved);
    GPInit(&previous);
    GPInit(&desired);
    result = GCWriteAllowed(r);
    if (result)
        goto done;
    result = GSHead(r, &current, source);
    haveSource = !result;
    if (result && result != GS_NOT_FOUND)
        goto done;
    result = r->read(r->context, "HEAD", &head, &hn);
    if (result)
        goto done;
    len = strlen(current);
    if (hn != len + 6 || memcmp(head, "ref: ", 5) || memcmp(head + 5, current, len) ||
        head[hn - 1] != '\n') {
        result = GS_CONFLICT;
        goto done;
    }
    if(discard && (strcmp(current,branch) || haveSource!=(expectedTip!=NULL) ||
        (haveSource && memcmp(source,expectedTip,20)))) {
        result=GS_CONFLICT;goto done;
    }
    len = strlen(branch);
    if (len > (size_t)-1 - 6) {
        result = GB_SPACE;
        goto done;
    }
    an = len + 6;
    after = (unsigned char *)malloc(an);
    if (!after) {
        result = GB_MEMORY;
        goto done;
    }
    memcpy(after, "ref: ", 5);
    memcpy(after + 5, branch, len);
    after[an - 1] = '\n';
    result = GQMeta(&next.transaction, "HEAD", head, hn, 1, after, an, 1);
    if (result)
        goto done;
    result = GQRef(r, &next.transaction, current, check, &found);
    if (!result && (found != haveSource || (found && memcmp(source, check, 20))))
        result = GS_CONFLICT;
    if (result)
        goto done;
    if (!strcmp(current, branch)) {
        found = haveSource;
        if (found) memcpy(tip, source, 20);
    } else {
        result = GQRef(r, &next.transaction, branch, tip, &found);
        if (result)
            goto done;
    }
    if (targetTip) {
        if (found != (expectedTip != NULL) || (found && memcmp(tip, expectedTip, 20))) {
            result = GS_CONFLICT;
            goto done;
        }
        memcpy(tip, targetTip, 20);
        result = GQSetRef(&next.transaction, branch, tip);
        if (result) goto done;
    } else if (!found && !discard) {
        result = GS_NOT_FOUND;
        goto done;
    }
    if (haveSource) {
        result = GRFromCommit(r, source, &h);
        if (result)
            goto done;
    }
    result = found || targetTip ? GRFromCommit(r, tip, &t):0;
    if (result)
        goto done;
    result = GILoad(r, &saved);
    if (result)
        goto done;
    for (i = 0; i < saved.count; ++i) {
        if (saved.entries[i].flags & 0x3000U) {
            result = GI_UNMERGED;
            goto done;
        }
        if ((saved.entries[i].flags & 0xf000U) || saved.entries[i].extended) {
            result = GI_UNSUPPORTED;
            goto done;
        }
    }
    result = GIWriteTree(r, &saved, tree);
    if (!result)
        result = GRFromTree(r, tree, &in);
    if (!result)
        result = GPLoad(r, eq, ctx, &previous);
    if (!result)
        result = GQInventory(&previous,work,wn,eq,ctx,error,discard!=NULL);
    if (!result)
        result = GQNodes(&h, &in, &t, work, wn, &nodes, &count);
    if (!result)
        result = GQSelect(r, &h, &in, &t, &previous, restore?restore:&previous, nodes, count, protection,owned,discard,&next.index,error);
    if(!result && !restore)result=GQDirectories(nodes,count,error,discard);
    if (!result)
        result = GIWriteTree(r, &next.index, tree);
    if (!result)
        result = GRFromTree(r, tree, &selected);
    if(!result && restore)result=GPBuild(&selected,restore,eq,ctx,&desired);
    if(!result && restore)result=GQRestoreAliases(nodes,count,&desired,protection);
    if(!result && restore)result=GQDirectories(nodes,count,error,discard);
    if (result)
        goto done;
    if (wn > (size_t)-1 / sizeof(*reservations)) {
        result = GB_SPACE;
        goto done;
    }
    reservations = (GPReservation *)calloc(wn ? wn : 1, sizeof(*reservations));
    if (!reservations) {
        result = GB_MEMORY;
        goto done;
    }
    for (i = 0; i < count; ++i)
        if (nodes[i].retain && nodes[i].w) {
            reservations[rn].path = nodes[i].w->path;
            reservations[rn].native = nodes[i].w->native;
            reservations[rn++].directory = nodes[i].w->file.present == 2;
        }
    result = GPBuildProtected(&selected, restore?restore:&previous, reservations, rn, eq, ctx, &next.mapping);
    if (!result && restore) GQRetainPlainDefaults(nodes,count,&previous,protection,&next.mapping);
    if (!result)
        result = GQOperations(nodes, count, &next.mapping, &next.transaction,discard!=NULL);
    if (!result)
        result = GIEncode(&next.index, &bytes, &bn);
    if (!result)
        result = GQMeta(&next.transaction, "index", saved.original, saved.originalLength,
                        saved.original != NULL, bytes, bn, 1);
    free(bytes);
    bytes = NULL;
    if (!result)
        result = GPEncode(&next.mapping, eq, ctx, &bytes, &bn);
    if (!result)
        result = GQMeta(&next.transaction, "ghclient-map", previous.original,
                        previous.originalLength, previous.original != NULL, bytes, bn, 1);
    free(bytes);
    bytes = NULL;
    if (result)
        goto done;
    if (saved.original) {
        next.index.original = (unsigned char *)GQCopy(saved.original, saved.originalLength);
        if (!next.index.original) {
            result = GB_MEMORY;
            goto done;
        }
        next.index.originalLength = saved.originalLength;
    }
    next.transaction.generation = 1;
    next.transaction.phase = GC_PREPARE;
    result = GCEncode(&next.transaction, eq, ctx, &bytes, &bn);
    if (!result) {
        GQFree(out);
        *out = next;
        GQInit(&next);
    }
done:
    free(bytes);
    free(head);
    free(after);
    free(current);
    free(nodes);
    free(reservations);
    GQFree(&next);
    GRFree(&h);
    GRFree(&in);
    GRFree(&t);
    GRFree(&selected);
    GIFree(&saved);
    GPFree(&previous);
    GPFree(&desired);
    return result;
}
int GQToBranch(GSRepository *r, const char *branch, const GQWork *work, size_t wn, GPEqual eq,
               void *ctx, GQPlan *out, GQError *error) {
    return GQPlanTo(r, branch, NULL, NULL, work, wn, eq, ctx, NULL,NULL,NULL,NULL,out,error);
}
int GQToCommit(GSRepository *r, const char *branch, const unsigned char *expectedTip,
               const unsigned char targetTip[20], const GQWork *work, size_t wn, GPEqual eq,
               void *ctx, GQPlan *out, GQError *error) {
    if (!targetTip) return GB_BAD;
    return GQPlanTo(r, branch, expectedTip, targetTip, work, wn, eq, ctx, NULL,NULL,NULL,NULL,out,error);
}
int GQToCommitProtected(GSRepository *r, const char *branch, const unsigned char *expectedTip,
               const unsigned char targetTip[20], const GQWork *work, size_t wn,
               const GQProtection *protection, GPEqual eq, void *ctx, GQPlan *out, GQError *error) {
    if (!targetTip || !protection) return GB_BAD;
    return GQPlanTo(r, branch, expectedTip, targetTip, work, wn, eq, ctx, protection,NULL,NULL,NULL,out,error);
}
int GQToCommitOwned(GSRepository *r,const char *branch,const unsigned char *expected,const unsigned char target[20],
    const GQWork *work,size_t count,const GQProtection *strict,const GQProtection *owned,GPEqual eq,void *ctx,GQPlan *out,GQError *why) {
    if(!target || !strict || !owned)return GB_BAD;
    return GQPlanTo(r,branch,expected,target,work,count,eq,ctx,strict,owned,NULL,NULL,out,why);
}
int GQToCommitRestored(GSRepository *r,const char *branch,const unsigned char *expected,const unsigned char target[20],
    const GQWork *work,size_t count,const GQProtection *strict,const GPMap *restore,GPEqual eq,void *ctx,GQPlan *out,GQError *why) {
    if(!target || !strict || !restore)return GB_BAD;
    return GQPlanTo(r,branch,expected,target,work,count,eq,ctx,strict,NULL,restore,NULL,out,why);
}
int GQDiscard(GSRepository *r,const char *branch,const unsigned char *expected,const GQWork *work,
    size_t count,const GQProtection *paths,GPEqual eq,void *ctx,GQPlan *out,GQError *why) {
    if(!paths || paths->changed)return GB_BAD;
    return GQPlanTo(r,branch,expected,NULL,work,count,eq,ctx,NULL,NULL,NULL,paths,out,why);
}
