/* Finder integration for System 7: dropped repository folders and normal Quit. */
static AEEventHandlerUPP gAppleEventHandler;
static AEDesc gOpenDocument;
static int gOpenPending,gOpeningDocument;
static void NativeClearPendingOpen(void) {
    if(gOpenPending)AEDisposeDesc(&gOpenDocument);
    memset(&gOpenDocument,0,sizeof(gOpenDocument));gOpenPending=0;
}
static OSErr NativeOpenError(const char *step, OSErr error) {
    char text[256];
    snprintf(text, sizeof(text), "Open Repository: %s failed (Mac OS error %d). Use File > Add Local Repository.", step, (int)error);
    SetStatus(text);
    return error;
}
static pascal OSErr NativeAppleEvent(const AppleEvent *event, AppleEvent *reply, long action) {
    AEDescList list;
    AEDesc document;
    AEKeyword keyword;
    long count = 0;
    OSErr error;
    (void)reply;
    if (action == 2) {
        gCancel = gDone = 1;
        NativeClearPendingOpen();
        return noErr;
    }
    if (action == 0) {
        if(gDeviceDialog)SelectWindow((WindowPtr)gDeviceDialog);
        else if(!gModalDepth)ShowWorkspace();
        return noErr;
    }
    if (gDone || gBusy || gModalDepth || gDeviceDialog || gOpenPending || gOpeningDocument)
        return errAEEventNotHandled;
    memset(&list, 0, sizeof(list));
    memset(&document, 0, sizeof(document));
    error = AEGetParamDesc(event, keyDirectObject, typeAEList, &list);
    if (error) {
        AEDisposeDesc(&list);
        return NativeOpenError("reading the document list", error);
    }
    if (!error)
        error = AECountItems(&list, &count);
    if (!error && count != 1) {
        SetStatus("Open one repository folder at a time. Use File > Add Local Repository.");
        error = paramErr;
    }
    if (!error)
        error = AEGetNthDesc(&list, 1, typeWildCard, &keyword, &document);
    AEDisposeDesc(&list);
    if (error) {
        AEDisposeDesc(&document);
        return NativeOpenError("reading the selected folder", error);
    }
    if (!document.dataHandle || (document.descriptorType != typeAlias &&
        (document.descriptorType != typeFSS || GetHandleSize(document.dataHandle) != sizeof(FSSpec))))
        error = errAEWrongDataType;
    if(error){AEDisposeDesc(&document);return NativeOpenError("reading the folder descriptor",error);}
    /* AEGetNthDesc gives us an owned copy. Return the sender's reply before
       alias resolution, disk access or a repository recovery/merge dialog.
       noErr means accepted for opening, not that the repository is valid. */
    gOpenDocument=document;gOpenPending=1;
    return noErr;
}
static void NativeOpenDocument(const AEDesc *document) {
    FSSpec folder;CInfoPBRec pb;Boolean changed;OSErr error;
    if(document->descriptorType==typeAlias)
        error=ResolveAlias(NULL,(AliasHandle)document->dataHandle,&folder,&changed);
    else {
        BlockMoveData(*document->dataHandle,&folder,sizeof(folder));error=noErr;
    }
    if(gDone)return;
    if (error)
        {NativeOpenError("resolving the folder alias", error);return;}
    if (!folder.name[0]) {
        error = FolderAt(folder.vRefNum, folder.parID, &folder);
        if (error)
            {NativeOpenError("finding the folder", error);return;}
    }
    memset(&pb, 0, sizeof(pb));
    pb.dirInfo.ioVRefNum = folder.vRefNum;
    pb.dirInfo.ioDrDirID = folder.parID;
    pb.dirInfo.ioNamePtr = folder.name;
    error = PBGetCatInfoSync(&pb);
    if(gDone)return;
    if (error)
        {NativeOpenError("reading the folder information", error);return;}
    if (!(pb.dirInfo.ioFlAttrib & 16)) {
        Message("Open Repository", "Drop a repository folder on GitHub Classic to open it.");
        return;
    }
    ShowWorkspace();LocalOpenSpec(&folder, 0);
}
static void NativeDispatchPendingOpen(void) {
    AEDesc document;
    if(gDone){NativeClearPendingOpen();return;}
    if(!gOpenPending || gOpeningDocument || gBusy || gModalDepth || gDeviceDialog)return;
    document=gOpenDocument;memset(&gOpenDocument,0,sizeof(gOpenDocument));gOpenPending=0;
    gOpeningDocument=1;NativeOpenDocument(&document);AEDisposeDesc(&document);gOpeningDocument=0;
}
static void InstallNativeEvents(void) {
    OSErr error;
    gAppleEventHandler = NewAEEventHandlerProc(NativeAppleEvent);
    if (!gAppleEventHandler) {
        SetStatus("Finder integration could not be initialized.");
        return;
    }
    error =
        AEInstallEventHandler(kCoreEventClass, kAEOpenApplication, gAppleEventHandler, 0, false);
    if (!error)
        error =
            AEInstallEventHandler(kCoreEventClass, kAEOpenDocuments, gAppleEventHandler, 1, false);
    if (!error)
        error = AEInstallEventHandler(kCoreEventClass, kAEQuitApplication, gAppleEventHandler, 2,
                                      false);
    if (!error)
        error=AEInstallEventHandler(kCoreEventClass,'rapp',gAppleEventHandler,0,false);
    if (error)
        SetStatus("Finder integration is unavailable; use the File menu to open and quit.");
}
static void RemoveNativeEvents(void) {
    NativeClearPendingOpen();
    if (!gAppleEventHandler)
        return;
    AERemoveEventHandler(kCoreEventClass, 'rapp', gAppleEventHandler, false);
    AERemoveEventHandler(kCoreEventClass, kAEOpenApplication, gAppleEventHandler, false);
    AERemoveEventHandler(kCoreEventClass, kAEOpenDocuments, gAppleEventHandler, false);
    AERemoveEventHandler(kCoreEventClass, kAEQuitApplication, gAppleEventHandler, false);
    DisposeRoutineDescriptor((UniversalProcPtr)gAppleEventHandler);
}
