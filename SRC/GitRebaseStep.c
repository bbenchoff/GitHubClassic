#include "GitRebaseStep.h"
#include "GitHistory.h"
#include <stdlib.h>
#include <string.h>

void RSInit(RSStep *step){memset(step,0,sizeof(*step));}
void RSFree(RSStep *step){free(step->original);TMFree(&step->merge);TMDraftFree(&step->draft);RSInit(step);}
static int RSCommit(GSRepository *source,const unsigned char id[20],GHCommitInfo *info,unsigned char **raw,size_t *n) {
    char type[7];int result=GSGetObject(source,id,type,raw,n);
    if(!result)result=strcmp(type,"commit")?GS_FORMAT:GHCommitParse(*raw,*n,info);return result;
}
static int RSSameIndex(const GIIndex *a,const GIIndex *b,GDProgress progress,void *context,int *same) {
    size_t i;int result;const GIEntry *left,*right;*same=0;
    if(a->count!=b->count)return 0;
    for(i=0;i<a->count;++i) {
        if(progress && (result=progress(context))!=0)return result;left=a->entries+i;right=b->entries+i;
        if(strcmp(left->path,right->path) || left->stat[6]!=right->stat[6] || memcmp(left->oid,right->oid,20) ||
           ((left->flags|right->flags)&0x3000))return 0;
    }
    *same=1;return 0;
}
int RSPrepare(GSRepository *source,const unsigned char candidate[20],const unsigned char onto[20],char newline,
    const TMLimits *limits,GDProgress progress,void *context,RSStep *destination) {
    GOReader state;GSRepository reader;RSStep *next;GHCommitInfo info;unsigned char *raw=NULL;size_t n=0;
    int result,same=0;
    if(!source || !source->read || !candidate || !onto || !limits || !destination || (newline!='\n' && newline!='\r'))return GB_BAD;
    result=GOReadStart(source,&limits->read,progress,context,&state,&reader);if(result)return result;
    next=(RSStep *)calloc(1,sizeof(*next));if(!next)return GB_MEMORY;
    memcpy(next->candidate,candidate,20);memcpy(next->onto,onto,20);
    result=RSCommit(&reader,candidate,&info,&next->original,&next->originalLength);
    if(!result && info.parents!=1)result=GB_BAD;
    if(!result){memcpy(next->trees[2],info.tree,20);memcpy(next->parent,info.parent,20);result=RSCommit(&reader,next->parent,&info,&raw,&n);}
    if(!result)memcpy(next->trees[0],info.tree,20);free(raw);raw=NULL;
    if(!result)result=RSCommit(&reader,onto,&info,&raw,&n);
    if(!result)memcpy(next->trees[1],info.tree,20);free(raw);raw=NULL;
    if(!result)result=TMFromTrees(&reader,next->trees[0],next->trees[1],next->trees[2],newline,limits,progress,context,&next->merge);
    if(!result) {
        if(next->merge.conflicts)next->kind=RS_CONFLICT;
        else if(!memcmp(next->trees[0],next->trees[2],20))next->kind=RS_KEEP_EMPTY;
        else {
            result=TMBuildIndex(&reader,&next->merge,progress,context,&next->draft);
            if(!result)result=RSSameIndex(&next->draft.index,&next->merge.snapshots[1].index,progress,context,&same);
            if(!result)next->kind=same?RS_DROP_EMPTY:RS_APPLY;
        }
    }
    if(!result && progress)result=progress(context);
    if(!result) {
        next->encodedReadBytes=state.bytes;next->expandedReadBytes=state.expanded;next->readCount=state.reads;
        RSFree(destination);*destination=*next;RSInit(next);
    }
    RSFree(next);free(next);return result;
}
