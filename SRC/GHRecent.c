#include "GHRecent.h"
#include <string.h>
static GBWord RecentWord(const unsigned char *p) {return ((GBWord)p[0]<<24)|((GBWord)p[1]<<16)|((GBWord)p[2]<<8)|p[3];}
static void RecentPut(unsigned char *p,GBWord n) {p[0]=(unsigned char)(n>>24);p[1]=(unsigned char)(n>>16);p[2]=(unsigned char)(n>>8);p[3]=(unsigned char)n;}
static int RecentName(const unsigned char *p) {
    size_t i;if(!p[0] || p[0]>31)return 0;
    for(i=1;i<=p[0];++i)if(!p[i] || p[i]==':')return 0;
    for(;i<32;++i)if(p[i])return 0;
    return 1;
}
static int RecentValid(const RecentEntry *e) {return RecentName(e->volume) && RecentName(e->name) && e->directory>=2 && e->signature<=65535;}
int RecentSame(const RecentEntry *a,const RecentEntry *b) {
    return a->volumeCreated==b->volumeCreated && a->signature==b->signature &&
        a->directory==b->directory && a->created==b->created && !memcmp(a->volume,b->volume,32);
}
int RecentRemove(RecentList *list,size_t at) {
    if(!list || list->count>RECENT_MAX || at>=list->count)return GB_BAD;
    memmove(list->entries+at,list->entries+at+1,(list->count-at-1)*sizeof(RecentEntry));
    memset(list->entries+--list->count,0,sizeof(RecentEntry));return 0;
}
int RecentTouch(RecentList *list,const RecentEntry *entry) {
    size_t i;RecentEntry copy;
    if(!list || !entry || list->count>RECENT_MAX || !RecentValid(entry))return GB_BAD;
    copy=*entry;for(i=0;i<list->count;++i)if(RecentSame(list->entries+i,&copy)){RecentRemove(list,i);break;}
    if(list->count==RECENT_MAX)RecentRemove(list,RECENT_MAX-1);
    memmove(list->entries+1,list->entries,list->count*sizeof(RecentEntry));list->entries[0]=copy;++list->count;return 0;
}
int RecentEncode(const RecentList *list,unsigned char out[RECENT_BYTES],size_t *length) {
    size_t i,j;unsigned char *p;
    if(!list || !out || !length || list->count>RECENT_MAX)return GB_BAD;
    memset(out,0,RECENT_BYTES);memcpy(out,"GHREC001",8);RecentPut(out+8,(GBWord)list->count);
    for(i=0;i<list->count;++i) {
        const RecentEntry *e=list->entries+i;if(!RecentValid(e))return GB_BAD;
        for(j=0;j<i;++j)if(RecentSame(e,list->entries+j))return GB_BAD;
        p=out+16+i*80;memcpy(p,e->volume,32);memcpy(p+32,e->name,32);
        RecentPut(p+64,e->volumeCreated);RecentPut(p+68,e->signature);RecentPut(p+72,e->directory);RecentPut(p+76,e->created);
    }
    *length=16+80*list->count;RecentPut(out+12,GBAdler32(out+16,*length-16));return 0;
}
int RecentDecode(RecentList *out,const void *data,size_t length) {
    const unsigned char *bytes=(const unsigned char *)data,*p;RecentList list;size_t i,j;
    if(!out || !bytes || length<16 || length>RECENT_BYTES || memcmp(bytes,"GHREC001",8))return GB_BAD;
    memset(&list,0,sizeof(list));list.count=(size_t)RecentWord(bytes+8);
    if(list.count>RECENT_MAX || length!=16+80*list.count || RecentWord(bytes+12)!=GBAdler32(bytes+16,length-16))return GB_BAD;
    for(i=0;i<list.count;++i) {
        RecentEntry *e=list.entries+i;p=bytes+16+i*80;memcpy(e->volume,p,32);memcpy(e->name,p+32,32);
        e->volumeCreated=RecentWord(p+64);e->signature=RecentWord(p+68);e->directory=RecentWord(p+72);e->created=RecentWord(p+76);
        if(!RecentValid(e))return GB_BAD;for(j=0;j<i;++j)if(RecentSame(e,list.entries+j))return GB_BAD;
    }
    *out=list;return 0;
}
