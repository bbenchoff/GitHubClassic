/* Private value/plan helpers derived from the tested merge workspace.
   No session ownership is shared. Callers initialize/free scratch outputs. */
#ifndef GH_WORKSPACE_PLAN_SUPPORT_H
#define GH_WORKSPACE_PLAN_SUPPORT_H
#include "GitMergeSession.h"
#include <stdlib.h>
#include <string.h>
typedef struct {char **paths;size_t count;} WXKeys;
static void *WXCopy(const void *p,size_t n) {
    void *out=malloc(n?n:1);if(out && n)memcpy(out,p,n);return out;
}
static char *WXString(const char *p) { return (char *)WXCopy(p,strlen(p)+1); }
static int WXPathAdd(WXKeys *s,const MSLimits *limits,const char *path) {
    char **items,*copy;size_t low=0,high=s->count,middle,n;int order;
    if(!GIValidPath(path))return GB_BAD;
    n=strlen(path);if(n>limits->pathBytes)return GB_SPACE;
    while(low<high){middle=low+(high-low)/2;order=strcmp(path,s->paths[middle]);
        if(!order)return 0;
        if(order<0)high=middle;else low=middle+1;}
    if(s->count>=limits->paths || s->count>=(size_t)-1/sizeof(*items))return GB_SPACE;
    copy=WXString(path);if(!copy)return GB_MEMORY;
    items=(char **)realloc(s->paths,(s->count+1)*sizeof(*items));
    if(!items){free(copy);return GB_MEMORY;}s->paths=items;
    memmove(items+low+1,items+low,(s->count-low)*sizeof(*items));items[low]=copy;++s->count;return 0;
}
static int WXEntrySame(const GIEntry *a,const GIEntry *b) {
    return (!a && !b) || (a && b && a->stat[6]==b->stat[6] &&
        (a->flags & 0xf000U)==(b->flags & 0xf000U) && a->extended==b->extended && !memcmp(a->oid,b->oid,20));
}
static int WXFileSame(const GRSnapshot *a,const GRFile *af,const GRSnapshot *b,const GRFile *bf) {
    if(!af || !bf)return !af && !bf;
    return WXEntrySame(a->index.entries+af->entry,b->index.entries+bf->entry) &&
        af->hasFinderInfo==bf->hasFinderInfo && (!af->hasFinderInfo ||
        WXEntrySame(a->index.entries+af->metadataEntry,b->index.entries+bf->metadataEntry));
}
static int WXStringOrder(const void *a,const void *b) { return strcmp(*(const char *const *)a,*(const char *const *)b); }
static void WXKeysFree(WXKeys *k) { size_t i;for(i=0;i<k->count;++i)free(k->paths[i]);free(k->paths);memset(k,0,sizeof(*k)); }
static int WXKeysMake(const char *const *paths,size_t count,WXKeys *k) {
    char key[96];size_t i;int result;
    if(count>(size_t)-1/2/sizeof(*k->paths))return GB_SPACE;
    k->paths=(char **)calloc(count?count*2:1,sizeof(*k->paths));if(!k->paths)return GB_MEMORY;
    for(i=0;i<count;++i) {
        k->paths[k->count]=WXString(paths[i]);if(!k->paths[k->count])return GB_MEMORY;++k->count;
        result=GIMacMetadataPath(paths[i],key);if(result)return result;
        k->paths[k->count]=WXString(key);if(!k->paths[k->count])return GB_MEMORY;++k->count;
    }
    qsort(k->paths,k->count,sizeof(*k->paths),WXStringOrder);return 0;
}
static int WXOwns(const WXKeys *k,const char *path) {
    size_t low=0,high=k->count,middle;int order;
    while(low<high){middle=low+(high-low)/2;order=strcmp(path,k->paths[middle]);
        if(!order)return 1;
        if(order<0)high=middle;else low=middle+1;}return 0;
}
static int WXIndexOrder(const void *a,const void *b) {
    const GIEntry *x=a,*y=b;int order=strcmp(x->path,y->path);
    return order?order:(int)((x->flags>>12)&3)-(int)((y->flags>>12)&3);
}
static int WXIndexSame(const GIIndex *a,const GIIndex *b) {
    size_t i;if(a->count!=b->count)return 0;
    for(i=0;i<a->count;++i)if(strcmp(a->entries[i].path,b->entries[i].path) || !WXEntrySame(a->entries+i,b->entries+i))return 0;
    return 1;
}
static int WXCompose(const GIIndex *head,const GIIndex *original,const GIIndex *target,const WXKeys *keys,GIIndex *out) {
    GIIndex next;const GIIndex *s;const GIEntry *e,*h,*i,*t,*version;size_t n,side,count=0;int result=0,forks=0;
    GIInit(&next);h=GIFind(head,GI_MAC_NAMESPACE "/version",0);i=GIFind(original,GI_MAC_NAMESPACE "/version",0);t=GIFind(target,GI_MAC_NAMESPACE "/version",0);
    if(WXEntrySame(t,h))version=i;else if(WXEntrySame(i,h) || WXEntrySame(i,t))version=t;else return GS_CONFLICT;
    for(side=0;side<2;++side) {
        s=side?target:original;
        for(n=0;n<s->count;++n) {
            e=s->entries+n;if(!strcmp(e->path,GI_MAC_NAMESPACE "/version"))continue;
            if(WXOwns(keys,e->path)!=(int)side)continue;
            if(++count>65535UL)return GB_SPACE;
            if(!strncmp(e->path,GI_MAC_NAMESPACE "/forks/",sizeof(GI_MAC_NAMESPACE "/forks/")-1))forks=1;
        }
    }
    if(forks && !version)version=i?i:t;
    if(forks && !version)return GS_FORMAT;
    if(version)++count;
    next.entries=(GIEntry *)calloc(count?count:1,sizeof(*next.entries));if(!next.entries)return GB_MEMORY;
    for(side=0;side<3 && !result;++side) {
        s=side?target:original;
        for(n=0;n<(side==2?(version?1:0):s->count);++n) {
            e=side==2?version:s->entries+n;
            if(side!=2 && (!strcmp(e->path,GI_MAC_NAMESPACE "/version") || WXOwns(keys,e->path)!=(int)side))continue;
            next.entries[next.count]=*e;next.entries[next.count].path=WXString(e->path);
            if(!next.entries[next.count].path){result=GB_MEMORY;break;}++next.count;
        }
    }
    if(!result){qsort(next.entries,next.count,sizeof(*next.entries),WXIndexOrder);GIFree(out);*out=next;GIInit(&next);}
    GIFree(&next);return result;
}
static int WXBytesSet(MSBytes *out,const void *p,size_t n,int present) {
    unsigned char *bytes=NULL;if(present){bytes=WXCopy(p,n);if(!bytes)return GB_MEMORY;}
    free(out->bytes);out->bytes=bytes;out->length=n;out->present=present;return 0;
}
static int WXMetaSet(GCTransaction *tx,const char *key,const void *before,size_t bn,int bp,const void *after,size_t an,int ap) {
    GCMetadata *m,*items;char *path;unsigned char *a=NULL,*b=NULL;size_t i;
    path=WXString(key);if(!path)return GB_MEMORY;
    if(bp)a=WXCopy(before,bn);
    if(ap)b=WXCopy(after,an);
    if((bp && !a) || (ap && !b)){free(path);free(a);free(b);return GB_MEMORY;}
    for(i=0;i<tx->metadataCount;++i)if(!strcmp(tx->metadata[i].path,key))break;
    if(i==tx->metadataCount) {
        if(i>=(size_t)-1/sizeof(*m)){free(path);free(a);free(b);return GB_SPACE;}
        items=(GCMetadata *)realloc(tx->metadata,(i+1)*sizeof(*m));
        if(!items){free(path);free(a);free(b);return GB_MEMORY;}tx->metadata=items;m=items+i;memset(m,0,sizeof(*m));++tx->metadataCount;
    }
    m=tx->metadata+i;free(m->path);free(m->before);free(m->after);
    m->path=path;m->before=a;m->beforeLength=bn;m->beforePresent=bp;m->after=b;m->afterLength=an;m->afterPresent=ap;return 0;
}
static const GCMetadata *WXMeta(const GCTransaction *t,const char *key) {
    size_t i;for(i=0;i<t->metadataCount;++i)if(!strcmp(t->metadata[i].path,key))return t->metadata+i;return NULL;
}
static int WXReadOnly(void *ctx,const char *key,const void *a,size_t an,const void *b,size_t bn) {
    (void)ctx;(void)key;(void)a;(void)an;(void)b;(void)bn;return GS_CONFLICT;
}
static int WXMatch(GSRepository *r,const char *key,const MSBytes *expected) {
    unsigned char *p=NULL;size_t n=0;int result=r->read(r->context,key,&p,&n);
    if(result==GS_NOT_FOUND)result=expected->present?GS_CONFLICT:0;
    else if(!result && (!expected->present || n!=expected->length || (n && memcmp(p,expected->bytes,n))))result=GS_CONFLICT;
    free(p);return result;
}
static int WXMapEntrySame(const GPEntry *a,const GPEntry *b) {
    return a && b && !strcmp(a->path,b->path) && !strcmp(a->native,b->native) &&
        a->mode==b->mode && a->flags==b->flags && !memcmp(a->dataOID,b->dataOID,20) &&
        !memcmp(a->metadataOID,b->metadataOID,20) && !memcmp(a->finderInfo,b->finderInfo,32);
}
static int WXMapCheck(const GRSnapshot *work,const GPMap *map,const GPMap *original,
    const WXKeys *keys,GPEqual eq,void *ctx) {
    GPMap expected;const GPEntry *e;size_t i;int result;
    GPInit(&expected);result=GPBuild(work,map,eq,ctx,&expected);
    if(!result && memcmp(work->tree,map->tree,20))result=GS_CONFLICT;
    for(i=0;!result && i<expected.count;++i)
        if(!WXMapEntrySame(expected.entries+i,GPFind(map,expected.entries[i].path)))result=GS_CONFLICT;
    for(i=0;!result && i<map->count;++i) {
        e=map->entries+i;if(GPFind(&expected,e->path))continue;
        /* Empty retained directories and local reservations have no baseline.
           Other retained identities must originate in the captured old map,
           outside the session's affected set. GPParse checked shape/aliases. */
        if(e->mode==GP_DIRECTORY || e->flags==GP_LOCAL)continue;
        if(WXOwns(keys,e->path) || !WXMapEntrySame(e,GPFind(original,e->path)))result=GS_CONFLICT;
    }
    GPFree(&expected);return result;
}
static const GRFile *WXFileAt(const GRSnapshot *s,const char *path) {
    size_t low=0,high=s->count,middle;
    while(low<high){middle=low+(high-low)/2;if(strcmp(s->files[middle].path,path)<0)low=middle+1;else high=middle;}
    return low<s->count && !strcmp(s->files[low].path,path)?s->files+low:NULL;
}
static int WXTake(GSRepository *r,const char *key,MSBytes *b) {
    unsigned char *p=NULL;size_t n=0;int result=r->read(r->context,key,&p,&n);
    if(result==GS_NOT_FOUND)return WXBytesSet(b,NULL,0,0);
    if(!result)result=WXBytesSet(b,p,n,1);
    free(p);return result;
}
static int WXRefShape(const MSBytes *b,const char *name) {
    char hex[41];unsigned char oid[20];size_t n=strlen(name);
    if(!b->present)return 0;
    if(b->length!=n+42 || memcmp(b->bytes,name,n+1) || b->bytes[n+41]!='\n')return GS_FORMAT;
    memcpy(hex,b->bytes+n+1,40);hex[40]=0;return GBOIDParse(hex,oid);
}
#endif
