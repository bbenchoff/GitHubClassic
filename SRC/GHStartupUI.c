/* Native encrypted startup state. Included after the vault UI/helpers.
   No TLS seed is installed until the encrypted next state and consumption of
   any private provisioning input have been flushed successfully. */
static unsigned char gStartupKey[32];
static char gStartupPassword[1025];
static unsigned long gStartupHigh,gStartupLow,gStartupNextHigh,gStartupNextLow;
static int gStartupHaveKey,gStartupStarting;
/* Ciphertext identities stay in RAM. A valid key alone does not authorize
   replacing another instance's newer vault. */
static unsigned char gStartupIdentity[32],gStartupPendingIdentity[32];
static unsigned long gStartupPendingHigh,gStartupPendingLow;
static int gStartupConfirmed,gStartupHavePending;
static int StartupConfirmCurrent(const unsigned char *,size_t);
typedef struct {FSSpec spec;short ref;long fileID;int have,fresh,consumed,inMemory;unsigned char bytes[64];} StartupInput;
static StartupInput gStartupInputs[2];
static int StartupInputCleanup(void) {
    int i,result=0;OSErr error;
    for(i=0;i<2;++i) {
        StartupInput *input=gStartupInputs+i;error=input->have?FSClose(input->ref):noErr;
        GVClear(input->bytes,sizeof(input->bytes));
        if(error)result=VF_IO;else memset(input,0,sizeof(*input));
    }
    return result;
}
/* Both the older beside-application input and the graphical first-install
   choice pass the same complete-file checks and consumption protocol. */
static int StartupReadInput(StartupInput *input,const FSSpec *spec) {
    CInfoPBRec info;long count;OSErr error;int j;
    if(input->have)return VF_IO;
    input->spec=*spec;memset(&info,0,sizeof(info));info.hFileInfo.ioNamePtr=input->spec.name;
    info.hFileInfo.ioVRefNum=input->spec.vRefNum;info.hFileInfo.ioDirID=input->spec.parID;
    error=PBGetCatInfoSync(&info);if(error)return VF_IO;
    if((info.hFileInfo.ioFlAttrib&16) || (((unsigned char *)&info.hFileInfo.ioFlFndrInfo)[8]&0x80) ||
       info.hFileInfo.ioFlRLgLen || info.hFileInfo.ioFlLgLen!=64 ||
       info.hFileInfo.ioFlFndrInfo.fdType=='GHZS')return SSL_NO_SEED;
    input->fileID=info.hFileInfo.ioDirID;
    error=FSpOpenDF(&input->spec,fsRdWrPerm,&input->ref);
    if(error)return VF_IO;
    input->have=1;count=64;error=FSRead(input->ref,&count,input->bytes);
    if(error || count!=64)return VF_IO;
    for(j=0;j<64 && !input->bytes[j];++j){}
    if(j<64)input->fresh=1;
    else {
        error=FSClose(input->ref);if(error)return VF_IO;
        memset(input,0,sizeof(*input));
    }
    return 0;
}
static int StartupReadInputs(int *which) {
    static const unsigned char names[2][16]={"\pSSL Seed","\p::SSL Seed"};
    ProcessInfoRec process;ProcessSerialNumber psn;FSSpec self,spec;
    OSErr error;int i,found=-1,result=StartupInputCleanup();
    if(result)return result;
    memset(gStartupInputs,0,sizeof(gStartupInputs));
    memset(&process,0,sizeof(process));process.processInfoLength=sizeof(process);process.processAppSpec=&self;
    if(GetCurrentProcess(&psn) || GetProcessInformation(&psn,&process))return VF_IO;
    for(i=0;i<2;++i) {
        StartupInput *input=gStartupInputs+i;
        error=FSMakeFSSpec(self.vRefNum,self.parID,(StringPtr)names[i],&spec);
        if(error==fnfErr)continue;if(error){result=VF_IO;break;}
        result=StartupReadInput(input,&spec);if(result)break;
        if(input->fresh) {
            if(found>=0){result=SC_BAD;break;}
            found=i;
        }
    }
    if(result){StartupInputCleanup();return result;}
    *which=found;return 0;
}
static int StartupSelectInput(int *which) {
    FSSpec spec;int result=StartupInputCleanup();
    if(result)return result;
    if(!StartupChooseProvisionFile(&spec))return GV_CANCEL;
    result=StartupReadInput(gStartupInputs,&spec);
    if(!result && !gStartupInputs[0].fresh)result=SSL_NO_SEED;
    if(result){StartupInputCleanup();return result;}
    *which=0;return 0;
}
/* A fresh installation can gather its bootstrap in RAM without a browser.
   The optional file path retains its existing consume-before-publish checks. */
static int StartupGatherInput(int *which) {
    int result=StartupInputCleanup();
    if(result)return result;
    result=StartupCollectSeed(gStartupInputs[0].bytes);
    if(result==1)return StartupSelectInput(which);
    if(result)return result;
    gStartupInputs[0].fresh=1;gStartupInputs[0].inMemory=1;*which=0;return 0;
}
/* Consume before publication. A crash during wiping leaves a reserved file
   type which is never accepted as entropy, even if some bytes remain. */
static int StartupConsumeInput(StartupInput *input) {
    CInfoPBRec info;unsigned char zero[64];long count;OSErr error;
    if(!input->fresh)return 0;
    if(input->inMemory){GVClear(input->bytes,64);input->fresh=0;input->inMemory=0;return 0;}
    if(!input->have)return VF_IO;
    memset(&info,0,sizeof(info));info.hFileInfo.ioNamePtr=input->spec.name;
    info.hFileInfo.ioVRefNum=input->spec.vRefNum;info.hFileInfo.ioDirID=input->spec.parID;
    error=PBGetCatInfoSync(&info);
    if(error || info.hFileInfo.ioDirID!=input->fileID)return VF_IO;
    info.hFileInfo.ioDirID=input->spec.parID;
    info.hFileInfo.ioFlFndrInfo.fdCreator='GHCl';info.hFileInfo.ioFlFndrInfo.fdType='GHZS';
    error=PBSetCatInfoSync(&info);
    if(!error)error=FlushVol(NULL,input->spec.vRefNum);
    memset(zero,0,sizeof(zero));count=64;
    if(!error)error=SetFPos(input->ref,fsFromStart,0);
    if(!error)error=FSWrite(input->ref,&count,zero);
    if(!error && count!=64)error=ioErr;
    if(!error)error=FlushVol(NULL,input->spec.vRefNum);
    if(!error)error=FSClose(input->ref);
    if(!error){input->have=0;input->consumed=1;}
    GVClear(zero,sizeof(zero));return error?VF_IO:0;
}
static int StartupRetireInput(StartupInput *input) {
    CInfoPBRec info;unsigned char bytes[64];long count;OSErr error;int i;
    if(!input->consumed)return 0;
    memset(&info,0,sizeof(info));info.hFileInfo.ioNamePtr=input->spec.name;
    info.hFileInfo.ioVRefNum=input->spec.vRefNum;info.hFileInfo.ioDirID=input->spec.parID;
    error=PBGetCatInfoSync(&info);
    if(error || info.hFileInfo.ioDirID!=input->fileID ||
       (info.hFileInfo.ioFlAttrib&16) || (((unsigned char *)&info.hFileInfo.ioFlFndrInfo)[8]&0x80) ||
       info.hFileInfo.ioFlLgLen!=64 || info.hFileInfo.ioFlRLgLen ||
       info.hFileInfo.ioFlFndrInfo.fdCreator!='GHCl' || info.hFileInfo.ioFlFndrInfo.fdType!='GHZS')return VF_IO;
    error=FSpOpenDF(&input->spec,fsRdWrPerm,&input->ref);
    if(error)return VF_IO;
    input->have=1;count=64;error=FSRead(input->ref,&count,bytes);
    if(!error && count!=64)error=ioErr;
    if(!error)for(i=0;i<64;++i)if(bytes[i]){error=ioErr;break;}
    GVClear(bytes,sizeof(bytes));
    if(!error)error=FSClose(input->ref);
    if(!error){input->have=0;error=FSpDelete(&input->spec);}
    if(!error)error=FlushVol(NULL,input->spec.vRefNum);
    if(!error)memset(input,0,sizeof(*input));
    return error?VF_IO:0;
}
static int StartupPublish(void *unused,const void *before,size_t bn,const void *after,size_t an) {
    int result,i;(void)unused;
    for(i=0;i<2;++i){result=StartupConsumeInput(gStartupInputs+i);if(result)return result;}
    result=VFReplace(&gVaultStore,before,bn,before!=NULL,after,an);
    if(result)return result;
    for(i=0;i<2;++i)if(StartupRetireInput(gStartupInputs+i))return VF_UNCERTAIN;
    return 0;
}
static void StartupAdoptPrepared(const void *record,size_t n,const unsigned char key[32],const char *password,
                          unsigned long high,unsigned long low,const unsigned char identity[32]) {
    if(key!=gStartupKey)memcpy(gStartupKey,key,32);
    if(password!=gStartupPassword)strcpy(gStartupPassword,password);gStartupHaveKey=1;
    gStartupHigh=high;gStartupLow=low;
    memcpy(gStartupIdentity,identity,32);gStartupConfirmed=1;gStartupHavePending=0;
    GVClear(gStartupPendingIdentity,sizeof(gStartupPendingIdentity));gStartupPendingHigh=gStartupPendingLow=0;
    if(!LCStore(password))LCKeyStore(record,n,key);
}
static int StartupAdopt(const void *record,size_t n,const unsigned char key[32],const char *password,
                          unsigned long high,unsigned long low) {
    unsigned char identity[32];int result;memset(identity,0,sizeof(identity));
    result=GVKeyID(record,n,identity);
    if(!result)StartupAdoptPrepared(record,n,key,password,high,low,identity);
    else gStartupConfirmed=0;
    GVClear(identity,sizeof(identity));return result;
}
static int StartupPrepare(unsigned char **before,size_t *bn,const unsigned char key[32],const char *password) {
    unsigned char *plain=NULL;size_t pn=0;SCView view;SCReservation reserved;
    int result,which=-1,previousBusy=gBusy,legacy=0;
    if(!before || !*before || !bn || !key || !password || !password[0])return SC_BAD;
    memset(&reserved,0,sizeof(reserved));gBusy=1;
    result=GVOpenWithKey(*before,*bn,key,&plain,&pn);
    if(!result) {
        legacy=pn>=48 && !memcmp(plain,"GHAC0001",8);
        if(!legacy)result=SCRead(plain,pn,&view);
    }
    if(!result && gTLS.initialized) {
        if(legacy)result=SC_BAD;
        else if(!gStartupHaveKey || strcmp(password,gStartupPassword) || memcmp(key,gStartupKey,32))result=VF_CONFLICT;
        else result=StartupConfirmCurrent(*before,*bn);
        goto done;
    }
    if(!result)result=StartupReadInputs(&which);
    if(!result && legacy && which<0)result=StartupGatherInput(&which);
    if(!result) {
        SetStatus("Preparing encrypted secure network state...");
        if(legacy)result=SCMigrate(*before,*bn,key,gStartupInputs[which].bytes,StartupPublish,NULL,&reserved);
        else if(which>=0)result=SCAdvanceWithEntropy(*before,*bn,key,gStartupInputs[which].bytes,StartupPublish,NULL,&reserved);
        else result=SCAdvance(*before,*bn,key,StartupPublish,NULL,&reserved);
    }
    if(!result) {
        result=StartupAdopt(reserved.encoded,reserved.length,reserved.key,password,reserved.high,reserved.low);
        if(!result){VaultBytesFree(before,bn);*before=reserved.encoded;*bn=reserved.length;reserved.encoded=NULL;reserved.length=0;
            result=SSL_Initialize(&gTLS,reserved.tlsSeed,Pump,NULL);}
    }
done:
    SCFree(&reserved);VaultBytesFree(&plain,&pn);
    if(StartupInputCleanup() && !result)result=VF_IO;
    gBusy=previousBusy;return result;
}
static int StartupOpen(const unsigned char *before,size_t n,const char *pass,unsigned char key[32],unsigned char **plain,size_t *pn) {
    int result=LCKeyLoad(before,n,key);
    if(!result)result=GVOpenWithKey(before,n,key,plain,pn);
    if(result)return GVOpenRemember(before,n,(const unsigned char *)pass,strlen(pass),VaultProgress,NULL,plain,pn,key);
    return 0;
}
static int StartupInitializeTLS(void) {
    unsigned char *before=NULL,*plain=NULL,key[32];size_t bn=0,pn=0;
    char pass[1025],again[1025];int present=0,result,which=-1,previousBusy=gBusy;SCReservation reserved;
    if(gTLS.initialized)return 0;if(gStartupStarting)return SC_BAD;
    memset(key,0,sizeof(key));memset(pass,0,sizeof(pass));memset(again,0,sizeof(again));
    memset(&reserved,0,sizeof(reserved));gStartupStarting=1;gBusy=1;
    result=StartupInputCleanup();if(!result)result=VaultCryptoReady();
    if(!result)result=VFRead(&gVaultStore,&before,&bn,&present);
    if(result)goto done;
    if(present) {
        if(LCLoad(pass) && !VaultPassphrase("Unlock Local Vault","Unlock the encrypted local network state and saved login for this Macintosh session.","Unlock",pass)) {result=GV_CANCEL;goto done;}
        result=StartupOpen(before,bn,pass,key,&plain,&pn);
        if(!result)result=StartupPrepare(&before,&bn,key,pass);
    }else {
        result=StartupReadInputs(&which);if(!result && which<0)result=StartupGatherInput(&which);
        if(result)goto done;
        if(LCLoad(pass) || !GVNewPassphraseValid((const unsigned char *)pass,strlen(pass))) {
            if(!VaultPassphrase("Protect This Macintosh","Choose a local vault passphrase of at least 12 characters for secure network state and saved login. Your GitHub password is not used.","Continue",pass) ||
               !VaultPassphrase("Confirm Local Passphrase","Enter the same local passphrase again.","Create Vault",again)) {result=GV_CANCEL;goto done;}
            if(strcmp(pass,again)){result=GV_AUTH;goto done;}
        }
        if(!GVNewPassphraseValid((const unsigned char *)pass,strlen(pass))) {
            Message("Passphrase Too Short","Use at least 12 characters for the local vault passphrase. No vault was created.");
            result=GV_BAD;goto done;
        }
        SetStatus("Creating encrypted secure network state... Escape cancels.");
        result=SCInitializeProgress((const unsigned char *)pass,strlen(pass),gStartupInputs[which].bytes,
                                   StartupPublish,NULL,VaultProgress,NULL,&reserved);
        if(!result) {
            result=StartupAdopt(reserved.encoded,reserved.length,reserved.key,pass,reserved.high,reserved.low);
            if(!result)result=SSL_Initialize(&gTLS,reserved.tlsSeed,Pump,NULL);
        }
    }
done:
    SCFree(&reserved);VaultBytesFree(&before,&bn);VaultBytesFree(&plain,&pn);
    GVClear(key,sizeof(key));GVClear(pass,sizeof(pass));GVClear(again,sizeof(again));
    if(StartupInputCleanup() && !result)result=VF_IO;
    if(result && gTLS.initialized)SSL_Close(&gTLS);
    gBusy=previousBusy;gStartupStarting=0;return result;
}
static int StartupWrap(const void *credentials,size_t cn,unsigned char **out,size_t *outLength) {
    unsigned char seed[64];int result;
    if(!gStartupHaveKey || !gTLS.initialized)return SSL_NO_SEED;
    if(gStartupHigh==0xffffffffUL && gStartupLow==0xffffffffUL)return SC_EXHAUSTED;
    gStartupNextHigh=gStartupHigh;gStartupNextLow=gStartupLow;
    if(gStartupNextLow==0xffffffffUL){++gStartupNextHigh;gStartupNextLow=0;}else ++gStartupNextLow;
    memset(seed,0,sizeof(seed));result=mbedtls_ctr_drbg_random(&gTLS.random,seed,sizeof(seed));
    if(!result)result=SCPack(seed,gStartupNextHigh,gStartupNextLow,credentials,cn,out,outLength);
    GVClear(seed,sizeof(seed));return result;
}
static int StartupSaveCancelled(void) {return gDone || VaultProgress(NULL) || gDone;}
/* Authenticate only our confirmed snapshot, or one of the two possible
   outcomes of our last uncertain publication. Confirm durability before
   adopting either outcome; never roll back the live TLS random generator. */
static int StartupConfirmCurrent(const unsigned char *record,size_t n) {
    unsigned char identity[32],*plain=NULL;size_t pn=0;SCView view;
    unsigned long high,low;int result;
    if(!gStartupHaveKey || !gTLS.initialized)return SSL_NO_SEED;
    memset(identity,0,sizeof(identity));result=GVKeyID(record,n,identity);
    high=gStartupHigh;low=gStartupLow;
    if(!result && !memcmp(identity,gStartupIdentity,32)) {
        if(!gStartupConfirmed && !gStartupHavePending)result=VF_CONFLICT;
    }else if(!result && !gStartupConfirmed && gStartupHavePending &&
             !memcmp(identity,gStartupPendingIdentity,32)) {
        high=gStartupPendingHigh;low=gStartupPendingLow;
    }else if(!result)result=VF_CONFLICT;
    if(!result)result=GVOpenWithKey(record,n,gStartupKey,&plain,&pn);
    if(!result)result=SCRead(plain,pn,&view);
    if(!result && (view.high!=high || view.low!=low))result=VF_CONFLICT;
    if(!result && !gStartupConfirmed) {
        if(StartupSaveCancelled())result=GV_CANCEL;
        else result=VFReplace(&gVaultStore,record,n,1,record,n);
        if(!result)StartupAdoptPrepared(record,n,gStartupKey,gStartupPassword,view.high,view.low,identity);
    }
    VaultBytesFree(&plain,&pn);GVClear(identity,sizeof(identity));return result;
}
/* Caller may synchronize its remembered snapshot only after the save routine
   has stopped borrowing it. This read never adopts a different identity. */
static int StartupReadConfirmed(unsigned char **out,size_t *length) {
    unsigned char identity[32],*record=NULL;size_t n=0;int present=0,result;
    if(!out || !length || !gStartupHaveKey || !gStartupConfirmed)return VF_CONFLICT;
    memset(identity,0,sizeof(identity));result=VFRead(&gVaultStore,&record,&n,&present);
    if(!result && !present)result=VF_CONFLICT;
    if(!result)result=GVKeyID(record,n,identity);
    if(!result && memcmp(identity,gStartupIdentity,32))result=VF_CONFLICT;
    if(!result){*out=record;*length=n;record=NULL;n=0;}
    VaultBytesFree(&record,&n);GVClear(identity,sizeof(identity));return result;
}
/* Updating verified credentials is not a password change. Keep the already
   authenticated salt/key/round count, and draw a fresh nonce from the advancing
   live DRBG for every encryption attempt, including failed-write retries. */
static int StartupSaveCredentials(const void *credentials,size_t cn,const char *password,
                    const unsigned char *expected,size_t bn,int present,unsigned char **saved,size_t *sn) {
    unsigned char nonce[12],identity[32],*wrapped=NULL,*encoded=NULL;size_t wn=0,en=0;int result;
    if(!saved || !sn || !password || !password[0] || !gStartupHaveKey || !gTLS.initialized)return SSL_NO_SEED;
    if(present!=1 || !expected || !bn || strcmp(password,gStartupPassword))return VF_CONFLICT;
    if(!credentials || !cn)return SC_BAD;
    memset(nonce,0,sizeof(nonce));memset(identity,0,sizeof(identity));
    result=StartupSaveCancelled()?GV_CANCEL:StartupConfirmCurrent(expected,bn);
    if(!result && StartupSaveCancelled())result=GV_CANCEL;
    if(!result)result=StartupWrap(credentials,cn,&wrapped,&wn);
    if(!result)result=mbedtls_ctr_drbg_random(&gTLS.random,nonce,sizeof(nonce));
    if(!result)result=GVResealWithKey(expected,bn,gStartupKey,wrapped,wn,nonce,&encoded,&en);
    if(!result)result=GVKeyID(encoded,en,identity);
    if(!result && StartupSaveCancelled())result=GV_CANCEL;
    if(!result) {
        /* Publication has no UI cancellation checkpoints. Even VF_IO may
           follow a successful exchange, so every error needs reconciliation. */
        result=VFReplace(&gVaultStore,expected,bn,1,encoded,en);
        if(!result) {
            StartupAdoptPrepared(encoded,en,gStartupKey,password,gStartupNextHigh,gStartupNextLow,identity);
            *saved=encoded;*sn=en;encoded=NULL;en=0;
        }else {
            gStartupConfirmed=0;gStartupHavePending=1;memcpy(gStartupPendingIdentity,identity,32);
            gStartupPendingHigh=gStartupNextHigh;gStartupPendingLow=gStartupNextLow;
        }
    }
    VaultBytesFree(&wrapped,&wn);VaultBytesFree(&encoded,&en);
    GVClear(nonce,sizeof(nonce));GVClear(identity,sizeof(identity));return result;
}
static int StartupHasCredentials(const void *record,size_t n,int *has) {
    unsigned char *plain=NULL;size_t pn=0;SCView view;int result;
    if(!gStartupHaveKey){*has=1;return 0;}
    result=GVOpenWithKey(record,n,gStartupKey,&plain,&pn);
    if(!result) {
        if(pn>=48 && !memcmp(plain,"GHAC0001",8))*has=1;
        else {result=SCRead(plain,pn,&view);if(!result)*has=view.credentialLength!=0;}
    }
    VaultBytesFree(&plain,&pn);return result;
}
static int StartupClearCredentials(const unsigned char *before,size_t bn,int present) {
    SCReservation next;unsigned char *plain=NULL,key[32];size_t pn=0;SCView view;
    char pass[1025];int result,previousBusy=gBusy;
    if(!present)return 0;
    memset(&next,0,sizeof(next));memset(key,0,sizeof(key));memset(pass,0,sizeof(pass));gBusy=1;
    result=StartupInputCleanup();
    if(!result && gStartupHaveKey){memcpy(key,gStartupKey,32);strcpy(pass,gStartupPassword);result=GVOpenWithKey(before,bn,key,&plain,&pn);}
    else if(!result) {
        if(LCLoad(pass) && !VaultPassphrase("Unlock Local Vault","Unlock to remove the saved GitHub login while retaining secure network state.","Unlock",pass))result=GV_CANCEL;
        if(!result)result=StartupOpen(before,bn,pass,key,&plain,&pn);
    }
    if(!result && pn>=48 && !memcmp(plain,"GHAC0001",8))result=VFDelete(&gVaultStore,before,bn,1);
    else if(!result) {
        result=SCRead(plain,pn,&view);
        if(!result)result=SCRemove(before,bn,key,StartupPublish,NULL,&next);
        if(!result)result=StartupAdopt(next.encoded,next.length,next.key,pass,next.high,next.low);
    }
    SCFree(&next);VaultBytesFree(&plain,&pn);GVClear(key,sizeof(key));GVClear(pass,sizeof(pass));gBusy=previousBusy;return result;
}
static void StartupKeepUnlocked(void) {
    unsigned char identity[32],*record=NULL;size_t n=0;int present=0;
    memset(identity,0,sizeof(identity));
    if(gStartupHaveKey && gStartupConfirmed && gStartupPassword[0] &&
       !VFRead(&gVaultStore,&record,&n,&present) && present && !GVKeyID(record,n,identity) &&
       !memcmp(identity,gStartupIdentity,32))
        if(!LCStore(gStartupPassword))LCKeyStore(record,n,gStartupKey);
    VaultBytesFree(&record,&n);GVClear(identity,sizeof(identity));
}
static int StartupCopyPassword(char pass[1025]) {
    if(!gStartupHaveKey || !gStartupPassword[0])return 0;
    strcpy(pass,gStartupPassword);return 1;
}
static int StartupRekeyPassword(const void *before,size_t bn,const char *password,unsigned char **out,size_t *length) {
    unsigned char random[GV_RANDOM];SCReservation next;int result;
    if(!gStartupHaveKey || !gTLS.initialized)return SSL_NO_SEED;
    memset(random,0,sizeof(random));memset(&next,0,sizeof(next));
    result=mbedtls_ctr_drbg_random(&gTLS.random,random,sizeof(random));
    if(!result)result=SCRekey(before,bn,gStartupKey,(const unsigned char *)password,strlen(password),random,
                            StartupPublish,NULL,VaultProgress,NULL,&next);
    if(!result) {
        result=StartupAdopt(next.encoded,next.length,next.key,password,next.high,next.low);
        if(!result){*out=next.encoded;*length=next.length;next.encoded=NULL;next.length=0;}
    }
    GVClear(random,sizeof(random));SCFree(&next);return result;
}
static void StartupShutdown(void) {
    StartupInputCleanup();GVClear(gStartupKey,sizeof(gStartupKey));GVClear(gStartupPassword,sizeof(gStartupPassword));
    gStartupHaveKey=0;gStartupHigh=gStartupLow=gStartupNextHigh=gStartupNextLow=0;
    GVClear(gStartupIdentity,sizeof(gStartupIdentity));GVClear(gStartupPendingIdentity,sizeof(gStartupPendingIdentity));
    gStartupConfirmed=gStartupHavePending=0;gStartupPendingHigh=gStartupPendingLow=0;
}
