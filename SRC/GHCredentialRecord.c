#include "GHCredentialRecord.h"
#include <stdlib.h>
#include <string.h>

static void CRPut(unsigned char *p,unsigned long n) {
    p[0]=(unsigned char)(n>>24);p[1]=(unsigned char)(n>>16);p[2]=(unsigned char)(n>>8);p[3]=(unsigned char)n;
}
static unsigned long CRWord(const unsigned char *p) {
    return ((unsigned long)p[0]<<24)|((unsigned long)p[1]<<16)|((unsigned long)p[2]<<8)|p[3];
}
static int CRText(const char *s,size_t cap,int kind,size_t *length) {
    size_t i;unsigned char c;const char *end=(const char *)memchr(s,0,cap);
    if(!end)return CR_BAD;
    *length=(size_t)(end-s);
    if((kind==1 || kind==3 || kind==4) && !*length)return CR_BAD;
    if(kind==3 && (*length>20 || s[0]=='0'))return CR_BAD;
    for(i=0;i<*length;++i) {
        c=(unsigned char)s[i];if(c<(kind==2?32:33) || c>126)return CR_BAD;
        if(kind==3 && (c<'0' || c>'9'))return CR_BAD;
        if(kind==4 && !((c>='a' && c<='z') || (c>='A' && c<='Z') || (c>='0' && c<='9') || c=='-'))return CR_BAD;
    }
    return 0;
}
static int CRShape(const OACredentials *c,size_t sizes[6]) {
    if(CRText(c->access,sizeof(c->access),1,sizes) || CRText(c->refresh,sizeof(c->refresh),0,sizes+1) ||
       CRText(c->scope,sizeof(c->scope),2,sizes+2) || CRText(c->login,sizeof(c->login),4,sizes+3) ||
       CRText(c->accountID,sizeof(c->accountID),3,sizes+4) || CRText(c->clientID,sizeof(c->clientID),0,sizes+5))return CR_BAD;
    if(c->deviceIssued!=0 && c->deviceIssued!=1)return CR_BAD;
    if(c->expires>=0x80000000UL || c->refreshExpires>=0x80000000UL)return CR_BAD;
    if(c->deviceIssued) {
        if(!OAClientValid(c->clientID))return CR_BAD;
        if((c->refresh[0]!=0)!=(c->refreshExpires!=0))return CR_BAD;
        if(c->refresh[0] && !c->expires)return CR_BAD;
    } else if(c->refresh[0] || c->clientID[0] || c->refreshExpires)return CR_BAD;
    return 0;
}
int CRPack(const OACredentials *c,unsigned long utcNow,unsigned long monotonicNow,
           unsigned char **out,size_t *outLength) {
    const char *strings[6];size_t sizes[6],i,total=48,at=24;unsigned long age,access=0,refresh=0,flags=0;
    unsigned char *bytes;
    if(!c || !out || !outLength || c->bound!=1 || !utcNow || utcNow>0xffffffffUL || CRShape(c,sizes))return CR_BAD;
    age=(monotonicNow-c->issued)&0xffffffffUL;if(age>=0x80000000UL)return CR_CLOCK;
    if(c->expires) {
        flags|=1;if(age<c->expires)access=c->expires-age;
        if(access>0xffffffffUL-utcNow)return CR_CLOCK;
    }
    if(c->refreshExpires) {
        flags|=2;if(age<c->refreshExpires)refresh=c->refreshExpires-age;
        if(refresh>0xffffffffUL-utcNow)return CR_CLOCK;
    }
    if(!access && c->expires && !refresh)return CR_EXPIRED;
    if(c->refreshExpires && !refresh)return CR_EXPIRED;
    if(c->deviceIssued)flags|=4;
    strings[0]=c->access;strings[1]=c->refresh;strings[2]=c->scope;
    strings[3]=c->login;strings[4]=c->accountID;strings[5]=c->clientID;
    for(i=0;i<6;++i)total+=sizes[i];
    bytes=(unsigned char *)malloc(total);if(!bytes)return CR_MEMORY;
    memcpy(bytes,"GHAC0001",8);CRPut(bytes+8,utcNow);CRPut(bytes+12,flags);
    CRPut(bytes+16,(flags&1)?utcNow+access:0);CRPut(bytes+20,(flags&2)?utcNow+refresh:0);
    for(i=0;i<6;++i){CRPut(bytes+at,(unsigned long)sizes[i]);at+=4;memcpy(bytes+at,strings[i],sizes[i]);at+=sizes[i];}
    *out=bytes;*outLength=total;return 0;
}
int CRUnpack(const void *input,size_t length,unsigned long utcNow,unsigned long monotonicNow,
             OACredentials *out,int *expiredAccess) {
    const unsigned char *bytes=(const unsigned char *)input;OACredentials *next;
    char *strings[6];size_t caps[6],sizes[6],at=24,i,n;unsigned long saved,flags,access,refresh;int result=CR_BAD,expired=0;
    if(!bytes || !out || !expiredAccess || length<48 || length>18000 || memcmp(bytes,"GHAC0001",8) || !utcNow || utcNow>0xffffffffUL)return CR_BAD;
    saved=CRWord(bytes+8);flags=CRWord(bytes+12);access=CRWord(bytes+16);refresh=CRWord(bytes+20);
    if(!saved || flags>7 || ((flags&1)==0 && access) || ((flags&2)==0 && refresh) ||
       ((flags&1) && access<saved) || ((flags&2) && refresh<saved) || ((flags&2) && (flags&5)!=5))return CR_BAD;
    if(utcNow<saved)return CR_CLOCK;
    if(((flags&2) && utcNow>=refresh) || ((flags&1) && utcNow>=access && !(flags&2)))return CR_EXPIRED;
    next=(OACredentials *)calloc(1,sizeof(*next));if(!next)return CR_MEMORY;
    strings[0]=next->access;caps[0]=sizeof(next->access);strings[1]=next->refresh;caps[1]=sizeof(next->refresh);
    strings[2]=next->scope;caps[2]=sizeof(next->scope);strings[3]=next->login;caps[3]=sizeof(next->login);
    strings[4]=next->accountID;caps[4]=sizeof(next->accountID);strings[5]=next->clientID;caps[5]=sizeof(next->clientID);
    for(i=0;i<6;++i) {
        if(length-at<4)goto done;
        n=(size_t)CRWord(bytes+at);at+=4;
        if(n>=caps[i] || n>length-at || memchr(bytes+at,0,n))goto done;
        memcpy(strings[i],bytes+at,n);strings[i][n]=0;at+=n;
    }
    if(at!=length)goto done;
    next->deviceIssued=(flags&4)!=0;next->issued=monotonicNow;
    if(flags&1) {
        if(utcNow>=access){expired=1;next->issued=(monotonicNow-1)&0xffffffffUL;next->expires=1;}
        else next->expires=access-utcNow;
    }
    if(flags&2)next->refreshExpires=refresh-utcNow+(unsigned long)expired;
    if(CRShape(next,sizes))goto done;
    /* The loaded identity is the expected account, never a fresh authorization. */
    next->bound=0;*out=*next;*expiredAccess=expired;result=0;
done:
    OAClear(next,sizeof(*next));free(next);return result;
}
