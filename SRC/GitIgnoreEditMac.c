#include "GitIgnoreEditMac.h"
#include "GitWorkMac.h"
#include <stdlib.h>
#include <string.h>

int GEIgnoreFile(const GSMacStore *root, GSRepository *repository, FSSpec *out, OSErr *last) {
    GPMap map;
    GIIndex index;
    const GPEntry *mapped;
    const GIEntry *indexed;
    GFCatalog parent;
    const char *leaf;
    char *logical = NULL, actual[32];
    size_t n;
    long number;
    CInfoPBRec pb;
    Str255 name;
    FSSpec spec;
    OSErr error;
    int result;
    if (!root || !repository || !out || !last) return GB_BAD;
    *last = noErr; GPInit(&map); GIInit(&index); memset(&spec, 0, sizeof(spec));
    result = GFDirectoryAt(root->volume, root->directory, &parent, last);
    if (!result && !(parent.attributes & 16)) result = GS_CONFLICT;
    if (!result) result = GPLoad(repository, GWMacNameEqual, NULL, &map);
    if (!result) result = GILoad(repository, &index);
    if (result) goto done;
    mapped = GPFind(&map, ".gitignore"); indexed = GIFind(&index, ".gitignore", 0);
    if ((mapped && mapped->mode != 0100644 && mapped->mode != 0100755) ||
        (indexed && indexed->stat[6] != 0100644 && indexed->stat[6] != 0100755)) {
        result = GI_UNSUPPORTED; goto done;
    }
    leaf = mapped ? mapped->native : ".gitignore"; n = strlen(leaf);
    if (!n || n > 31 || strchr(leaf, ':')) { result = GI_UNSUPPORTED; goto done; }
    result = GPResolve(&map, leaf, GWMacNameEqual, NULL, &logical);
    if (!result && strcmp(logical, ".gitignore")) result = GS_CONFLICT;
    free(logical); logical = NULL;
    if (result) goto done;
    spec.vRefNum = root->volume; spec.parID = root->directory;
    spec.name[0] = (unsigned char)n; memcpy(spec.name + 1, leaf, n);
    /* HFS lookup alone would accept .GITIGNORE as .gitignore. Enumerate the
       physical spelling and resolve its actual ownership before editing it. */
    for (number = 1; number <= 32767; ++number) {
        memset(&pb, 0, sizeof(pb)); pb.dirInfo.ioNamePtr = name;
        pb.dirInfo.ioVRefNum = root->volume; pb.dirInfo.ioDrDirID = root->directory;
        pb.dirInfo.ioFDirIndex = (short)number; error = PBGetCatInfoSync(&pb);
        if (error == fnfErr) { *out = spec; goto done; }
        if (error) { *last = error; result = GS_IO; goto done; }
        if (!name[0] || name[0] > 31 || memchr(name + 1, 0, name[0])) {
            result = GI_UNSUPPORTED; goto done;
        }
        memcpy(actual, name + 1, name[0]); actual[name[0]] = 0;
        if (!GWMacNameEqual(NULL, actual, leaf)) continue;
        if (pb.dirInfo.ioFlAttrib & 16) { result = GI_UNSUPPORTED; goto done; }
        if (((unsigned char *)&pb.hFileInfo.ioFlFndrInfo)[8] & 0x80) {
            result = GI_UNSUPPORTED; goto done;
        }
        result = GPResolve(&map, actual, GWMacNameEqual, NULL, &logical);
        if (!result && strcmp(logical, ".gitignore")) result = GS_CONFLICT;
        if (!result) { memcpy(spec.name, name, (size_t)name[0] + 1); *out = spec; }
        goto done;
    }
    result = GI_UNSUPPORTED;
done:
    free(logical); GPFree(&map); GIFree(&index); return result;
}
