#include "GitIgnore.h"
#include <stdlib.h>
#include <string.h>

void GOInit(GOSet *set) { memset(set, 0, sizeof(*set)); }
static void GOFreeSource(GOSource *s) {
    size_t i;
    for (i = 0; i < s->count; ++i) free(s->patterns[i].pattern);
    free(s->patterns); free(s->base); memset(s, 0, sizeof(*s));
}
void GOFree(GOSet *set) {
    size_t i;
    for (i = 0; i < set->count; ++i) GOFreeSource(set->sources + i);
    free(set->sources); GOInit(set);
}
static int GOPath(const char *path, int empty) {
    size_t i, start = 0, n = strlen(path);
    if (n > 4096 || (!n && !empty)) return 0;
    if (!n) return 1;
    for (i = 0; i <= n; ++i) if (!path[i] || path[i] == '/') {
        if (i == start || (i - start == 1 && path[start] == '.') ||
            (i - start == 2 && !memcmp(path + start, "..", 2))) return 0;
        start = i + 1;
    }
    return 1;
}
static char *GOString(const void *data, size_t n) {
    char *p = (char *)malloc(n + 1);
    if (p) { if (n) memcpy(p, data, n); p[n] = 0; }
    return p;
}
int GOAdd(GOSet *set, const char *base, int priority, const void *input, size_t length) {
    const unsigned char *bytes = (const unsigned char *)input;
    GOSource next, *grown;
    GOPattern *rules, *rule;
    size_t i = 0, start, end, at, slashes;
    int error = 0;
    if (!set || !base || (!input && length) || !GOPath(base, 1) ||
        (priority != 0 && priority != 1) || (length && memchr(input, 0, length))) return GB_BAD;
    if (set->count >= 256 || length > 131072UL - set->bytes) return GB_SPACE;
    memset(&next, 0, sizeof(next)); next.priority = priority;
    next.base = GOString(base, strlen(base)); if (!next.base) return GB_MEMORY;
    if (length >= 3 && !memcmp(bytes, "\357\273\277", 3)) i = 3;
    while (i < length) {
        start = i; while (i < length && bytes[i] != '\n') ++i; end = i;
        if (i < length) ++i;
        if (end > start && bytes[end - 1] == '\r') --end;
        while (end > start && bytes[end - 1] == ' ') {
            slashes = 0; at = end - 1;
            while (at > start && bytes[at - 1] == '\\') { --at; ++slashes; }
            if (slashes & 1) break;
            --end;
        }
        if (end == start || bytes[start] == '#') continue;
        if (end - start > 4096 || set->rules + next.count >= 2048) { error = GB_SPACE; goto done; }
        rules = (GOPattern *)realloc(next.patterns, (next.count + 1) * sizeof(*rules));
        if (!rules) { error = GB_MEMORY; goto done; }
        next.patterns = rules; rule = rules + next.count; memset(rule, 0, sizeof(*rule));
        if (bytes[start] == '!') { rule->negate = 1; ++start; }
        if (start == end) continue;
        if (bytes[end - 1] == '/') { rule->directory = 1; --end; }
        if (start < end && bytes[start] == '/') { rule->anchored = 1; ++start; }
        if (start == end) continue;
        if (memchr(bytes + start, '/', end - start)) rule->anchored = 1;
        rule->pattern = GOString(bytes + start, end - start);
        if (!rule->pattern) { error = GB_MEMORY; goto done; }
        ++next.count;
    }
    grown = (GOSource *)realloc(set->sources, (set->count + 1) * sizeof(*grown));
    if (!grown) { error = GB_MEMORY; goto done; }
    set->sources = grown; set->sources[set->count++] = next;
    set->rules += next.count; set->bytes += length; memset(&next, 0, sizeof(next));
done:
    GOFreeSource(&next); return error;
}
static int GOCategory(const unsigned char *name, size_t n, unsigned c) {
    int lower = c >= 'a' && c <= 'z', upper = c >= 'A' && c <= 'Z';
    int digit = c >= '0' && c <= '9';
#define GO_CLASS(s) (n == sizeof(s) - 1 && !memcmp(name, s, n))
    if (GO_CLASS("alnum")) return lower || upper || digit;
    if (GO_CLASS("alpha")) return lower || upper;
    if (GO_CLASS("blank")) return c == ' ' || c == '\t';
    if (GO_CLASS("cntrl")) return c < 32 || c == 127;
    if (GO_CLASS("digit")) return digit;
    if (GO_CLASS("graph")) return c >= 33 && c <= 126;
    if (GO_CLASS("lower")) return lower;
    if (GO_CLASS("print")) return c >= 32 && c <= 126;
    if (GO_CLASS("punct")) return c >= 33 && c <= 126 && !lower && !upper && !digit;
    if (GO_CLASS("space")) return c == ' ' || (c >= 9 && c <= 13);
    if (GO_CLASS("upper")) return upper;
    if (GO_CLASS("xdigit")) return digit || (c >= 'a' && c <= 'f') || (c >= 'A' && c <= 'F');
    return -1;
#undef GO_CLASS
}
static size_t GOClass(const unsigned char *p, size_t n, unsigned char mask[256]) {
    size_t i = 1, start, end;
    unsigned c, last;
    int negate = 0, value;
    memset(mask, 0, 256);
    if (i < n && (p[i] == '!' || p[i] == '^')) { negate = 1; ++i; }
    if (i < n && p[i] == ']') mask[p[i++]] = 1;
    while (i < n && p[i] != ']') {
        if (p[i] == '[' && i + 1 < n && p[i + 1] == ':') {
            start = i + 2; end = start;
            while (end + 1 < n && !(p[end] == ':' && p[end + 1] == ']')) ++end;
            if (end + 1 == n) return 0;
            for (c = 0; c < 256; ++c) {
                value = GOCategory(p + start, end - start, c);
                if (value < 0) return 0;
                if (value) mask[c] = 1;
            }
            i = end + 2; continue;
        }
        c = p[i++];
        if (c == '\\') { if (i == n) return 0; c = p[i++]; }
        if (i + 1 < n && p[i] == '-' && p[i + 1] != ']') {
            ++i; last = p[i++];
            if (last == '\\') { if (i == n) return 0; last = p[i++]; }
            while (c <= last) mask[c++] = 1;
        } else mask[c] = 1;
    }
    if (i == n) return 0;
    if (negate) for (c = 0; c < 256; ++c) mask[c] = !mask[c];
    return i + 1;
}
/* Two iterative DP rows. A double-star followed by slash can consume zero or
   more directory prefixes; terminal double-star spans slashes. Ordinary stars
   never cross them. No recursive wildcard expansion. */
static int GOWild(const char *pattern, const char *text, size_t n,
                   unsigned char *a, unsigned char *b, size_t *work, int *match) {
    const unsigned char *p = (const unsigned char *)pattern;
    size_t pn = strlen(pattern), i = 0, j, next, run;
    unsigned char mask[256], literal = 0, *swap;
    int kind, seen, live;
    *match = 0; memset(a, 0, n + 1); a[0] = 1;
    while (i < pn) {
        kind = 0; next = i + 1; literal = p[i];
        if (p[i] == '*') {
            run = next; while (run < pn && p[run] == '*') ++run;
            kind = 2; next = run;
            if (run - i >= 2 && (!i || p[i - 1] == '/') &&
                (run == pn || p[run] == '/' || (p[run] == '\\' && run + 1 < pn && p[run + 1] == '/'))) {
                kind = run < pn && p[run] == '/' ? 4 : 3;
                if (kind == 4) next = run + 1;
            }
        } else if (p[i] == '?') kind = 1;
        else if (p[i] == '[') {
            run = GOClass(p + i, pn - i, mask); if (!run) return 0;
            kind = 5; next = i + run;
        } else if (p[i] == '\\') {
            if (next == pn) return 0;
            literal = p[next++];
        }
        memset(b, 0, n + 1); seen = live = 0;
        for (j = 0; j <= n; ++j) {
            if (++*work > 8000000UL) return GB_SPACE;
            if (kind == 2 || kind == 3) b[j] = a[j] || (j && b[j - 1] && (kind == 3 || text[j - 1] != '/'));
            else if (kind == 4) { if (a[j]) seen = 1; b[j] = a[j] || (j && text[j - 1] == '/' && seen); }
            else if (j && a[j - 1]) {
                if (kind == 1) b[j] = text[j - 1] != '/';
                else if (kind == 5) b[j] = text[j - 1] != '/' && mask[(unsigned char)text[j - 1]];
                else b[j] = (unsigned char)text[j - 1] == literal;
            }
            live |= b[j];
        }
        if (!live) return 0;
        swap = a; a = b; b = swap; i = next;
    }
    *match = a[n] != 0; return 0;
}
static int GOAt(const GOSet *set, const char *path, size_t n, int directory,
                 unsigned char *a, unsigned char *b, size_t *work, int *ignored) {
    size_t i, j, base, start, winningBase = 0;
    int rank = -1, match, error;
    const GOSource *s;
    const GOPattern *r;
    *ignored = 0;
    for (i = 0; i < set->count; ++i) {
        s = set->sources + i; base = strlen(s->base);
        if (base && (n <= base || path[base] != '/' || memcmp(path, s->base, base))) continue;
        if (s->priority < rank || (s->priority == rank && base < winningBase)) continue;
        for (j = 0; j < s->count; ++j) {
            r = s->patterns + j; if (r->directory && !directory) continue;
            start = base ? base + 1 : 0;
            if (!r->anchored) { size_t k; for (k = start; k < n; ++k) if (path[k] == '/') start = k + 1; }
            error = GOWild(r->pattern, path + start, n - start, a, b, work, &match);
            if (error) return error;
            if (match) { *ignored = !r->negate; rank = s->priority; winningBase = base; }
        }
    }
    return 0;
}
int GOIgnored(const GOSet *set, const char *path, int directory, int *ignored) {
    unsigned char *rows;
    size_t i, n, work = 0;
    int error = 0, found = 0;
    if (ignored) *ignored = 0;
    if (!set || !path || !ignored || !GOPath(path, 0) || (directory != 0 && directory != 1)) return GB_BAD;
    n = strlen(path); rows = (unsigned char *)malloc(2 * (n + 1)); if (!rows) return GB_MEMORY;
    for (i = 0; i <= n; ++i) if (i == n || path[i] == '/') {
        error = GOAt(set, path, i, i < n || directory, rows, rows + n + 1, &work, &found);
        if (error || found) break;
    }
    free(rows); if (!error) *ignored = found; return error;
}
