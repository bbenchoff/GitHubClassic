/* Included after GitRebaseTransitions.c; draft explicit choices into the actual
   working preview, index, map and marker under one reserved generation. */
#include "GitRebaseTransitions.h"
int RLUpdate(GSRepository *source,const void *expected,size_t length,const RLLimits *limits,const unsigned char binding[32],
    const MSChoices *choices,const GQWork *work,size_t count,GPEqual eq,void *eqCtx,GDProgress fn,void *ctx,RLPlan *out,GQError *why) {
    RLSession *old;RLPlan *next;MSWorkspace drafts;RKState parsed;RLIO io;RLView view;GSRepository r,virtualRepo;
    MSBytes incoming;WXKeys keys,oldKeys,paths,strict;GIIndex original,composed;GRSnapshot after;GQProtection protection,owned;
    const GCMetadata *map,*index;unsigned char *bytes=NULL,*wire=NULL;size_t n=0,wn=0,i;GBWord generation=0;
    char incomingKey[64],branchKey[64];int result,borrowed=0;
    if(!expected || !length || !limits || !binding || !choices || !out || !eq || (count && !work))return GB_BAD;
    if(why)memset(why,0,sizeof(*why));old=(RLSession *)calloc(1,sizeof(*old));next=(RLPlan *)calloc(1,sizeof(*next));
    if(!old || !next){free(old);free(next);return GB_MEMORY;}MSWorkspaceInit(&drafts);RKInit(&parsed);memset(&view,0,sizeof(view));memset(&incoming,0,sizeof(incoming));
    memset(&keys,0,sizeof(keys));memset(&oldKeys,0,sizeof(oldKeys));memset(&paths,0,sizeof(paths));memset(&strict,0,sizeof(strict));GIInit(&original);GIInit(&composed);GRInit(&after);
    result=RLIOStart(source,limits,fn,ctx,&io,&r);if(!result)result=RLOpen(&r,limits,binding,eq,eqCtx,fn,ctx,old);
    if(!result && (length!=old->state.originalLength || memcmp(expected,old->state.original,length)))result=GS_CONFLICT;
    if(!result)result=RLLive(&r,&old->state,&generation);if(!result && generation==0xffffffffU)result=GB_SPACE;
    if(!result)result=GSRefKey(old->state.replay.ontoRef,incomingKey);if(!result)result=WXTake(&r,incomingKey,&incoming);
    if(!result)result=WXRefShape(&incoming,old->state.replay.ontoRef);
    if(!result)result=RKParse(old->state.original,old->state.originalLength,&limits->state,eq,eqCtx,&next->state);
    if(!result){MSChoicesFree(&next->state.replay.choices);next->state.replay.choices=*choices;borrowed=1;}
    if(!result)result=RLPreview(&r,&next->state.replay,&old->replay,fn,ctx,&drafts,next->tree,next->state.workspace,&after);
    if(!result){paths.paths=next->state.affected;paths.count=next->state.affectedCount;next->state.affected=NULL;next->state.affectedCount=0;
        result=RLAffected(&paths,&old->replay.original,&old->replay.conflict,choices,&after,&limits->state.records);}
    if(!result){next->state.affected=paths.paths;next->state.affectedCount=paths.count;memset(&paths,0,sizeof(paths));}
    if(!result)result=WXKeysMake((const char *const *)old->state.affected,old->state.affectedCount,&oldKeys);
    if(!result)result=WXKeysMake((const char *const *)next->state.affected,next->state.affectedCount,&keys);
    for(i=0;!result && i<next->state.affectedCount;++i) {
        const char *path=next->state.affected[i];
        if(!WXOwns(&oldKeys,path) || WXFileSame(&old->preview,WXFileAt(&old->preview,path),&after,WXFileAt(&after,path)))result=WXPathAdd(&strict,&limits->state.records,path);
    }
    protection.paths=(const char *const *)strict.paths;protection.count=strict.count;protection.changed=0;
    owned.paths=(const char *const *)old->state.affected;owned.count=old->state.affectedCount;owned.changed=0;
    if(!result)result=RLViewStart(&r,&old->state,&view,&virtualRepo);
    if(!result)result=GQToCommitOwned(&virtualRepo,old->state.replay.branch,old->state.workspace,next->state.workspace,
        work,count,&protection,&owned,eq,eqCtx,&next->checkout,why);
    if(!result)result=GIParse(old->state.replay.before[2].bytes,old->state.replay.before[2].length,&original);
    if(!result)result=WXCompose(&old->replay.original.index,&original,&drafts.preview.index,&keys,&composed);
    if(!result && !WXIndexSame(&composed,&next->checkout.index))result=GS_CONFLICT;
    if(!result)result=WXCompose(&old->replay.original.index,&original,&drafts.index.index,&keys,&composed);
    if(!result)result=GIEncode(&composed,&bytes,&n);if(!result)result=WXBytesSet(&next->state.index,bytes,n,1);free(bytes);bytes=NULL;
    index=WXMeta(&next->checkout.transaction,"index");map=WXMeta(&next->checkout.transaction,"ghclient-map");if(!result && (!index || !map))result=GS_FORMAT;
    if(!result)result=WXBytesSet(&next->state.workIndex,index->after,index->afterLength,index->afterPresent);
    if(!result)result=WXBytesSet(&next->state.mapping,map->after,map->afterLength,map->afterPresent);
    if(!result){next->state.replay.revision=generation;result=RKEncode(&next->state,&limits->state,eq,eqCtx,&wire,&wn);}
    if(borrowed){MSChoicesInit(&next->state.replay.choices);borrowed=0;}
    if(!result)result=RKParse(wire,wn,&limits->state,eq,eqCtx,&parsed);if(!result){RKFree(&next->state);next->state=parsed;RKInit(&parsed);}
    if(!result)result=GSRefKey(old->state.replay.branch,branchKey);
    if(!result)result=WXMetaSet(&next->checkout.transaction,"HEAD",old->state.replay.before[0].bytes,old->state.replay.before[0].length,1,
        old->state.replay.before[0].bytes,old->state.replay.before[0].length,1);
    if(!result)result=WXMetaSet(&next->checkout.transaction,branchKey,old->state.replay.before[1].bytes,old->state.replay.before[1].length,1,
        old->state.replay.before[1].bytes,old->state.replay.before[1].length,1);
    if(!result)result=WXMetaSet(&next->checkout.transaction,"index",old->state.index.bytes,old->state.index.length,1,next->state.index.bytes,next->state.index.length,1);
    if(!result)result=WXMetaSet(&next->checkout.transaction,incomingKey,incoming.bytes,incoming.length,incoming.present,incoming.bytes,incoming.length,incoming.present);
    if(!result)result=WXMetaSet(&next->checkout.transaction,"ghclient-rebase",old->state.original,old->state.originalLength,1,wire,wn,1);
    next->checkout.transaction.generation=generation;next->unresolved=drafts.index.unresolved;
    if(!result)result=GCEncode(&next->checkout.transaction,eq,eqCtx,&bytes,&n);if(!result && n>limits->journalBytes)result=GB_SPACE;
    if(!result)result=RLLive(&r,&old->state,&generation);if(!result)result=WXMatch(&r,incomingKey,&incoming);if(!result)result=RLTick(&io);
    if(!result){RLFree(out);*out=*next;RLInit(next);}
    free(bytes);free(wire);free(view.ref.bytes);free(incoming.bytes);WXKeysFree(&keys);WXKeysFree(&oldKeys);WXKeysFree(&paths);WXKeysFree(&strict);
    GIFree(&original);GIFree(&composed);GRFree(&after);RKFree(&parsed);MSWorkspaceFree(&drafts);RLSessionFree(old);RLFree(next);free(old);free(next);return result;
}
int RLUpdateStart(GSRepository *r,GCBackend *b,GTControl *c,const unsigned char binding[32],GPEqual eq,void *ctx,const RLPlan *p) {
    const GCMetadata *m;
    if(!p || !binding || memcmp(binding,p->state.replay.binding,32) || !p->state.original || !p->state.replay.generation ||
        p->state.replay.generation>=p->checkout.transaction.generation || p->state.replay.revision!=p->checkout.transaction.generation || p->exitAction)return GS_CONFLICT;
    m=WXMeta(&p->checkout.transaction,"ghclient-rebase");
    if(!m || !m->beforePresent || !m->beforeLength || !m->afterPresent || m->afterLength!=p->state.originalLength || memcmp(m->after,p->state.original,m->afterLength))return GS_CONFLICT;
    return GTStartAtGeneration(r,b,c,binding,eq,ctx,p->checkout.transaction.generation,&p->checkout.transaction);
}
