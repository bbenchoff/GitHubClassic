#include "GitStashDrop.h"
#include "GitCheckoutSession.h"
#include "GitHistory.h"
#include <stdlib.h>
#include <string.h>

static void *SDCopy(const void *p,size_t n){void *q=malloc(n?n:1);if(q && n)memcpy(q,p,n);return q;}
static const GCMetadata *SDMeta(const GCTransaction *t,const char *key){
    size_t i;for(i=0;i<t->metadataCount;++i)if(!strcmp(t->metadata[i].path,key))return t->metadata+i;return NULL;
}
static int SDAdd(GCTransaction *t,const char *key,const void *a,size_t an,int ap,const void *b,size_t bn,int bp){
    GCMetadata *m;
    if(SDMeta(t,key))return GS_FORMAT;
    if(t->metadataCount>=(size_t)-1/sizeof(*m))return GB_SPACE;
    m=realloc(t->metadata,(t->metadataCount+1)*sizeof(*m));if(!m)return GB_MEMORY;
    t->metadata=m;m+=t->metadataCount++;memset(m,0,sizeof(*m));m->path=SDCopy(key,strlen(key)+1);
    m->beforePresent=ap;m->afterPresent=bp;m->beforeLength=an;m->afterLength=bn;
    if(ap)m->before=SDCopy(a,an);if(bp)m->after=SDCopy(b,bn);
    return !m->path || (ap && !m->before) || (bp && !m->after)?GB_MEMORY:0;
}
static int SDRead(GSRepository *r,const char *key,size_t cap,unsigned char **p,size_t *n,int *present){
    int result;*p=NULL;*n=0;*present=0;result=r->read(r->context,key,p,n);
    if(result==GS_NOT_FOUND){free(*p);*p=NULL;*n=0;return 0;}
    if(result)return result;
    if(*n>cap)return GB_SPACE;
    if(!*p)return GS_FORMAT;
    *present=1;return 0;
}
static int SDGuard(GSRepository *r,const char *key,size_t cap,GCTransaction *t){
    unsigned char *p=NULL;size_t n=0;int present=0,result;
    result=SDRead(r,key,cap,&p,&n,&present);
    if(!result)result=SDAdd(t,key,p,n,present,p,n,present);free(p);return result;
}
static int SDReviewSame(const SPState *a,const SPState *b){
    if(a->refPresent!=b->refPresent || a->logPresent!=b->logPresent ||
       a->refLength!=b->refLength || a->log.length!=b->log.length)return 0;
    if(a->refLength && (!a->ref || memcmp(a->ref,b->ref,a->refLength)))return 0;
    return !a->log.length || (a->log.bytes && !memcmp(a->log.bytes,b->log.bytes,a->log.length));
}
static int SDCommit(GSRepository *r,const unsigned char oid[20],size_t cap,GHCommitInfo *info,unsigned char *parents){
    unsigned char *p=NULL,*tree=NULL;size_t n=0,tn=0,at,end,count=0;char type[7],hex[41];int result;
    result=GSGetObjectLimit(r,oid,type,&p,&n,cap);
    if(!result)result=strcmp(type,"commit")?GS_FORMAT:GHCommitParse(p,n,info);
    if(!result && parents){
        if(info->parents<2 || info->parents>3)result=GS_FORMAT;
        for(at=46;!result && at<info->messageOffset-1;at=end+1){
            for(end=at;end<n && p[end]!='\n';++end){}
            if(end-at>=7 && !memcmp(p+at,"parent ",7)){
                if(count>=3 || end-at!=47){result=GS_FORMAT;break;}
                memcpy(hex,p+at+7,40);hex[40]=0;result=GBOIDParse(hex,parents+count++*20);
            }
        }
        if(!result && count!=(size_t)info->parents)result=GS_FORMAT;
    }
    if(!result)result=GSGetObjectLimit(r,info->tree,type,&tree,&tn,cap);
    if(!result && strcmp(type,"tree"))result=GS_FORMAT;
    free(p);free(tree);return result;
}
static int SDStash(GSRepository *r,const unsigned char oid[20],size_t cap){
    GHCommitInfo working,base,index,untracked;unsigned char parents[60];int result;
    result=SDCommit(r,oid,cap,&working,parents);
    if(!result)result=SDCommit(r,parents,cap,&base,NULL);
    if(!result)result=SDCommit(r,parents+20,cap,&index,NULL);
    if(!result && (index.parents!=1 || memcmp(index.parent,parents,20)))result=GS_FORMAT;
    if(!result && working.parents==3){
        result=SDCommit(r,parents+40,cap,&untracked,NULL);
        if(!result && untracked.parents)result=GS_FORMAT;
    }
    return result;
}
static int SDFresh(GSRepository *r,const GCTransaction *t,size_t cap){
    unsigned char *p=NULL;size_t n=0,i;GBWord generation;int present=0,result;
    result=GTNormalWriteAllowed(r);if(!result)result=GTNextGeneration(r,&generation);
    if(!result && generation!=t->generation)result=GS_CONFLICT;
    for(i=0;!result && i<t->metadataCount;++i){const GCMetadata *m=t->metadata+i;
        /* Stash log may have its own larger cap; its exact captured length is
           already bounded by SPRead and the encoded transaction budget. */
        size_t bound=m->beforeLength>cap?m->beforeLength:cap;
        result=SDRead(r,m->path,bound,&p,&n,&present);
        if(!result && (present!=m->beforePresent || n!=m->beforeLength ||
           (n && memcmp(p,m->before,n))))result=GS_CONFLICT;
        free(p);p=NULL;
    }
    return result;
}
int SDPrepareDrop(GSRepository *r,const SPState *reviewed,size_t newestIndex,
    const unsigned char expected[20],const SLLimits *limits,size_t stateBytes,
    GPEqual eq,void *ctx,GCTransaction *out){
    GCTransaction next;SPState state;const GCMetadata *m;unsigned char tip[20],ref[52],*log=NULL,*wire=NULL;
    size_t n=0,wn=0,bn=0,latest;char *branch=NULL,key[64],hex[41];int result,haveTip,remain;
    if(!r || !r->read || !reviewed || !expected || !limits || stateBytes<160 || !eq || !out)return GB_BAD;
    GCInit(&next);SPStateInit(&state);
    result=GTNormalWriteAllowed(r);
    if(!result)result=GTNextGeneration(r,&next.generation);
    if(!result)result=SPRead(r,limits,&state);
    if(!result && !SDReviewSame(reviewed,&state))result=GS_CONFLICT;
    if(!result)result=SLDrop(&state.log,newestIndex,expected,limits,&log,&n);
    if(!result)result=SDStash(r,expected,stateBytes);
    if(!result){
        memset(tip,0,20);result=GSHead(r,&branch,tip);haveTip=!result;
        if(result==GS_NOT_FOUND && branch)result=0;
        if(!result && (!GSValidRef(branch) || strlen(branch)>1024))result=GS_FORMAT;
        if(!result)result=SDGuard(r,"HEAD",stateBytes,&next);
        m=!result?SDMeta(&next,"HEAD"):NULL;bn=branch?strlen(branch):0;
        if(!result && (!m->beforePresent || m->beforeLength!=bn+6 || memcmp(m->before,"ref: ",5) ||
           memcmp(m->before+5,branch,bn) || m->before[bn+5]!='\n'))result=GS_CONFLICT;
        if(!result)result=GSRefKey(branch,key);
        if(!result)result=SDGuard(r,key,stateBytes,&next);
        if(!result){m=SDMeta(&next,key);GBOIDFormat(tip,hex);
            if(m->beforePresent!=haveTip || (haveTip && (m->beforeLength!=bn+42 ||
               memcmp(m->before,branch,bn+1) || memcmp(m->before+bn+1,hex,40) ||
               m->before[bn+41]!='\n')))result=GS_CONFLICT;
        }
    }
    if(!result)result=SDGuard(r,"index",stateBytes,&next);
    if(!result)result=SDGuard(r,"ghclient-map",stateBytes,&next);
    if(!result)result=SDGuard(r,WS_LIST_KEY,stateBytes,&next);
    remain=state.log.count>1;
    if(!result && remain){
        latest=state.log.count-1;if(!newestIndex)--latest;
        memcpy(ref,"refs/stash",11);GBOIDFormat(state.log.entries[latest].after,hex);memcpy(ref+11,hex,40);ref[51]='\n';
    }
    if(!result)result=GSRefKey("refs/stash",key);
    if(!result)result=SDAdd(&next,key,state.ref,state.refLength,state.refPresent,remain?ref:NULL,remain?52:0,remain);
    if(!result)result=SDAdd(&next,SP_LOG_KEY,state.log.bytes,state.log.length,state.logPresent,remain?log:NULL,remain?n:0,remain);
    next.phase=GC_PREPARE;
    if(!result)result=GCEncode(&next,eq,ctx,&wire,&wn);
    if(!result && wn>stateBytes)result=GB_SPACE;
    if(!result)result=SDFresh(r,&next,stateBytes);
    if(!result){GCFree(out);*out=next;GCInit(&next);}
    free(branch);free(log);free(wire);SPStateFree(&state);GCFree(&next);return result;
}
