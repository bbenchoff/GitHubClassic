/* Local catalog uses the same keyboard, scrolling and accessibility as other lists. */
static int RecentRow(void *context,size_t at,char label[256],char name[256],char state[256]) {
    RecentList *list=(RecentList *)context;RecentEntry *entry;FSSpec folder;char volume[32];
    if(at>=list->count)return 0;entry=list->entries+at;
    memcpy(name,entry->name+1,entry->name[0]);name[entry->name[0]]=0;
    memcpy(volume,entry->volume+1,entry->volume[0]);volume[entry->volume[0]]=0;
    snprintf(label,256,"%.80s - %.80s",name,volume);
    snprintf(state,256,RecentResolve(entry,&folder)?"Disk or folder unavailable. Add its folder again, or remove this entry.":"Local repository on %.80s. Open reads local files; no GitHub request.",volume);
    return 1; /* Unavailable entries remain selectable for Remove. Resolve again on Open. */
}
static char *RecentDetails(void *context,size_t at) {(void)context;(void)at;return NULL;}
static int RecentConfirmRemove(const RecentEntry *entry) {
    OperationPrompt prompt;char name[32],volume[32];
    memcpy(name,entry->name+1,entry->name[0]);name[entry->name[0]]=0;
    memcpy(volume,entry->volume+1,entry->volume[0]);volume[entry->volume[0]]=0;
    memset(&prompt,0,sizeof(prompt));prompt.title="Remove Recent Repository";prompt.repository=name;
    prompt.state="Forget this repository's entry on this Macintosh?";prompt.primary="Remove Entry";
    prompt.primaryText="Remove only the bookmark from Local Repositories. Your repository, working files, commits and GitHub copy are kept.";
    prompt.footer="Cancel keeps this entry. You can add the folder again at any time.";prompt.canPrimary=1;
    prompt.labels[0]="Folder";prompt.values[0]=name;prompt.labels[1]="Disk";prompt.values[1]=volume;
    return OperationConfirm(&prompt)==1 && !gDone;
}
static void RecentRepositories(void) {
    RecentList list;NativeChoices choices;DialogPtr d;short hit;FSSpec folder;RecentEntry selected;
    const ChoiceItems items={1,4,5,7,9,10,11};int haveSelection,action;
    if(RecentAccess(&list,NULL,NULL)) {
        Message("Recent Repositories Unavailable","The saved repository list could not be read or is in use. Your repository files are unchanged. Use File > Add Local Repository to open a folder.");return;
    }
    for(;;) {
        memset(&choices,0,sizeof(choices));choices.context=&list;choices.count=list.count;choices.row=RecentRow;
        choices.title="Local Repositories";choices.description="Open a recent repository, or Add Folder. Remove forgets only its list entry.";
        choices.action="Open";choices.noun="Repositories";choices.details=RecentDetails;
        d=GetNewDialog(159,NULL,(WindowPtr)-1);if(!d)return;
        PrepareDialogChrome(d,6,8);DialogText(d,3,choices.description);
        if(!ChoiceCreate(d,&choices,&items,1)){DisposeDialog(d);SetPort(gWindow);return;}
        PrepareDialog(d,1,2);ChoiceRefresh(d);ChoiceEnable(d,11,list.count>0);DrawDialog(d);action=0;
        while(!gDone) {
            hit=0;RunModalDialog(gChoiceFilter,&hit);
            if(hit==2)break;
            if(hit==1 && gChoiceValid){action=1;break;}
            if(hit==11 && gChoiceValid){action=11;break;}
            if(hit==12){action=12;break;}
        }
        haveSelection=gChoiceValid && gChoiceSelected<list.count;
        if(haveSelection)selected=list.entries[gChoiceSelected];
        ChoiceDispose();DisposeDialog(d);SetPort(gWindow);
        if(gDone || !action)return;
        if(action==12){LocalOpenMode(0);return;}
        if(!haveSelection)continue;
        if(action==1) {
            if(RecentResolve(&selected,&folder)) {
                Message("Repository Unavailable","The bookmarked disk or folder is unavailable. Mount its disk, or use Add Folder to choose the repository again. Remove only forgets this list entry; your files are kept.");continue;
            }
            LocalOpenSpec(&folder,0);return;
        }
        if(!RecentConfirmRemove(&selected))continue;
        if(RecentAccess(&list,NULL,&selected)) {Message("Remove Repository Entry","The recent list could not be updated. Repository files and the current window are unchanged.");return;}
    }
}
static void RecentRemoveCurrent(void) {
    RecentList list;RecentEntry entry;
    if(!gLocal){CloseRepository();return;}
    if(RecentForFolder(&gWork.folder,&entry)) {
        Message("Remove Repository Entry","This repository's bookmark could not be identified. Its files and current window are unchanged.");return;
    }
    if(!RecentConfirmRemove(&entry))return;
    if(RecentAccess(&list,NULL,&entry)) {
        Message("Remove Repository Entry","The recent list could not be updated. The current repository remains open; no repository files were removed.");return;
    }
    if(CloseRepository())SetStatus("Repository removed from the recent list. All its files remain on disk.");
}
