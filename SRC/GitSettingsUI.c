/* Native repository settings and a bounded, scrolling TextEdit ignore editor.
   Included after GitMenuUI.c; no Navigation Services or typed volume paths. */
typedef struct {
    char bytes[GE_TEXT_LIMIT];
    short length, start, end;
    int valid;
} GEEditUndo;
typedef struct {
    DialogPtr dialog;
    TEHandle edit;
    ControlHandle scroll;
    Rect well, view;
    GEText text;
    GEEditUndo undo, redo;
    int canSave, saveStopped, active;
} GEEditorUI;
static GEEditorUI gIgnoreEditor;
static GEFile gIgnoreFile;
static int gIgnoreLease;

static int SettingsRelease(void) {
    int result = GEFileFree(&gIgnoreFile);
    if (!result && gIgnoreLease) {
        result = GSMacLeave(&gWork.database);
        if (!result) gIgnoreLease = 0;
    }
    if (result) gLocalBlocked = 1;
    return result;
}
static int IgnoreBreaks(const char *p, size_t n) {
    size_t i;
    int count = 0;
    for (i = 0; i < n; ++i) if (p[i] == '\r') ++count;
    return count;
}
static int IgnoreCanInsert(const char *p, size_t n) {
    TEPtr t = *gIgnoreEditor.edit;
    return n <= GE_TEXT_LIMIT - (size_t)(t->teLength - t->selEnd + t->selStart) &&
           IgnoreBreaks(*t->hText, (size_t)t->teLength) -
               IgnoreBreaks(*t->hText + t->selStart, (size_t)(t->selEnd - t->selStart)) +
               IgnoreBreaks(p, n) <= 1024;
}
static void IgnoreScrollSync(void) {
    TEPtr t = *gIgnoreEditor.edit;
    long height = (long)t->nLines * t->lineHeight;
    int visible = gIgnoreEditor.view.bottom - gIgnoreEditor.view.top, top, maximum;
    if (t->teLength && (*t->hText)[t->teLength - 1] == '\r') height += t->lineHeight;
    maximum = height > visible ? (int)(height - visible) : 0;
    /* TextEdit coordinates and the classic control value are signed shorts. */
    if (maximum > 30000) maximum = 30000;
    top = gIgnoreEditor.view.top - t->destRect.top;
    if (top < 0) top = 0;
    if (top > maximum) {
        TEPinScroll(0, (short)(top - maximum), gIgnoreEditor.edit);
        top = maximum;
    }
    SetControlMaximum(gIgnoreEditor.scroll, (short)maximum);
    SetControlValue(gIgnoreEditor.scroll, (short)top);
}
static void IgnoreMove(short distance) {
    SetPort((GrafPtr)gIgnoreEditor.dialog);
    TEPinScroll(0, distance, gIgnoreEditor.edit);
    IgnoreScrollSync();
}
static pascal void IgnoreScrollAction(ControlHandle control, short part) {
    short delta = 0, line = (*gIgnoreEditor.edit)->lineHeight;
    (void)control;
    if (part == kControlUpButtonPart) delta = line;
    if (part == kControlDownButtonPart) delta = (short)-line;
    if (part == kControlPageUpPart || part == kControlPageDownPart) {
        delta = (short)(gIgnoreEditor.view.bottom - gIgnoreEditor.view.top - line);
        if (part == kControlPageDownPart) delta = (short)-delta;
    }
    if (delta) IgnoreMove(delta);
}
static pascal void IgnoreDraw(DialogPtr dialog, short item) {
    GrafPtr saved;
    RGBColor background, white = {65535, 65535, 65535};
    (void)item;
    GetPort(&saved); SetPort((GrafPtr)dialog);
    GetBackColor(&background); RGBBackColor(&white);
    Color(255, 255, 255); PaintRect(&gIgnoreEditor.well);
    Color(96, 96, 96); FrameRect(&gIgnoreEditor.well);
    Color(0, 0, 0); TEUpdate(&gIgnoreEditor.view, gIgnoreEditor.edit);
    RGBBackColor(&background);
    SetPort(saved);
}
static void IgnoreSnapshot(GEEditUndo *u) {
    TEPtr t = *gIgnoreEditor.edit;
    u->length = t->teLength; u->start = t->selStart; u->end = t->selEnd;
    if (u->length) memcpy(u->bytes, *t->hText, (size_t)u->length);
    u->valid = 1;
}
static void IgnoreCapture(void) {
    IgnoreSnapshot(&gIgnoreEditor.undo); gIgnoreEditor.redo.valid = 0;
}
static void IgnoreUndo(int redo) {
    GEEditUndo *from = redo ? &gIgnoreEditor.redo : &gIgnoreEditor.undo;
    GEEditUndo *to = redo ? &gIgnoreEditor.undo : &gIgnoreEditor.redo;
    if (!from->valid) { SysBeep(1); return; }
    IgnoreSnapshot(to);
    TESetText(from->bytes, from->length, gIgnoreEditor.edit);
    TESetSelect(from->start, from->end, gIgnoreEditor.edit);
    TESelView(gIgnoreEditor.edit); IgnoreScrollSync(); from->valid = 0;
    /* TESetText changes storage without erasing the old drawn lines. */
    InvalRect(&gIgnoreEditor.well);
}
static int IgnoreDirty(void) {
    TEPtr t = *gIgnoreEditor.edit;
    return (size_t)t->teLength != gIgnoreEditor.text.length ||
           (t->teLength && memcmp(*t->hText, gIgnoreEditor.text.text, (size_t)t->teLength));
}
static void IgnorePaste(void) {
    Handle scrap;
    long n, offset;
    size_t i, used = 0;
    char *text;
    unsigned char c;
    n = GetScrap(NULL, 'TEXT', &offset);
    if (n < 0 || n > GE_TEXT_LIMIT * 2L) { SysBeep(1); return; }
    scrap = NewHandle(n);
    if (!scrap) { SysBeep(1); return; }
    if (GetScrap(scrap, 'TEXT', &offset) != n) { DisposeHandle(scrap); SysBeep(1); return; }
    text = (char *)malloc(n ? (size_t)n : 1);
    if (!text) { DisposeHandle(scrap); SysBeep(1); return; }
    HLock(scrap);
    for (i = 0; i < (size_t)n; ++i) {
        c = (unsigned char)(*scrap)[i];
        if (c == '\r') {
            if (i + 1 < (size_t)n && (*scrap)[i + 1] == '\n') ++i;
        } else if (c == '\n') c = '\r';
        else if ((c < 32 && c != '\t') || c == 127) break;
        text[used++] = (char)c;
    }
    HUnlock(scrap); DisposeHandle(scrap);
    if (i == (size_t)n && IgnoreCanInsert(text, used)) {
        IgnoreCapture(); TEDelete(gIgnoreEditor.edit);
        TEInsert(text, (long)used, gIgnoreEditor.edit);
        TESelView(gIgnoreEditor.edit); IgnoreScrollSync();
    } else SysBeep(1);
    free(text);
}
static pascal Boolean IgnoreFilter(DialogPtr dialog, EventRecord *event, short *item) {
    GrafPtr saved;
    Point p;
    ControlHandle control;
    ControlActionUPP action;
    short part, before;
    unsigned char key;
    RGBColor background, white = {65535, 65535, 65535};
    Boolean handled = false;
    GetPort(&saved); SetPort((GrafPtr)dialog); Color(0, 0, 0);
    GetBackColor(&background); RGBBackColor(&white);
    if (event->what == nullEvent && gDone) { *item = 2; handled = true; }
    else if (event->what == nullEvent) TEIdle(gIgnoreEditor.edit);
    else if (event->what == keyDown || event->what == autoKey) {
        key = (unsigned char)(event->message & charCodeMask); handled = true;
        if (event->modifiers & cmdKey) {
            if (key >= 'A' && key <= 'Z') key += 'a' - 'A';
            if (key == 's') { if (gIgnoreEditor.canSave) *item = 1; else SysBeep(1); }
            else if (key == 'q') { gDone = 1; *item = 2; }
            else if (key == '.' || key == 'w') *item = 2;
            else if (key == 'a') TESetSelect(0, 32767, gIgnoreEditor.edit);
            else if (key == 'c' || key == 'x') {
                if (CopyTextSelection(gIgnoreEditor.edit) && key == 'x') {
                    IgnoreCapture(); TEDelete(gIgnoreEditor.edit);
                }
                IgnoreScrollSync();
            } else if (key == 'v') IgnorePaste();
            else if (key == 'z' || key == 'y') IgnoreUndo(key == 'y' || (event->modifiers & shiftKey));
            else SysBeep(1);
        } else if (key == 27) *item = 2;
        else if (key == 3) { if (gIgnoreEditor.canSave) *item = 1; else SysBeep(1); }
        else if (key == 1 || key == 4) IgnoreMove(key == 1 ? 30000 : -30000);
        else if (key == 11 || key == 12) IgnoreMove((short)((key == 11 ? 1 : -1) *
            (gIgnoreEditor.view.bottom - gIgnoreEditor.view.top - (*gIgnoreEditor.edit)->lineHeight)));
        else if (key == 127) {
            IgnoreCapture();
            if ((*gIgnoreEditor.edit)->selStart == (*gIgnoreEditor.edit)->selEnd &&
                (*gIgnoreEditor.edit)->selEnd < (*gIgnoreEditor.edit)->teLength)
                TESetSelect((*gIgnoreEditor.edit)->selStart, (*gIgnoreEditor.edit)->selEnd + 1, gIgnoreEditor.edit);
            TEDelete(gIgnoreEditor.edit); TESelView(gIgnoreEditor.edit); IgnoreScrollSync();
        } else if (key == 8 || key == 13 || key == 9 || key >= 32 || (key >= 28 && key <= 31)) {
            if (key == 8 || key == 13 || key == 9 || key >= 32) {
                if (key != 8 && !IgnoreCanInsert((const char *)&key, 1)) {
                    SysBeep(1); RGBBackColor(&background); SetPort(saved); return true;
                }
                IgnoreCapture();
            }
            TEKey((char)key, gIgnoreEditor.edit); TESelView(gIgnoreEditor.edit); IgnoreScrollSync();
        } else SysBeep(1);
    } else if (event->what == mouseDown) {
        p = event->where; GlobalToLocal(&p);
        if (PtInRect(p, &gIgnoreEditor.well)) {
            TEClick(p, (event->modifiers & shiftKey) != 0, gIgnoreEditor.edit);
            IgnoreScrollSync(); handled = true;
        } else {
            part = FindControl(p, (WindowPtr)dialog, &control);
            if (part && control == gIgnoreEditor.scroll) {
                before = GetControlValue(control);
                if (part == kControlIndicatorPart) {
                    TrackControl(control, p, NULL);
                    IgnoreMove((short)(before - GetControlValue(control)));
                } else {
                    action = NewControlActionProc(IgnoreScrollAction);
                    if (action) {
                        TrackControl(control, p, action);
                        DisposeRoutineDescriptor((UniversalProcPtr)action);
                    }
                }
                handled = true;
            }
        }
    }
    RGBBackColor(&background);
    if (!handled && event->what != nullEvent) handled = NativeDialogFilter(dialog, event, item);
    SetPort(saved); return handled;
}
static void IgnoreActive(int active) {
    if (active != gIgnoreEditor.active) {
        SetPort((GrafPtr)gIgnoreEditor.dialog);
        if (active) TEActivate(gIgnoreEditor.edit);
        else TEDeactivate(gIgnoreEditor.edit);
        gIgnoreEditor.active = active;
    }
}
static void IgnoreMenus(void) {
    MenuHandle menu;
    short mid, number, command;
    TEPtr t = *gIgnoreEditor.edit;
    int allowed, selection = t->selStart != t->selEnd;
    for (mid = 128; mid <= 134; ++mid) {
        menu = GetMenuHandle(mid);
        if (!menu) continue;
        for (number = 1; number <= CountMItems(menu); ++number) {
            command = MenuCommand(mid, number);
            allowed = command == MC_CLOSE_REPOSITORY || command == MC_QUIT ||
                      (command == MC_UNDO && gIgnoreEditor.undo.valid) ||
                      (command == MC_REDO && gIgnoreEditor.redo.valid) ||
                      ((command == MC_CUT || command == MC_COPY) && selection) ||
                      command == MC_PASTE || command == MC_SELECT_ALL;
            if (mid == 128 && number > 2) allowed = 1; /* Desk accessories. */
            if (allowed) EnableItem(menu, number); else DisableItem(menu, number);
        }
    }
}
static void IgnoreMenuChoice(long choice, short *hit) {
    short mid = (short)(choice >> 16), number = (short)choice;
    char key = 0;
    EventRecord event;
    Str255 name;
    if (mid == 128 && number > 2) {
        GetMenuItemText(GetMenuHandle(128), number, name); OpenDeskAcc(name);
    } else switch (MenuCommand(mid, number)) {
        case MC_CLOSE_REPOSITORY: key = 'w'; break;
        case MC_QUIT: key = 'q'; break;
        case MC_UNDO: key = 'z'; break;
        case MC_REDO: key = 'y'; break;
        case MC_CUT: key = 'x'; break;
        case MC_COPY: key = 'c'; break;
        case MC_PASTE: key = 'v'; break;
        case MC_SELECT_ALL: key = 'a'; break;
    }
    if (key) {
        memset(&event, 0, sizeof(event)); event.what = keyDown;
        event.message = key; event.modifiers = cmdKey;
        IgnoreFilter(gIgnoreEditor.dialog, &event, hit);
    }
    HiliteMenu(0);
}
/* System7 movable modal dialogs use DialogSelect, not ModalDialog. Keep
   repository commands/documents blocked, but yield and allow process switches. */
static void IgnoreRun(short *hit) {
    EventRecord event;
    WindowPtr window;
    DialogPtr selected;
    short part, item;
    Rect bounds;
    ++gModalDepth;
    while (!*hit) {
        if (!WaitNextEvent(everyEvent, &event, 6, NULL)) event.what = nullEvent;
        if (gDone) { *hit = 2; break; }
        /* This movable editor owns its event loop, so it does not pass idle
           events through NativeDialogFilter's display-change containment. */
        if (event.what == nullEvent) KeepDialogOnScreen(gIgnoreEditor.dialog);
        if (event.what == kHighLevelEvent) {
            AEProcessAppleEvent(&event);
            /* Reopening the app selects its main window in the shared event
               handler. Keep this movable modal editor in front instead. */
            if (!gDone) SelectWindow((WindowPtr)gIgnoreEditor.dialog);
            continue;
        }
        if (event.what == osEvt) {
            if ((unsigned char)(event.message >> 24) == suspendResumeMessage)
                IgnoreActive((event.message & resumeFlag) != 0);
            continue;
        }
        if (event.what == updateEvt || event.what == activateEvt) {
            window = (WindowPtr)event.message;
            if (window == (WindowPtr)gIgnoreEditor.dialog) {
                if (event.what == activateEvt) IgnoreActive((event.modifiers & activeFlag) != 0);
                DialogSelect(&event, &selected, &item);
            } else if (event.what == updateEvt) Event(&event);
            continue;
        }
        if (event.what == mouseDown) {
            part = FindWindow(event.where, &window);
            if (part == inMenuBar) {
                IgnoreMenus(); IgnoreMenuChoice(MenuSelect(event.where), hit); continue;
            }
            if (part == inSysWindow) { SystemClick(&event, window); continue; }
            if (window != (WindowPtr)gIgnoreEditor.dialog) {
                SysBeep(1); continue;
            }
            if (part == inDrag) {
                bounds = qd.screenBits.bounds; bounds.top += 20;
                DragWindow(window, event.where, &bounds);
                KeepDialogOnScreen(gIgnoreEditor.dialog); continue;
            }
            if (part != inContent) continue;
            if (FrontWindow() != window) { SelectWindow(window); continue; }
        }
        if (FrontWindow() != (WindowPtr)gIgnoreEditor.dialog || !gIgnoreEditor.active) continue;
        if (IgnoreFilter(gIgnoreEditor.dialog, &event, hit)) continue;
        item = 0;
        if (DialogSelect(&event, &selected, &item) && selected == gIgnoreEditor.dialog) *hit = item;
    }
    --gModalDepth;
}
static int IgnoreConfirm(short resource, short defaultItem, int saveEnabled) {
    DialogPtr d = GetNewDialog(resource, NULL, (WindowPtr)-1);
    short hit = 0, kind;
    Handle item;
    Rect r;
    char message[256],repository[256];
    if (!d) return 2;
    if(resource==145)PrepareDialogChrome(d,4,5);
    else {
        PrepareDialogChrome(d,5,6);memcpy(repository,gWork.folder.name+1,gWork.folder.name[0]);repository[gWork.folder.name[0]]=0;
        snprintf(message,sizeof(message),"Save the .gitignore edits in %.63s before quitting?\r\rSave writes these rules. Don't Save keeps the disk copy. Cancel returns to the editor.",repository);
        DialogText(d,4,message);
    }
    if (!saveEnabled) {
        GetDialogItem(d, 1, &kind, &item, &r); HiliteControl((ControlHandle)item, 255);
    }
    PrepareDialog(d, defaultItem, 2);
    while (hit != 1 && hit != 2 && (resource != 146 || hit != 3)) RunModalDialog(gDialogFilter, &hit);
    DisposeDialog(d); SetPort((GrafPtr)gIgnoreEditor.dialog); return hit;
}
static int IgnoreSameSpec(const FSSpec *a, const FSSpec *b) {
    return a->vRefNum == b->vRefNum && a->parID == b->parID && a->name[0] == b->name[0] &&
           !memcmp(a->name + 1, b->name + 1, a->name[0]);
}
static int IgnoreSave(void) {
    unsigned char *bytes = NULL;
    size_t n = 0;
    int result, changed, phase = GE_PREPARING, closed, haveTemporary = 0;
    FSSpec current, temporary;
    char text[768], leaf[32];
    Handle control;
    short kind;
    Rect r;
    OSErr error = noErr;
    TEPtr t = *gIgnoreEditor.edit;
    HLock(t->hText);
    result = GETextEncode(&gIgnoreEditor.text, *t->hText, (size_t)t->teLength, 0, &bytes, &n, &changed);
    HUnlock((*gIgnoreEditor.edit)->hText);
    if (result == GE_NEWLINES) {
        if (IgnoreConfirm(145, 2, 1) != 1) return 0;
        t = *gIgnoreEditor.edit;
        HLock(t->hText);
        result = GETextEncode(&gIgnoreEditor.text, *t->hText, (size_t)t->teLength, 1, &bytes, &n, &changed);
        HUnlock((*gIgnoreEditor.edit)->hText);
    }
    if (result) {
        Message("Ignored Files", "These edits could not be encoded. Your file was not replaced. Try copying the text before closing this window.");
        SetPort((GrafPtr)gIgnoreEditor.dialog); return 0;
    }
    if (!changed && gIgnoreFile.present) { free(bytes); return 1; }
    result = GSMacEnter(&gWork.database, 0);
    if (result) error = gWork.database.lastError;
    if (!result) {
        gIgnoreLease = 1;
        result = GEIgnoreFile(&gWork.root, &gWork.repository, &current, &error);
        if (!result && !IgnoreSameSpec(&current, &gIgnoreFile.file)) result = GS_CONFLICT;
        if (!result) {
            result = GEFileSave(&gIgnoreFile, &gWork.database, bytes, n);
            error = gIgnoreFile.lastError;
        }
        phase = gIgnoreFile.phase; haveTemporary = gIgnoreFile.haveTemporary;
        temporary = gIgnoreFile.temporary;
    }
    free(bytes); closed = SettingsRelease();
    if (!result) result = closed;
    if (!result) return 1;
    /* Keep the edited text available for Copy after stale/ambiguous saves. A
       consumed snapshot must not silently become a fresh overwrite attempt. */
    gIgnoreEditor.canSave = 0;
    gIgnoreEditor.saveStopped = 1;
    GetDialogItem(gIgnoreEditor.dialog, 1, &kind, &control, &r);
    HiliteControl((ControlHandle)control, 255);
    if (haveTemporary) { memcpy(leaf, temporary.name + 1, temporary.name[0]); leaf[temporary.name[0]] = 0; }
    else leaf[0] = 0;
    snprintf(text, sizeof(text), "%s\r\rError %d (Mac %d). %s%s%s\r\rCopy any edits you want to keep, then Cancel and reopen this editor.%s",
             phase >= GE_PUBLISHED ? "The new file was published, but verification or cleanup failed."
             : phase == GE_ATTEMPTED ? "The save may already be on disk; Classic Github could not confirm its result."
                                    : "Classic Github did not replace the ignore file. It may have changed while this window was open, or the disk may be unavailable.",
             result, error, haveTemporary ? "Keep the temporary file " : "", leaf,
             haveTemporary ? " in this repository until you have checked both versions." : "",
             closed ? " The disk could not close its files. Use Refresh to retry closing them, or quit Classic Github." : "");
    GetDialogItem(gIgnoreEditor.dialog,3,&kind,&control,&r);
    InvalRect(&r);
    Message("Ignored Files", text); SetPort((GrafPtr)gIgnoreEditor.dialog); return 0;
}
static pascal void IgnorePanelDraw(DialogPtr dialog,short number) {
    GrafPtr saved;PenState pen;RGBColor foreground;Rect r;Handle item;short kind,font,size;Style face;char name[256],label[300];
    GetPort(&saved);SetPort((GrafPtr)dialog);font=((GrafPtr)dialog)->txFont;size=((GrafPtr)dialog)->txSize;face=((GrafPtr)dialog)->txFace;
    GetPenState(&pen);GetForeColor(&foreground);PenNormal();GetDialogItem(dialog,number,&kind,&item,&r);
    Box(r.left,r.top,r.right,r.bottom,255,255,255);
    if(number==3) {
        memcpy(name,gWork.folder.name+1,gWork.folder.name[0]);name[gWork.folder.name[0]]=0;
        snprintf(label,sizeof(label),"%s / .gitignore",name);FitText(r.left,(short)(r.top+13),label,gGeneva,12,(short)(r.right-r.left),0,0,0);
        Text(r.left,(short)(r.top+31),gIgnoreEditor.saveStopped?
            "Save stopped. Copy your edits, Cancel, then reopen.":gIgnoreFile.present?
            "Edit local rules. Tracked files are unaffected.":
            "New local rules. Tracked files are unaffected.",gGeneva,9,64,64,64);
    } else {
        Text(r.left,(short)(r.top+11),"One pattern per line; # comments, ! exceptions.",gGeneva,9,64,64,64);
        Text(r.left,(short)(r.top+25),"Command-S saves. Return starts a new rule.",gGeneva,9,64,64,64);
    }
    RGBForeColor(&foreground);SetPenState(&pen);TextFont(font);TextSize(size);TextFace(face);SetPort(saved);
}
static void EditIgnoredFiles(void) {
    FSSpec file;
    OSErr error;
    int result, saved = 0;
    DialogPtr d;
    Handle item;
    short kind, hit = 0;
    Rect r, scroll;
    UserItemUPP draw = NULL,panel = NULL;
    Str255 closeTitle;
    MenuHandle fileMenu;
    FontInfo metrics;
    char message[256];
    result = SettingsRelease();
    if (!result) result = GEIgnoreFile(&gWork.root, &gWork.repository, &file, &error);
    if (!result) result = GEFileOpen(&gIgnoreFile, &file);
    memset(&gIgnoreEditor, 0, sizeof(gIgnoreEditor)); GETextInit(&gIgnoreEditor.text);
    if (!result) result = GETextOpen(&gIgnoreEditor.text, gIgnoreFile.data, gIgnoreFile.length);
    if (!result && IgnoreBreaks((const char *)gIgnoreEditor.text.text, gIgnoreEditor.text.length) > 1024)
        result = GB_SPACE;
    if (result) {
        snprintf(message, sizeof(message), "%s\r\rYour file has not been replaced. Error %d.",
                 result == GE_ENCODING ? "This file contains characters that the classic editor cannot display."
                 : result == GB_SPACE ? "This file is too large for this editor."
                 : "The ignore file could not be opened. Check for a conflicting name, alias, symlink or unavailable disk.", result);
        SettingsRelease(); GETextFree(&gIgnoreEditor.text); Message("Ignored Files", message); return;
    }
    d = GetNewDialog(144, NULL, (WindowPtr)-1); gIgnoreEditor.dialog = d;
    if (!d) { SettingsRelease(); GETextFree(&gIgnoreEditor.text); return; }
    if(!PrepareDialogChrome(d,6,7))goto done;
    SetPort((GrafPtr)d); GetDialogItem(d, 4, &kind, &item, &r);
    gIgnoreEditor.well = r; InsetRect(&r, 4, 3); gIgnoreEditor.view = r;
    TextFont(gMonaco); TextSize(9); TextFace(0); GetFontInfo(&metrics);
    /* The CR and byte limits plus these font metrics keep wrapped TextEdit
       geometry inside its signed-short coordinate range. Never truncate. */
    if (metrics.widMax < 1 || metrics.widMax > 12 ||
        metrics.ascent + metrics.descent + metrics.leading < 1 ||
        metrics.ascent + metrics.descent + metrics.leading > 14) goto done;
    gIgnoreEditor.edit = TENew(&r, &r); TextFont(0); TextSize(0);
    scroll = gIgnoreEditor.well; scroll.left = scroll.right - 1; scroll.right += 15;
    gIgnoreEditor.scroll = NewControl((WindowPtr)d, &scroll, "\p", true, 0, 0, 0, scrollBarProc, 0);
    draw = NewUserItemProc(IgnoreDraw);
    panel = NewUserItemProc(IgnorePanelDraw);
    if (!gIgnoreEditor.edit || !gIgnoreEditor.scroll || !draw || !panel) goto done;
    (*gIgnoreEditor.edit)->txFont = gMonaco; (*gIgnoreEditor.edit)->txSize = 9;
    TECalText(gIgnoreEditor.edit); TEAutoView(true, gIgnoreEditor.edit);
    TESetText(gIgnoreEditor.text.text, (long)gIgnoreEditor.text.length, gIgnoreEditor.edit);
    TESetSelect(0, 0, gIgnoreEditor.edit);
    if (gCommitField) TEDeactivate(gCommitField == 1 ? gSummaryEdit : gDescriptionEdit);
    IgnoreActive(1);
    SetDialogItem(d, 4, kind, (Handle)draw, &gIgnoreEditor.well);
    GetDialogItem(d,3,&kind,&item,&r);SetDialogItem(d,3,kind,(Handle)panel,&r);
    GetDialogItem(d,5,&kind,&item,&r);SetDialogItem(d,5,kind,(Handle)panel,&r);
    PrepareDialog(d, 1, 2); gIgnoreEditor.canSave = 1; IgnoreScrollSync();
    fileMenu = GetMenuHandle(129); GetMenuItemText(fileMenu, 9, closeTitle);
    SetMenuItemText(fileMenu, 9, "\pClose Editor"); IgnoreMenus();
    InvalRect(&((WindowPtr)d)->portRect);
    for (;;) {
        hit = 0; IgnoreRun(&hit);
        if (hit == 1 && gIgnoreEditor.canSave) { if (IgnoreSave()) { saved = 1; break; } }
        if (hit == 2) {
            if (gDone && IgnoreDirty()) {
                gDone = 0;
                hit = IgnoreConfirm(146, gIgnoreEditor.canSave ? 1 : 2, gIgnoreEditor.canSave);
                if (hit == 2) { gDone = 0; continue; }
                if (hit == 1 && !IgnoreSave()) continue;
                saved = hit == 1; gDone = 1;
            }
            break;
        }
    }
    SetMenuItemText(fileMenu, 9, closeTitle); UpdateMenus();
    if (GetMenuHandle(128)) EnableItem(GetMenuHandle(128), 1);
done:
    if (gIgnoreEditor.edit) { TEDeactivate(gIgnoreEditor.edit); TEDispose(gIgnoreEditor.edit); }
    DisposeDialog(d);
    if (draw) DisposeRoutineDescriptor((UniversalProcPtr)draw);
    if (panel) DisposeRoutineDescriptor((UniversalProcPtr)panel);
    GETextFree(&gIgnoreEditor.text); SetPort(gWindow);
    if (gCommitField) TEActivate(gCommitField == 1 ? gSummaryEdit : gDescriptionEdit);
    result = SettingsRelease();
    if (result) {
        SetStatus("The ignore file could not close. Try Refresh to retry closing it, or quit Classic Github.");
        LocalEditState();
    } else if (!gDone && (saved || gIgnoreEditor.saveStopped)) {
        LocalRefresh();
        if (gIgnoreEditor.saveStopped && !gLocalBlocked)
            SetStatus("A save stopped with an error. Check the ignore file and any retained temporary before continuing.");
    } else if (!gDone) SetStatus("Ignore editor closed. Unsaved edits were not applied.");
    InvalRect(&gWindow->portRect);
}
static void RepositorySettings(void) {
    DialogPtr d;
    Handle item;
    Rect r;
    short hit, kind;
    if (!gLocal) return;
    if (SettingsRelease()) {
        Message("Repository Settings", "The previous save could not close its files. Try Refresh or quit Classic Github.");
        return;
    }
    for (;;) {
        if (gDone) break;
        d = GetNewDialog(143, NULL, (WindowPtr)-1);
        if (!d) break;
        NetworkHeader();
        PrepareSettingsArt(d);
        GetDialogItem(d, 2, &kind, &item, &r); HiliteControl((ControlHandle)item, gLocalBlocked ? 255 : 0);
        GetDialogItem(d, 9, &kind, &item, &r); HiliteControl((ControlHandle)item, gLocalBlocked ? 255 : 0);
        PrepareDialog(d, 1, 1); hit = 0;
        while (!gDone && hit != 1 && hit != 2 && hit != 3 && hit != 9) RunModalDialog(gDialogFilter, &hit);
        DisposeDialog(d); SetPort(gWindow);
        if (gDone || hit == 1) break;
        if (hit == 2 && !gLocalBlocked) LocalAuthor(1);
        if (hit == 3) EditIgnoredFiles();
        if (hit == 9 && !gLocalBlocked) NetworkUpstream();
        if (SettingsRelease()) break;
    }
    SetPort(gWindow); InvalRect(&gWindow->portRect);
}
