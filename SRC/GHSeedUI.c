/* First-launch user-assisted randomness, entirely on the Macintosh. */
#include <Timer.h>
static GHSeedCollector *gSeedCollector;
static UserItemUPP gSeedArt;
static ModalFilterUPP gSeedFilter;
static unsigned long gSeedPaintTick;
static short gSeedPaintPercent=-1;

static unsigned long SeedClock(void) {
    UnsignedWide now;Microseconds(&now);return now.lo;
}
static pascal void SeedDraw(DialogPtr dialog,short number) {
    GrafPtr previous;PenState pen;RGBColor foreground,background,white={65535,65535,65535};
    short font,size;Style face;unsigned short percent;char label[96];
    (void)number;if(!gSeedCollector)return;
    GetPort(&previous);SetPort((GrafPtr)dialog);GetPenState(&pen);
    GetForeColor(&foreground);GetBackColor(&background);
    font=((GrafPtr)dialog)->txFont;size=((GrafPtr)dialog)->txSize;face=((GrafPtr)dialog)->txFace;
    PenNormal();RGBBackColor(&white);Box(24,138,496,216,255,255,255);
    percent=GHSProgress(gSeedCollector,SeedClock());
    snprintf(label,sizeof(label),"Preparing this Macintosh: %u%%",(unsigned)percent);
    Text(26,151,label,gGeneva,12,0,0,0);
    Box(26,164,494,182,255,255,255);Color(96,96,96);
    MoveTo(26,164);LineTo(493,164);LineTo(493,181);LineTo(26,181);LineTo(26,164);
    if(percent)Box(28,166,(short)(28+464UL*percent/100),180,39,104,208);
    Text(26,204,gSeedCollector->moves>=GHS_MOVES && gSeedCollector->cells>=GHS_CELLS?
         "Pointer activity: ready":"Pointer activity: move around the window",gGeneva,9,64,64,64);
    Text(292,204,gSeedCollector->keys>=GHS_KEYS && gSeedCollector->distinctKeys>=GHS_DISTINCT_KEYS?
         "Keyboard activity: ready":"Keyboard activity: type random words",gGeneva,9,64,64,64);
    RGBForeColor(&foreground);RGBBackColor(&background);SetPenState(&pen);
    TextFont(font);TextSize(size);TextFace(face);SetPort(previous);
}
static void SeedRefresh(DialogPtr dialog) {
    short kind;Handle item;Rect bounds;unsigned long tick=TickCount();unsigned short percent;
    percent=GHSProgress(gSeedCollector,SeedClock());
    if(gSeedPaintPercent==(short)percent && tick-gSeedPaintTick<6)return;
    gSeedPaintTick=tick;gSeedPaintPercent=(short)percent;
    GetDialogItem(dialog,1,&kind,&item,&bounds);HiliteControl((ControlHandle)item,percent==100?0:255);
    SeedDraw(dialog,6);
}
static pascal Boolean SeedFilter(DialogPtr dialog,EventRecord *event,short *item) {
    GrafPtr previous;Point point;unsigned long now;unsigned char cell,key;
    if(!gSeedCollector)return NativeDialogFilter(dialog,event,item);
    if(event->what==nullEvent) {
        GetPort(&previous);SetPort((GrafPtr)dialog);GetMouse(&point);SetPort(previous);
        if(point.h>=0 && point.h<520 && point.v>=0 && point.v<330 && FrontWindow()==(WindowPtr)dialog) {
            cell=(unsigned char)((point.v*8/330)*8+point.h*8/520);
            now=SeedClock();GHSPointer(gSeedCollector,now,TickCount(),point.h,point.v,cell);
        }
        SeedRefresh(dialog);
    } else if(event->what==keyDown && !(event->modifiers&(cmdKey|controlKey|optionKey))) {
        key=(unsigned char)(event->message&charCodeMask);
        if(key>=32 && key!=127) {
            GHSKey(gSeedCollector,SeedClock(),TickCount(),(unsigned char)((event->message&keyCodeMask)>>8),event->modifiers);
            SeedRefresh(dialog);*item=0;return true;
        }
    } else if(event->what==autoKey && !(event->modifiers&cmdKey)) {*item=0;return true;}
    if(gSeedCollector->failed){*item=2;return true;}
    return NativeDialogFilter(dialog,event,item);
}
/* 0: seed returned in RAM; 1: explicit provisioning-file import; GV_CANCEL:
   no setup published. The caller alone owns encrypted durable publication. */
static int StartupCollectSeed(unsigned char output[64]) {
    DialogPtr dialog=NULL;short kind,hit=0;Handle item;Rect bounds;int result=GV_CANCEL;
    GVClear(output,64);
    if(gSeedCollector)return SC_BAD;
    gSeedCollector=(GHSeedCollector *)calloc(1,sizeof(*gSeedCollector));
    if(!gSeedCollector)return GV_MEMORY;
    result=GHSInit(gSeedCollector,SeedClock());if(result)goto done;
    result=GV_MEMORY;
    if(!gSeedArt)gSeedArt=NewUserItemProc(SeedDraw);
    if(!gSeedFilter)gSeedFilter=NewModalFilterProc(SeedFilter);
    if(!gSeedArt || !gSeedFilter)goto done;
    dialog=GetNewDialog(160,NULL,(WindowPtr)-1);if(!dialog)goto done;
    if(!PrepareDialogChrome(dialog,4,7))goto done;
    GetDialogItem(dialog,6,&kind,&item,&bounds);
    SetDialogItem(dialog,6,kind,(Handle)gSeedArt,&bounds);
    PrepareDialog(dialog,1,2);gSeedPaintPercent=-1;gSeedPaintTick=0;
    SeedRefresh(dialog);DrawDialog(dialog);result=GV_CANCEL;
    while(!gDone) {
        hit=0;RunModalDialog(gSeedFilter,&hit);
        if(gSeedCollector->failed){result=SSL_NO_SEED;break;}
        if(hit==2)break;
        if(hit==3){result=1;break;}
        if(hit==1 && GHSProgress(gSeedCollector,SeedClock())==100) {
            result=GHSFinish(gSeedCollector,SeedClock(),output);break;
        }
    }
done:
    if(dialog)DisposeDialog(dialog);
    GHSClear(gSeedCollector);free(gSeedCollector);gSeedCollector=NULL;
    if(result)GVClear(output,64);
    SetPort(gWindow);return result;
}
