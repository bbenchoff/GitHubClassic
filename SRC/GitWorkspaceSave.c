#include "GitWorkspaceSave.h"
#include "GitHistory.h"
#include "GitCheckoutSession.h"
#include <stdlib.h>
#include <string.h>

static GBWord WSWord(const unsigned char *p) {
    return ((GBWord)p[0]<<24)|((GBWord)p[1]<<16)|((GBWord)p[2]<<8)|p[3];
}
static void WSPut(unsigned char *p,GBWord n) {
    p[0]=(unsigned char)(n>>24);p[1]=(unsigned char)(n>>16);
    p[2]=(unsigned char)(n>>8);p[3]=(unsigned char)n;
}
static void WSHash(const void *p,size_t n,unsigned char out[20]) {
    GBSHA1 h;GBSHA1Start(&h);GBSHA1Update(&h,p,n);GBSHA1Finish(&h,out);
}
static void *WSCopy(const void *p,size_t n) {
    void *out=malloc(n?n:1);if(out && n)memcpy(out,p,n);return out;
}
static int WSZero(const void *p,size_t n) {
    const unsigned char *s=p;while(n--)if(*s++)return 0;return 1;
}
void WSInit(WSRecord *r) {memset(r,0,sizeof(*r));}
void WSFree(WSRecord *r) {
    size_t i;GCFree(&r->discard);GPFree(&r->aliases);
    for(i=0;i<r->pathCount;++i)free(r->paths[i]);
    free(r->directories);free(r->paths);free(r->original);WSInit(r);
}
void WSPlanInit(WSPlan *p) {memset(p,0,sizeof(*p));}
void WSPlanFree(WSPlan *p) {WSFree(&p->record);GCFree(&p->transaction);WSPlanInit(p);}
static const GCMetadata *WSMeta(const GCTransaction *t,const char *key) {
    size_t i;for(i=0;i<t->metadataCount;++i)if(t->metadata[i].path && !strcmp(t->metadata[i].path,key))return t->metadata+i;
    return NULL;
}
static int WSSameGuard(const GCMetadata *m) {
    return m && m->beforePresent==m->afterPresent && m->beforeLength==m->afterLength &&
        (!m->beforeLength || (m->before && m->after)) &&
        (!m->beforeLength || !memcmp(m->before,m->after,m->beforeLength));
}
static int WSBranch(const GCTransaction *t,char **branch,unsigned char tip[20],int *present) {
    const GCMetadata *head=WSMeta(t,"HEAD"),*ref;
    char key[64],hex[41],*name;size_t n;int result;
    *branch=NULL;
    if(!WSSameGuard(head) || !head->beforePresent || head->beforeLength<17 ||
        memcmp(head->before,"ref: ",5) || head->before[head->beforeLength-1]!='\n')return GS_FORMAT;
    n=head->beforeLength-6;name=(char *)malloc(n+1);if(!name)return GB_MEMORY;
    memcpy(name,head->before+5,n);name[n]=0;
    result=memchr(name,0,n)?GS_FORMAT:GSRefKey(name,key);
    if(!result && !GSValidRef(name))result=GS_FORMAT;
    ref=!result?WSMeta(t,key):NULL;
    if(!result && !WSSameGuard(ref))result=GS_FORMAT;
    if(!result) {
        *present=ref->beforePresent;memset(tip,0,20);
        if(*present) {
            if(ref->beforeLength!=n+42 || memcmp(ref->before,name,n+1) || ref->before[n+41]!='\n')result=GS_FORMAT;
            else {memcpy(hex,ref->before+n+1,40);hex[40]=0;result=GBOIDParse(hex,tip);}
        }
    }
    if(result)free(name);else *branch=name;return result;
}
static int WSPaths(const GQProtection *paths,const WSLimits *l) {
    size_t i;
    if(!paths || paths->changed || paths->count>l->paths || (paths->count && !paths->paths))return GB_BAD;
    for(i=0;i<paths->count;++i)
        if(!GIValidPath(paths->paths[i]) || strlen(paths->paths[i])>l->pathBytes ||
            !strcmp(paths->paths[i],GI_MAC_NAMESPACE) ||
            !strncmp(paths->paths[i],GI_MAC_NAMESPACE "/",sizeof(GI_MAC_NAMESPACE)) ||
            (i && strcmp(paths->paths[i-1],paths->paths[i])>=0))return GB_BAD;
    return 0;
}
static int WSHas(const GQProtection *paths,const char *path) {
    size_t lo=0,hi=paths->count,m;int cmp;
    while(lo<hi){m=lo+(hi-lo)/2;cmp=strcmp(path,paths->paths[m]);if(!cmp)return 1;if(cmp<0)hi=m;else lo=m+1;}
    return 0;
}
static int WSLimitValid(const WSLimits *l) {
    return l && l->stateBytes>=160 && l->files && l->paths && l->pathBytes &&
        l->forkBytes && l->workBytes && l->entries && l->files<=(size_t)-1/4 && l->stateBytes<=0xffffffffUL;
}
static int WSShape(const WSRecord *r,const WSLimits *l) {
    GQProtection p;char *branch=NULL;unsigned char tip[20];size_t i;int present,result;
    if(!r || !WSLimitValid(l) || WSZero(r->binding,32) || !r->discard.generation ||
        r->discard.metadataCount!=4 || !r->discard.metadata ||
        r->discard.fileCount>l->files || r->discard.directoryCount>l->files || r->discard.createdDirectoryCount ||
        r->discard.phase!=GC_PREPARE || r->discard.rollbackFrom ||
        (r->haveBase!=0 && r->haveBase!=1) || (r->haveUntracked!=0 && r->haveUntracked!=1) ||
        (r->haveBase?WSZero(r->base,20):!WSZero(r->base,20)) ||
        (r->haveUntracked?WSZero(r->untracked,20):!WSZero(r->untracked,20)) ||
        WSZero(r->staged,20) || WSZero(r->working,20) || WSMeta(&r->discard,WS_LIST_KEY))return GS_FORMAT;
    if((r->completeDirectories!=0 && r->completeDirectories!=1) ||
        (!r->completeDirectories && r->directories) ||
        (r->completeDirectories && r->discard.directoryCount && !r->directories))return GS_FORMAT;
    for(i=0;r->completeDirectories && i<r->discard.directoryCount;++i)
        if(!(r->directories[i].attributes&16))return GS_FORMAT;
    p.paths=(const char *const *)r->paths;p.count=r->pathCount;p.changed=0;
    result=WSPaths(&p,l);
    if(!result)result=WSBranch(&r->discard,&branch,tip,&present);
    if(!result && (present!=r->haveBase || memcmp(tip,r->base,20)))result=GS_FORMAT;
    free(branch);return result;
}
int WSEncode(const WSRecord *r,const WSLimits *l,GPEqual eq,void *ctx,unsigned char **out,size_t *length) {
    unsigned char *plan=NULL,*map=NULL,*p=NULL;size_t pn=0,mn=0,n=160,at,i,a;int result;
    if(!out || !length || !eq)return GB_BAD;
    *out=NULL;*length=0;
    result=WSShape(r,l);
    if(!result)result=GCEncode(&r->discard,eq,ctx,&plan,&pn);
    if(!result)result=GPEncode(&r->aliases,eq,ctx,&map,&mn);
    if(!result && (pn>l->stateBytes || mn>l->stateBytes || pn>l->stateBytes-160 || mn>l->stateBytes-160-pn))result=GB_SPACE;
    if(!result)n+=pn+mn;
    for(i=0;!result && i<r->pathCount;++i) {
        a=strlen(r->paths[i]);if(n>l->stateBytes || l->stateBytes-n<4 || a>l->stateBytes-n-4)result=GB_SPACE;
        else n+=4+a;
    }
    if(!result && r->completeDirectories) {
        if(r->discard.directoryCount>(l->stateBytes-n)/48)result=GB_SPACE;
        else n+=r->discard.directoryCount*48;
    }
    if(!result && (n>0xffffffffUL || pn>0xffffffffUL || mn>0xffffffffUL || r->pathCount>0xffffffffUL))result=GB_SPACE;
    if(!result){p=(unsigned char *)malloc(n);if(!p)result=GB_MEMORY;}
    if(!result) {
        memcpy(p,r->completeDirectories?"GHSAVE02":"GHSAVE01",8);memcpy(p+8,r->binding,32);WSPut(p+40,r->discard.generation);
        WSPut(p+44,(GBWord)(r->haveBase|(r->haveUntracked<<1)));
        memcpy(p+48,r->base,20);memcpy(p+68,r->staged,20);memcpy(p+88,r->working,20);memcpy(p+108,r->untracked,20);
        WSPut(p+128,(GBWord)pn);WSPut(p+132,(GBWord)mn);WSPut(p+136,(GBWord)r->pathCount);
        at=140;memcpy(p+at,plan,pn);at+=pn;memcpy(p+at,map,mn);at+=mn;
        for(i=0;i<r->pathCount;++i){a=strlen(r->paths[i]);WSPut(p+at,(GBWord)a);at+=4;memcpy(p+at,r->paths[i],a);at+=a;}
        for(i=0;r->completeDirectories && i<r->discard.directoryCount;++i) {
            const WSDirectory *d=r->directories+i;
            WSPut(p+at,d->attributes);WSPut(p+at+4,d->created);WSPut(p+at+8,d->modified);WSPut(p+at+12,d->backup);
            memcpy(p+at+16,d->finderInfo,32);at+=48;
        }
        WSHash(p,at,p+at);*out=p;*length=n;
    }
    free(plan);free(map);return result;
}
int WSParse(const void *data,size_t n,const WSLimits *l,GPEqual eq,void *ctx,WSRecord *out) {
    const unsigned char *p=data;WSRecord r;unsigned char hash[20];size_t pn,mn,count,at,i,a;GBWord flags;int result=0;
    if(!p || !out || !eq || !WSLimitValid(l))return GB_BAD;
    if(n<160 || n>l->stateBytes || (memcmp(p,"GHSAVE01",8) && memcmp(p,"GHSAVE02",8)))return GS_FORMAT;
    WSHash(p,n-20,hash);if(memcmp(hash,p+n-20,20))return GB_CHECKSUM;
    pn=WSWord(p+128);mn=WSWord(p+132);count=WSWord(p+136);flags=WSWord(p+44);
    if((flags&~3U) || pn>n-160 || mn>n-160-pn || count>l->paths || count>(n-160-pn-mn)/5 ||
        count>(size_t)-1/sizeof(*r.paths))return GS_FORMAT;
    WSInit(&r);r.completeDirectories=!memcmp(p,"GHSAVE02",8);
    memcpy(r.binding,p+8,32);r.haveBase=(int)(flags&1);r.haveUntracked=(int)((flags>>1)&1);
    memcpy(r.base,p+48,20);memcpy(r.staged,p+68,20);memcpy(r.working,p+88,20);memcpy(r.untracked,p+108,20);
    result=GCParse(p+140,pn,eq,ctx,&r.discard);
    if(!result && r.discard.generation!=WSWord(p+40))result=GS_FORMAT;
    if(!result)result=GPParse(p+140+pn,mn,eq,ctx,&r.aliases);
    if(!result && count){r.paths=(char **)calloc(count,sizeof(*r.paths));if(!r.paths)result=GB_MEMORY;}
    at=140+pn+mn;
    for(i=0;!result && i<count;++i) {
        if(at>n-20 || n-20-at<4){result=GS_FORMAT;break;}
        a=WSWord(p+at);at+=4;
        if(!a || a>l->pathBytes || a>n-20-at || memchr(p+at,0,a)){result=GS_FORMAT;break;}
        r.paths[i]=(char *)malloc(a+1);if(!r.paths[i]){result=GB_MEMORY;break;}
        memcpy(r.paths[i],p+at,a);r.paths[i][a]=0;++r.pathCount;at+=a;
    }
    if(!result && r.completeDirectories && r.discard.directoryCount) {
        if(at>n-20 || r.discard.directoryCount>(n-20-at)/48 ||
            r.discard.directoryCount>l->files || r.discard.directoryCount>(size_t)-1/sizeof(*r.directories))result=GS_FORMAT;
        else {r.directories=(WSDirectory *)calloc(r.discard.directoryCount,sizeof(*r.directories));if(!r.directories)result=GB_MEMORY;}
        for(i=0;!result && i<r.discard.directoryCount;++i) {
            WSDirectory *d=r.directories+i;GBWord attributes=WSWord(p+at);
            if(attributes>255 || !(attributes&16)){result=GS_FORMAT;break;}
            d->attributes=(unsigned char)attributes;d->created=WSWord(p+at+4);d->modified=WSWord(p+at+8);d->backup=WSWord(p+at+12);
            memcpy(d->finderInfo,p+at+16,32);at+=48;
        }
    }
    if(!result && at!=n-20)result=GS_FORMAT;
    if(!result)result=WSShape(&r,l);
    if(!result){r.original=WSCopy(data,n);if(!r.original)result=GB_MEMORY;else r.originalLength=n;}
    if(!result){WSFree(out);*out=r;WSInit(&r);}WSFree(&r);return result;
}
static int WSReadOnly(void *ctx,const char *key,const void *a,size_t an,const void *b,size_t bn) {
    (void)ctx;(void)b;(void)bn;
    /* GSPutObject interprets conflict as "read and verify the existing object".
       Never forward a write, including when that object is actually missing. */
    return !strncmp(key,"objects/",8) && !a && !an?GS_CONFLICT:GS_FORMAT;
}
static int WSObjectsOnly(void *ctx,const char *key,const void *a,size_t an,const void *b,size_t bn) {
    GSRepository *r=ctx;if(strncmp(key,"objects/",8) || a || an)return GS_FORMAT;
    return r->replace(r->context,key,NULL,0,b,bn);
}
static int WSRead(void *ctx,const char *key,unsigned char **p,size_t *n) {
    GSRepository *r=ctx;return r->read(r->context,key,p,n);
}
static int WSClone(const GCTransaction *t,GPEqual eq,void *ctx,GCTransaction *out) {
    unsigned char *p=NULL;size_t n=0;int result=GCEncode(t,eq,ctx,&p,&n);
    if(!result)result=GCParse(p,n,eq,ctx,out);
    free(p);return result;
}
static int WSIndex(const GCTransaction *t,const char *key,GIIndex *out) {
    const GCMetadata *m=WSMeta(t,key);if(!m)return GS_FORMAT;
    return m->beforePresent?GIParse(m->before,m->beforeLength,out):0;
}
void WSListInit(WSList *list) {memset(list,0,sizeof(*list));}
void WSListFree(WSList *list) {free(list->ids);free(list->original);WSListInit(list);}
static int WSListValid(const unsigned char *ids,size_t count) {
    size_t i,j;
    for(i=0;i<count;++i) {
        if(WSZero(ids+i*20,20))return GS_FORMAT;
        for(j=0;j<i;++j)if(!memcmp(ids+i*20,ids+j*20,20))return GS_FORMAT;
    }
    return 0;
}
int WSListParse(const void *bytes,size_t n,const WSLimits *l,WSList *out) {
    const unsigned char *p=bytes;unsigned char hash[20];size_t count;WSList next;int result;
    if(!l || !l->stateBytes || !l->entries || !out)return GB_BAD;
    if(n>l->stateBytes)return GB_SPACE;
    if(!p || n<32 || memcmp(p,"GHSL0001",8))return GS_FORMAT;
    count=WSWord(p+8);
    if(count>l->entries)return GB_SPACE;
    if(count>(n-32)/20 || n!=32+count*20)return GS_FORMAT;
    WSHash(p,n-20,hash);if(memcmp(hash,p+n-20,20))return GB_CHECKSUM;
    result=WSListValid(p+12,count);if(result)return result;
    WSListInit(&next);next.count=count;next.present=1;next.originalLength=n;
    next.original=WSCopy(p,n);
    if(count)next.ids=WSCopy(p+12,count*20);
    if(!next.original || (count && !next.ids)){WSListFree(&next);return GB_MEMORY;}
    WSListFree(out);*out=next;return 0;
}
int WSListEncode(const WSList *list,const WSLimits *l,unsigned char **bytes,size_t *length) {
    unsigned char *p;size_t n;int result;
    if(!list || !l || !l->stateBytes || !l->entries || !bytes || !length ||
       (list->count && !list->ids))return GB_BAD;
    if(list->count>l->entries || list->count>((size_t)-1-32)/20 ||
       list->count>(GBWord)~(GBWord)0)return GB_SPACE;
    n=32+list->count*20;if(n>l->stateBytes)return GB_SPACE;
    result=WSListValid((const unsigned char *)list->ids,list->count);if(result)return result;
    p=malloc(n);if(!p)return GB_MEMORY;
    memcpy(p,"GHSL0001",8);WSPut(p+8,(GBWord)list->count);
    if(list->count)memcpy(p+12,list->ids,list->count*20);
    WSHash(p,n-20,p+n-20);*bytes=p;*length=n;return 0;
}
int WSListRead(GSRepository *r,const WSLimits *l,WSList *out) {
    unsigned char *p=NULL;size_t n=0;WSList next;int result;
    if(!r || !r->read || !l || !l->stateBytes || !l->entries || !out)return GB_BAD;
    WSListInit(&next);result=r->read(r->context,WS_LIST_KEY,&p,&n);
    if(result==GS_NOT_FOUND)result=0;
    else if(!result)result=WSListParse(p,n,l,&next);
    free(p);
    if(!result){WSListFree(out);*out=next;WSListInit(&next);}
    WSListFree(&next);return result;
}
static int WSAddList(GSRepository *r,const WSLimits *l,const unsigned char oid[20],GCTransaction *t) {
    unsigned char *next=NULL;unsigned char (*ids)[20]=NULL;size_t n=0,i;GCMetadata *m;WSList list,view;int result;
    WSListInit(&list);WSListInit(&view);result=WSListRead(r,l,&list);
    for(i=0;!result && i<list.count;++i)if(!memcmp(list.ids[i],oid,20))result=GS_CONFLICT;
    if(!result && (list.count>=l->entries || list.count>((size_t)-1-52)/20 ||
        52+list.count*20>l->stateBytes))result=GB_SPACE;
    if(!result){ids=malloc((list.count+1)*20);if(!ids)result=GB_MEMORY;}
    if(!result) {
        memcpy(ids[0],oid,20);if(list.count)memcpy(ids+1,list.ids,list.count*20);
        view.ids=ids;view.count=list.count+1;result=WSListEncode(&view,l,&next,&n);
    }
    if(!result) {
        if(t->metadataCount>=(size_t)-1/sizeof(*m))result=GB_SPACE;
        else {m=(GCMetadata *)realloc(t->metadata,(t->metadataCount+1)*sizeof(*m));if(!m)result=GB_MEMORY;
            else {t->metadata=m;m+=t->metadataCount++;memset(m,0,sizeof(*m));m->path=WSCopy(WS_LIST_KEY,sizeof(WS_LIST_KEY));
                if(!m->path)result=GB_MEMORY;
                m->before=list.original;m->beforeLength=list.originalLength;m->beforePresent=list.present;
                m->after=next;m->afterLength=n;m->afterPresent=1;list.original=NULL;next=NULL;}}
    }
    free(ids);free(next);WSListFree(&list);return result;
}
static int WSGuardNow(GSRepository *r,const GCTransaction *t) {
    unsigned char *p=NULL;size_t i,n=0;GBWord generation;int result=GTNormalWriteAllowed(r);
    if(!result)result=GTNextGeneration(r,&generation);
    if(!result && generation!=t->generation)result=GS_CONFLICT;
    for(i=0;!result && i<t->metadataCount;++i) {
        const GCMetadata *m=t->metadata+i;
        result=r->read(r->context,m->path,&p,&n);
        if(result==GS_NOT_FOUND)result=m->beforePresent?GS_CONFLICT:0;
        else if(!result && (!m->beforePresent || n!=m->beforeLength || (n && memcmp(p,m->before,n))))result=GS_CONFLICT;
        free(p);p=NULL;
    }
    return result;
}
static int WSSelectFile(const GIIndex *from,const char *path,GIIndex *to) {
    char key[96];const GIEntry *e;int result=GIMacMetadataPath(path,key);
    e=GIFind(from,path,0);if(!e)return GS_FORMAT;
    if(!result)result=GISet(to,path,e->stat[6],e->oid,e->stat[9]);
    e=GIFind(from,key,0);
    if(!result && e) {
        result=GISet(to,key,e->stat[6],e->oid,e->stat[9]);e=GIFind(from,GI_MAC_NAMESPACE "/version",0);
        if(!e)return GS_FORMAT;
        if(!result)result=GISet(to,e->path,e->stat[6],e->oid,e->stat[9]);
    }
    return result;
}
static int WSBelow(const char *parent,const char *child) {
    size_t n=strlen(parent);return !strncmp(parent,child,n) && child[n]=='/';
}
static int WSClearPrefixes(GIIndex *index,const char *path) {
    size_t i=0;int result=0;char *copy;
    while(!result && i<index->count) {
        const char *other=index->entries[i].path;
        if(WSBelow(path,other) || WSBelow(other,path)) {
            copy=WSCopy(other,strlen(other)+1);if(!copy)return GB_MEMORY;
            result=GIRemoveMac(index,copy);free(copy);
        } else ++i;
    }
    return result;
}
static const GRFile *WSFile(const GRSnapshot *s,const char *path) {
    size_t lo=0,hi=s->count,m;int cmp;
    while(lo<hi){m=lo+(hi-lo)/2;cmp=strcmp(path,s->files[m].path);if(!cmp)return s->files+m;if(cmp<0)hi=m;else lo=m+1;}
    return NULL;
}
static int WSParents(GSRepository *r,const unsigned char oid[20],const unsigned char *parents,size_t count,
    const WSLimits *l,unsigned char tree[20]) {
    unsigned char *body=NULL,parent[20];char type[7],hex[41];GHCommitInfo info;
    size_t n=0,at=0,end,k=0;int result=GSGetObjectLimit(r,oid,type,&body,&n,l->stateBytes);
    if(!result && strcmp(type,"commit"))result=GS_FORMAT;
    if(!result)result=GHCommitParse(body,n,&info);
    if(!result && count!=(size_t)-1 && info.parents!=count)result=GS_FORMAT;
    while(!result && at<n && body[at]!='\n') {
        end=at;while(end<n && body[end]!='\n')++end;
        if(end-at>=7 && !memcmp(body+at,"parent ",7)) {
            if(count==(size_t)-1){at=end+1;continue;}
            if(end-at!=47 || k>=count)result=GS_FORMAT;
            else {memcpy(hex,body+at+7,40);hex[40]=0;result=GBOIDParse(hex,parent);
                if(!result && memcmp(parent,parents+k*20,20))result=GS_FORMAT;
                ++k;}
        }
        at=end+1;
    }
    if(!result && count!=(size_t)-1 && k!=count)result=GS_FORMAT;
    if(!result)memcpy(tree,info.tree,20);
    free(body);return result;
}
static int WSFileIdentity(GSRepository *r,const GRSnapshot *s,const char *path,const GPMap *defaults,GCFile *out) {
    const GRFile *f=WSFile(s,path);GRContents c;int result;
    memset(out,0,sizeof(*out));if(!f)return GS_NOT_FOUND;GRContentsInit(&c);
    result=GRReadFile(r,s,(size_t)(f-s->files),&c);
    if(!result){out->present=1;memcpy(out->dataOID,s->index.entries[f->entry].oid,20);
        result=GBObjectID("blob",c.resource,c.resourceLength,out->resourceOID);
        memcpy(out->finderInfo,c.finderInfo,32);if(!c.hasFinderInfo)GPDefaultFinderInfo(defaults,path,out->finderInfo);
        out->finderInfo[8]&=(unsigned char)~1U;memset(out->finderInfo+10,0,6);memset(out->finderInfo+28,0,4);}
    GRContentsFree(&c);return result;
}
static const GPEntry *WSNative(const GPMap *map,const char *native) {
    size_t i;for(i=0;i<map->count;++i)if(!strcmp(map->entries[i].native,native))return map->entries+i;return NULL;
}
static int WSUntracked(GSRepository *r,const unsigned char tree[20],const GRSnapshot *working,
    const GIReadLimits *limits,GRSnapshot *out) {
    GIIndex index;const GIEntry *version;size_t i;int result,needs=0;
    GIInit(&index);result=GIReadTreeBounded(r,tree,&index,limits);
    if(!result && GIFind(&index,GI_MAC_NAMESPACE "/version",0))result=GS_FORMAT;
    for(i=0;!result && i<index.count;++i)
        if(!strncmp(index.entries[i].path,GI_MAC_NAMESPACE "/",sizeof(GI_MAC_NAMESPACE)))needs=1;
    version=GIFind(&working->index,GI_MAC_NAMESPACE "/version",0);
    if(!result && needs && !version)result=GS_FORMAT;
    if(!result && needs)result=GISet(&index,version->path,version->stat[6],version->oid,version->stat[9]);
    if(!result)result=GRFromIndex(r,&index,out);
    GIFree(&index);return result;
}
int WSReadUntracked(GSRepository *r,const WSRecord *record,const WSLimits *l,GRSnapshot *out) {
    GRSnapshot working;GIReadLimits bounds;unsigned char tree[20];int result;
    if(!r || !r->read || !record || !out || !WSLimitValid(l))return GB_BAD;
    GRInit(&working);memset(&bounds,0,sizeof(bounds));bounds.entries=l->files*4;bounds.depth=128;bounds.pathBytes=l->pathBytes;
    result=WSParents(r,record->working,NULL,(size_t)-1,l,tree);
    if(!result)result=GRFromTreeBounded(r,tree,&working,&bounds);
    if(!result && record->haveUntracked)result=WSParents(r,record->untracked,NULL,0,l,tree);
    if(!result && record->haveUntracked)result=WSUntracked(r,tree,&working,&bounds,out);
    if(!result && !record->haveUntracked){GRFree(out);GRInit(out);}
    GRFree(&working);return result;
}
static int WSVerify(GSRepository *source,const WSLimits *l,WSRecord *record,GPEqual eq,void *ctx) {
    GSRepository r=*source;GRSnapshot staged,working,untracked,base;GIIndex index;
    GPMap after;GIReadLimits limits;const GCMetadata *m;const GPEntry *e;GQProtection owned;
    unsigned char tree[20],parents[60];GCFile f;size_t i;int result=0;
    r.replace=WSReadOnly;GRInit(&staged);GRInit(&working);GRInit(&untracked);GRInit(&base);GIInit(&index);GPInit(&after);
    memset(&limits,0,sizeof(limits));limits.entries=l->files*4;limits.depth=128;limits.pathBytes=l->pathBytes;
    owned.paths=(const char *const *)record->paths;owned.count=record->pathCount;owned.changed=0;
    if(record->haveBase)result=WSParents(&r,record->base,NULL,(size_t)-1,l,tree);
    if(!result && record->haveBase)result=GRFromTreeBounded(&r,tree,&base,&limits);
    if(!result)result=WSParents(&r,record->staged,record->base,record->haveBase?1:0,l,tree);
    if(!result)result=GRFromTreeBounded(&r,tree,&staged,&limits);
    if(!result)result=WSIndex(&record->discard,"index",&index);
    if(!result)result=GIWriteTree(&r,&index,tree);
    if(!result && memcmp(tree,staged.tree,20))result=GS_FORMAT;
    GIFree(&index);
    if(record->haveBase){memcpy(parents,record->base,20);memcpy(parents+20,record->staged,20);i=2;}
    else {memcpy(parents,record->staged,20);i=1;}
    if(record->haveUntracked)memcpy(parents+(i++)*20,record->untracked,20);
    if(!result)result=WSParents(&r,record->working,parents,i,l,tree);
    if(!result)result=GRFromTreeBounded(&r,tree,&working,&limits);
    if(!result && memcmp(working.tree,record->aliases.tree,20))result=GS_FORMAT;
    if(!result && record->haveUntracked)result=WSParents(&r,record->untracked,NULL,0,l,tree);
    if(!result && record->haveUntracked)result=WSUntracked(&r,tree,&working,&limits,&untracked);
    for(i=0;!result && i<working.count+untracked.count;++i) {
        const GRSnapshot *s=i<working.count?&working:&untracked;
        const GRFile *file=s->files+(i<working.count?i:i-working.count);
        unsigned char expectedInfo[32];
        e=GPFind(&record->aliases,file->path);
        if(!e || e->mode==GP_DIRECTORY || (s==&untracked && WSFile(&working,file->path)))result=GS_FORMAT;
        else if(e->mode!=file->mode)result=GS_FORMAT;
        else if(s==&working && (memcmp(e->dataOID,s->index.entries[file->entry].oid,20) ||
            e->flags!=(file->hasFinderInfo?GP_FORKS:0) ||
            (!file->hasFinderInfo && !WSZero(e->metadataOID,20)) ||
            (file->hasFinderInfo && memcmp(e->metadataOID,s->index.entries[file->metadataEntry].oid,20))))result=GS_FORMAT;
        if(!result && s==&working) {
            if(file->hasFinderInfo) {
                memcpy(expectedInfo,file->finderInfo,32);
                expectedInfo[8]&=(unsigned char)~1U;memset(expectedInfo+10,0,6);memset(expectedInfo+28,0,4);
                if(memcmp(e->finderInfo,expectedInfo,32))result=GS_FORMAT;
            }else if(!GPPlainFinderInfo(e->finderInfo))result=GS_FORMAT;
        }
    }
    m=WSMeta(&record->discard,"index");
    if(!result && (!m || !m->afterPresent))result=GS_FORMAT;
    if(!result)result=GIParse(m->after,m->afterLength,&index);
    if(!result)result=GIWriteTree(&r,&index,tree);
    if(!result && record->haveBase && memcmp(tree,base.tree,20))result=GS_FORMAT;
    if(!result && !record->haveBase && index.count)result=GS_FORMAT;
    m=WSMeta(&record->discard,"ghclient-map");
    if(!result && (!m || !m->afterPresent))result=GS_FORMAT;
    if(!result)result=GPParse(m->after,m->afterLength,eq,ctx,&after);
    if(!result && memcmp(after.tree,tree,20))result=GS_FORMAT;
    for(i=0;!result && i<record->discard.fileCount;++i) {
        const GCOperation *o=record->discard.files+i;
        if(o->oldPath) {
            e=WSNative(&record->aliases,o->oldPath);
            if(!e || !WSHas(&owned,e->path))result=GS_FORMAT;
            else {result=WSFileIdentity(&r,&working,e->path,&record->aliases,&f);
                if(result==GS_NOT_FOUND)result=WSFileIdentity(&r,&untracked,e->path,&record->aliases,&f);
                if(!result && !GCFileEqual(&f,&o->oldFile))result=GS_FORMAT;}
        }
        if(!result && o->newPath) {
            const GRFile *target;
            e=WSNative(&after,o->newPath);target=e?WSFile(&base,e->path):NULL;
            if(!e || !target || !record->haveBase || !WSHas(&owned,e->path) || target->mode!=o->mode ||
                (target->hasFinderInfo?memcmp(o->metadataOID,base.index.entries[target->metadataEntry].oid,20):!WSZero(o->metadataOID,20)))result=GS_FORMAT;
            else {result=WSFileIdentity(&r,&base,e->path,&after,&f);
                if(!result && !GCFileEqual(&f,&o->newFile))result=GS_FORMAT;}
        }
    }
    for(i=0;!result && i<record->discard.directoryCount;++i) {
        e=WSNative(&record->aliases,record->discard.directories[i]);
        if(!e || e->mode!=GP_DIRECTORY || !WSHas(&owned,e->path))result=GS_FORMAT;
    }
    GRFree(&staged);GRFree(&working);GRFree(&untracked);GRFree(&base);GIFree(&index);GPFree(&after);return result;
}
int WSOpen(GSRepository *r,const unsigned char oid[20],const WSLimits *l,GPEqual eq,void *ctx,WSRecord *out) {
    WSRecord next;unsigned char *p=NULL;size_t n=0;char type[7];int result;
    if(!r || !r->read || !oid || !out || !eq || !WSLimitValid(l))return GB_BAD;
    WSInit(&next);result=GSGetObjectLimit(r,oid,type,&p,&n,l->stateBytes);
    if(!result && strcmp(type,"blob"))result=GS_FORMAT;
    if(!result)result=WSParse(p,n,l,eq,ctx,&next);
    if(!result)result=WSVerify(r,l,&next,eq,ctx);
    if(!result){WSFree(out);*out=next;WSInit(&next);}free(p);WSFree(&next);return result;
}
int WSPrepareDiscard(GSRepository *source,const GQPlan *plan,const unsigned char binding[32],
    const GQWork *work,size_t count,const GQProtection *paths,WSReadWork readWork,WSReadDirectory readDirectory,void *readContext,
    const WSLimits *l,GPEqual eq,void *eqContext,WSPlan *out) {
    WSPlan next;GSRepository r;GIIndex original,policy,tracked,untracked;GRSnapshot head,working;
    GPMap before;GPReservation *reservations=NULL;const GCMetadata *m;
    unsigned char *p=NULL,*data=NULL,*resource=NULL,info[32],tree[20],parents[60];GIReadLimits bounds;
    size_t n=0,dn=0,rn=0,i,j,total=0,parentCount;int result,present,isTracked;char *branch=NULL;
    if(!source || !source->read || !source->replace || !plan || !binding || !out || !eq || !readWork || !readDirectory ||
        !WSLimitValid(l) || WSZero(binding,32) || count>l->files || count>(size_t)-1/sizeof(*reservations) || (count && !work))return GB_BAD;
    result=WSPaths(paths,l);if(result)return result;
    for(i=0;i<count;++i)
        if(!work[i].path || !work[i].native || strlen(work[i].path)>l->pathBytes ||
            (work[i].file.present!=1 && work[i].file.present!=2))return GB_BAD;
    WSPlanInit(&next);GIInit(&original);GIInit(&policy);GIInit(&tracked);GIInit(&untracked);
    GRInit(&head);GRInit(&working);GPInit(&before);
    memset(&bounds,0,sizeof(bounds));bounds.entries=l->files*4;bounds.depth=128;bounds.pathBytes=l->pathBytes;
    r.context=source;r.read=WSRead;r.replace=WSObjectsOnly;memcpy(next.record.binding,binding,32);
    result=WSClone(&plan->transaction,eq,eqContext,&next.record.discard);
    if(!result && (next.record.discard.directoryCount>l->files ||
        next.record.discard.directoryCount>l->stateBytes/48 ||
        next.record.discard.directoryCount>(size_t)-1/sizeof(*next.record.directories)))result=GB_SPACE;
    if(!result && next.record.discard.directoryCount) {
        next.record.directories=(WSDirectory *)calloc(next.record.discard.directoryCount,sizeof(*next.record.directories));
        if(!next.record.directories)result=GB_MEMORY;
    }
    for(i=0;!result && i<next.record.discard.directoryCount;++i) {
        for(j=0;j<count && strcmp(work[j].native,next.record.discard.directories[i]);++j){}
        if(j==count || work[j].file.present!=2)result=GS_CONFLICT;
        else result=readDirectory(readContext,work+j,next.record.directories+i);
        if(!result && !(next.record.directories[i].attributes&16))result=GS_FORMAT;
    }
    if(!result)next.record.completeDirectories=1;
    if(!result)result=WSGuardNow(&r,&next.record.discard);
    if(!result)result=WSBranch(&next.record.discard,&branch,next.record.base,&present);
    if(!result)next.record.haveBase=present;
    if(!result && present)result=WSParents(&r,next.record.base,NULL,(size_t)-1,l,tree);
    if(!result && present)result=GRFromTreeBounded(&r,tree,&head,&bounds);
    if(!result)result=WSIndex(&next.record.discard,"index",&original);
    if(!result)result=GIEncode(&original,&p,&n);
    if(!result)result=GIParse(p,n,&policy);
    free(p);p=NULL;
    if(!result)result=GIWriteTree(&r,&original,tree);
    if(!result)result=GSWriteCommitObject(&r,tree,next.record.base,present?1:0,
        "GHClient Workspace <workspace@localhost>","GHClient Workspace <workspace@localhost>","0","+0000","GHClient staged workspace",next.record.staged);
    m=WSMeta(&next.record.discard,"ghclient-map");
    if(!result && !m)result=GS_FORMAT;
    if(!result && m->beforePresent)result=GPParse(m->before,m->beforeLength,eq,eqContext,&before);
    if(!result)result=GQCheckInventory(&before,work,count,eq,eqContext,1);
    if(!result && count){reservations=(GPReservation *)calloc(count,sizeof(*reservations));if(!reservations)result=GB_MEMORY;}
    for(i=0;!result && i<count;++i) {
        const GQWork *w=work+i;GCFile actual;
        if(!w->path || !w->native || strlen(w->path)>l->pathBytes || (w->file.present!=1 && w->file.present!=2)){result=GB_BAD;break;}
        reservations[i].path=w->path;reservations[i].native=w->native;reservations[i].directory=w->file.present==2;
        if(w->file.present==2)continue;
        isTracked=WSFile(&head,w->path)!=NULL || GIFind(&original,w->path,0)!=NULL;
        if(!isTracked && !WSHas(paths,w->path))continue;
        memset(info,0,32);result=readWork(readContext,w,l->forkBytes,&data,&dn,&resource,&rn,info);
        if(!result && ((!data && dn) || (!resource && rn) || dn>l->forkBytes || rn>l->forkBytes-dn ||
            total>l->workBytes || dn+rn>l->workBytes-total))result=GB_SPACE;
        memset(&actual,0,sizeof(actual));actual.present=1;
        if(!result)result=GBObjectID("blob",data,dn,actual.dataOID);
        if(!result)result=GBObjectID("blob",resource,rn,actual.resourceOID);
        memcpy(actual.finderInfo,info,32);actual.finderInfo[8]&=(unsigned char)~1U;
        memset(actual.finderInfo+10,0,6);memset(actual.finderInfo+28,0,4);
        if(!result && !GCFileEqual(&actual,&w->file))result=GS_CONFLICT;
        if(!result)result=WSClearPrefixes(&policy,w->path);
        if(!result)result=GPStageWork(&r,&policy,GPFind(&before,w->path),w->path,data,dn,actual.finderInfo,resource,rn);
        if(!result)result=WSSelectFile(&policy,w->path,isTracked?&tracked:&untracked);
        if(!result)total+=dn+rn;
        free(data);free(resource);data=resource=NULL;dn=rn=0;
    }
    if(!result && untracked.count) {
        const GIEntry *version=GIFind(&untracked,GI_MAC_NAMESPACE "/version",0);
        if(version) {
            result=GISet(&tracked,version->path,version->stat[6],version->oid,version->stat[9]);
            if(!result)result=GIRemove(&untracked,GI_MAC_NAMESPACE "/version");
        }
        if(!result)result=GIWriteTree(&r,&untracked,tree);
        if(!result)result=GSWriteCommitObject(&r,tree,NULL,0,"GHClient Workspace <workspace@localhost>",
            "GHClient Workspace <workspace@localhost>","0","+0000","GHClient untracked workspace",next.record.untracked);
        if(!result)next.record.haveUntracked=1;
    }
    if(!result)result=GIWriteTree(&r,&tracked,tree);
    if(!result)result=GRFromTreeBounded(&r,tree,&working,&bounds);
    if(!result)result=GPBuildProtected(&working,&before,reservations,count,eq,eqContext,&next.record.aliases);
    parentCount=0;if(next.record.haveBase){memcpy(parents,next.record.base,20);++parentCount;}
    memcpy(parents+parentCount++*20,next.record.staged,20);
    if(next.record.haveUntracked)memcpy(parents+parentCount++*20,next.record.untracked,20);
    if(!result)result=GSWriteCommitObject(&r,tree,parents,parentCount,"GHClient Workspace <workspace@localhost>",
        "GHClient Workspace <workspace@localhost>","0","+0000","GHClient working workspace",next.record.working);
    if(!result && paths->count){next.record.paths=(char **)calloc(paths->count,sizeof(*next.record.paths));if(!next.record.paths)result=GB_MEMORY;}
    for(i=0;!result && i<paths->count;++i) {
        next.record.paths[i]=WSCopy(paths->paths[i],strlen(paths->paths[i])+1);
        if(!next.record.paths[i])result=GB_MEMORY;else ++next.record.pathCount;
    }
    if(!result)result=WSVerify(&r,l,&next.record,eq,eqContext);
    if(!result)result=WSEncode(&next.record,l,eq,eqContext,&p,&n);
    if(!result)result=GSPutObject(&r,"blob",p,n,next.oid);
    if(!result)result=WSClone(&plan->transaction,eq,eqContext,&next.transaction);
    if(!result)result=WSAddList(&r,l,next.oid,&next.transaction);
    if(!result)result=WSGuardNow(&r,&next.transaction);
    if(!result){WSPlanFree(out);*out=next;WSPlanInit(&next);}
    free(branch);free(p);free(data);free(resource);free(reservations);GIFree(&original);GIFree(&policy);
    GIFree(&tracked);GIFree(&untracked);GRFree(&head);GRFree(&working);GPFree(&before);WSPlanFree(&next);return result;
}
