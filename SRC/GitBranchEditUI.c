/* Current-branch Rename and graphical local-branch Delete. Uses shared native
   field/list/decision panels, all designed within the minimum display canvas. */
static int BUINameSpace(void *context,const char *source,const char *target) {
    GXCheckout *x=(GXCheckout *)context;CUIBranches names;FSSpec refs;
    OSErr error;long id;int kind,result;size_t i,n,tn=strlen(target);
    if(x!=&gUICheckout || !x->store.leaseHeld)return GS_CONFLICT;
    memset(&names,0,sizeof(names));
    result=GFResolve(&x->store,"refs",&refs,&kind,&id,&error);
    if(!result && kind==2)result=CUICollect(&names,id,"refs",0);
    else if(!result && kind)result=GS_FORMAT;
    for(i=0;!result && i<names.count;++i) {
        const char *name=names.names[i];n=strlen(name);
        if(!strcmp(name,source))continue;
        if(!strcmp(name,target) || (n<tn && !memcmp(name,target,n) && target[n]=='/') ||
           (tn<n && !memcmp(name,target,tn) && name[tn]=='/'))result=GS_CONFLICT;
    }
    CUIFree(&names);return result;
}
static int BUIRow(void *context,size_t at,char label[256],char name[256],char state[256]) {
    CUIBranches *b=(CUIBranches *)context;
    if(at>=b->count)return 0;
    LocalDisplayPath(b->names[at]+11,name);snprintf(label,256,"%.250s",name);
    if(!strcmp(b->names[at],gWork.branch)) {
        snprintf(label,256,"%.238s (current)",name);
        snprintf(state,256,"Current branch. Switch to another branch before deleting this one.");return 0;
    }
    strcpy(state,"Local branch. Review its commits before confirming deletion.");return 1;
}
static char *BUIDetails(void *context,size_t at) {
    CUIBranches *b=(CUIBranches *)context;
    return at<b->count?ChoiceIdentityDetails("Local branch",b->names[at]):NULL;
}
static void BUIError(int result) {
    if(result==BE_PENDING_PUSH)Message("Review Pending Push","Finish or review the pending Push before changing branch names. Choose Repository > Review Pending Push, then try again.");
    else if(result==BE_CURRENT)Message("Current Branch","Switch to another branch before deleting the current branch.");
    else if(result==BE_UNMERGED)Message("Unmerged Commits","Deletion needs explicit approval because this branch has commits outside the current branch.");
    else if(result==GS_CONFLICT)Message("Branch Changed","The branch, its settings or this repository changed while it was being reviewed. Refresh and try again. The requested branch change was not confirmed.");
    else if(!gCheckoutStopped && result!=GC_RECOVERY)CheckoutError("Change Local Branch",result);
}
static void BranchEditCommand(int kind) {
    BEPlan plan;BELimits limits;CUIBranches branches;NativeChoices choices;OperationPrompt prompt;
    char typed[256]="",target[268],source[1025],name[256],repository[256],state[700],hex[41],status[256];
    unsigned char tip[20];size_t selected,i;int result=0,closed,answer;
    if(!gLocal || gBusy || gDone)return;
    LocalRefresh();if(gLocalBlocked || gDone)return;
    BEInit(&plan);memset(&branches,0,sizeof(branches));source[0]=target[0]=0;
    if(kind==BE_RENAME) {
        strcpy(source,gWork.branch);
        if(strlen(source+11)<sizeof(typed)) {
            const unsigned char *p=(const unsigned char *)source+11;
            while(*p && *p<128)++p;if(!*p)strcpy(typed,source+11);
        }
        if(!AskAction("Rename Branch","Choose a new name for the current local branch. Your staged changes and working files are kept.","Review",ASK_BRANCH,typed))goto done;
        for(i=0;typed[i] && (unsigned char)typed[i]<128;++i){}
        snprintf(target,sizeof(target),"refs/heads/%s",typed);
        if(typed[i] || !GSValidRef(target) || !strcmp(source,target)) {
            Message("Branch Name","Enter a different valid ASCII Git branch name, such as feature/classic-mac.");goto done;
        }
        if(gWork.haveHead)memcpy(tip,gWork.tip,20);
    } else {
        result=CUILoad(&branches);if(result)goto failed;
        for(i=0;i<branches.count;++i)if(strcmp(branches.names[i],gWork.branch))break;
        if(i==branches.count){Message("Delete Branch","There are no other local branches to delete. Switch to another branch before deleting this one.");goto done;}
        memset(&choices,0,sizeof(choices));choices.context=&branches;choices.count=branches.count;choices.initial=i;
        choices.row=BUIRow;choices.details=BUIDetails;choices.title="Delete Local Branch";
        choices.description="Choose a local branch to review for deletion. Switch away from the current branch before deleting it.";
        choices.action="Review";choices.noun="Branches";
        selected=PickNativeChoice(&choices);if(gDone || selected==(size_t)-1)goto done;
        strcpy(source,branches.names[selected]);
        result=CheckoutAttach(&gWork.folder);
        if(!result)result=GSMacEnter(&gUICheckout.store,0);
        if(!result)result=GSReadRef(&gUICheckout.raw,source,tip);
        closed=CheckoutRelease();if(!result)result=closed;if(result)goto failed;
    }
    memset(&limits,0,sizeof(limits));limits.stateBytes=4UL*1024*1024;
    limits.read.objectBytes=2UL*1024*1024;limits.read.encodedBytes=3UL*1024*1024;
    limits.read.readBytes=64UL*1024*1024;limits.read.reads=32768;
    limits.graph.objects=8192;limits.graph.objectBytes=2UL*1024*1024;limits.graph.readBytes=64UL*1024*1024;
    result=CheckoutAttach(&gWork.folder);
    if(!result) {
        CheckoutBegin("Reviewing local branch and commit ancestry... Escape cancels.");
        result=GXBranchEditPrepare(&gUICheckout,kind,gWork.branch,gWork.haveHead?gWork.tip:NULL,
            source,(kind==BE_RENAME && !gWork.haveHead)?NULL:tip,kind==BE_RENAME?target:NULL,
            &limits,BUINameSpace,&gUICheckout,&plan);gBusy=0;
    }
    closed=CheckoutRelease();if(!result)result=closed;if(result)goto failed;
    if(gDone)goto done;
    LocalRefresh();if(gLocalBlocked || gDone)goto done;
    SetStatus("Review the local branch change. Nothing has been applied.");
    memcpy(repository,gWork.folder.name+1,gWork.folder.name[0]);repository[gWork.folder.name[0]]=0;
    LocalDisplayPath(source+11,name);memset(&prompt,0,sizeof(prompt));
    prompt.title=kind==BE_RENAME?"Rename Local Branch":"Delete Local Branch";prompt.repository=repository;
    if(kind==BE_RENAME) {
        char proposed[256];LocalDisplayPath(target+11,proposed);
        snprintf(state,sizeof(state),"Current: %.255s\rNew: %.255s",name,proposed);
    } else snprintf(state,sizeof(state),"%s\r%s",name,
        plan.merged?"Its commits are reachable from the current branch.":"This branch has commits outside the current branch.");
    prompt.state=state;prompt.primary=kind==BE_RENAME?"Rename":plan.merged?"Delete Branch":"Delete Unmerged";
    prompt.primaryText=kind==BE_RENAME?"Apply the new local name. Your current GitHub tracking target is kept.":
        plan.merged?"Remove the local branch reference. Its commit remains in the current branch history.":
        "Explicitly delete this unmerged local reference. Its tip is retained in local recovery history.";
    prompt.canPrimary=1;prompt.footer="Working files and staged changes are kept. GitHub branch names are unchanged. Local recovery history is retained.";
    prompt.labels[0]="Original local branch";prompt.values[0]=source;
    if(kind==BE_RENAME){prompt.labels[1]="New local branch";prompt.values[1]=target;}
    else {prompt.labels[1]="Current local branch";prompt.values[1]=gWork.branch;}
    if(kind==BE_DELETE || gWork.haveHead){GBOIDFormat(tip,hex);prompt.labels[2]="Reviewed branch tip";prompt.values[2]=hex;}
    answer=OperationConfirm(&prompt);if(answer!=1 || gDone){SetStatus("Branch change cancelled. Local branches and files are unchanged.");goto done;}
    result=CheckoutAttach(&gWork.folder);
    if(!result) {
        CheckoutBegin("Updating local branch metadata... Escape stops at a recoverable checkpoint.");
        result=GXBranchEditApply(&gUICheckout,&plan,BUINameSpace,&gUICheckout,kind==BE_DELETE && !plan.merged);gBusy=0;
    }
    closed=CheckoutRelease();if(!result)result=closed;if(result)goto failed;
    LocalRefresh();
    if(!gLocalBlocked){snprintf(status,sizeof(status),"%s %.180s. Working files and staged changes kept.",kind==BE_RENAME?"Renamed":"Deleted local branch",name);SetStatus(status);}
    goto done;
failed:
    if(!gDone){BUIError(result);LocalRefresh();}
done:
    CUIFree(&branches);BEFree(&plan);gBusy=0;
    if(gLocal && gLocalBlocked && !gDone)LocalRefresh();
}
