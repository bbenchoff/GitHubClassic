#include "GitStashApply.h"
#include "GitWorkspaceRestore.h"
#include "GitCheckoutSession.h"
#include <stdlib.h>
#include <string.h>

void SAPlanInit(SAPlan *p){memset(p,0,sizeof(*p));GQInit(&p->checkout);}
void SAPlanFree(SAPlan *p){GQFree(&p->checkout);SAPlanInit(p);}
typedef struct {GSRepository *source,objects;GOReader bounds;size_t stateBytes;GDProgress tick;void *context;} SABIO;
static int SABTick(SABIO *io){return io->tick?io->tick(io->context):0;}
static int SABRead(void *context,const char *key,unsigned char **p,size_t *n){
    SABIO *io=context;int result;*p=NULL;*n=0;
    if(!strncmp(key,"objects/",8))return io->objects.read(io->objects.context,key,p,n);
    result=SABTick(io);if(!result)result=io->source->read(io->source->context,key,p,n);
    if(!result && *n>io->stateBytes)result=GB_SPACE;
    if(!result && !*p)result=GS_FORMAT;
    if(!result)result=SABTick(io);
    if(result){free(*p);*p=NULL;*n=0;}return result;
}
static int SABPut(void *context,const char *key,const void *a,size_t an,const void *b,size_t bn){
    SABIO *io=context;int result;
    if(strncmp(key,"objects/",8) || a || an)return GS_FORMAT;
    if(bn>io->bounds.limits.encodedBytes)return GB_SPACE;
    result=SABTick(io);if(!result)result=io->source->replace(io->source->context,key,NULL,0,b,bn);
    if(!result)result=SABTick(io);return result;
}
static void *SABCopy(const void *p,size_t n){void *out=malloc(n?n:1);if(out && n)memcpy(out,p,n);return out;}
static const GCMetadata *SABMeta(const GCTransaction *t,const char *key){size_t i;for(i=0;i<t->metadataCount;++i)if(!strcmp(t->metadata[i].path,key))return t->metadata+i;return NULL;}
static int SABBefore(const GCMetadata *a,const GCMetadata *b){
    return a->beforePresent==b->beforePresent && a->beforeLength==b->beforeLength &&
        (!a->beforeLength || !memcmp(a->before,b->before,a->beforeLength));
}
static int SABMetaSet(GCTransaction *t,const char *key,const void *a,size_t an,int ap,const void *b,size_t bn,int bp){
    GCMetadata *m,*items;char *path;unsigned char *before=NULL,*after=NULL;size_t i;
    path=SABCopy(key,strlen(key)+1);if(!path)return GB_MEMORY;
    if(ap)before=SABCopy(a,an);if(bp)after=SABCopy(b,bn);
    if((ap && !before) || (bp && !after)){free(path);free(before);free(after);return GB_MEMORY;}
    for(i=0;i<t->metadataCount;++i)if(!strcmp(t->metadata[i].path,key))break;
    if(i==t->metadataCount){
        if(i>=(size_t)-1/sizeof(*m)){free(path);free(before);free(after);return GB_SPACE;}
        items=realloc(t->metadata,(i+1)*sizeof(*items));if(!items){free(path);free(before);free(after);return GB_MEMORY;}
        t->metadata=items;memset(items+i,0,sizeof(*items));++t->metadataCount;
    }
    m=t->metadata+i;free(m->path);free(m->before);free(m->after);memset(m,0,sizeof(*m));
    m->path=path;m->before=before;m->beforeLength=an;m->beforePresent=ap;m->after=after;m->afterLength=bn;m->afterPresent=bp;return 0;
}
static int SABFresh(GSRepository *r,const GCTransaction *t){
    unsigned char *p=NULL;size_t i,n=0;GBWord generation;int result,present;
    result=GTNormalWriteAllowed(r);if(!result)result=GTNextGeneration(r,&generation);
    if(!result && generation!=t->generation)result=GS_CONFLICT;
    for(i=0;!result && i<t->metadataCount;++i){const GCMetadata *m=t->metadata+i;
        result=r->read(r->context,m->path,&p,&n);present=!result;if(result==GS_NOT_FOUND)result=0;
        if(!result && (present!=m->beforePresent || n!=m->beforeLength || (n && memcmp(p,m->before,n))))result=GS_CONFLICT;
        free(p);p=NULL;n=0;
    }
    return result;
}
typedef struct {const char **paths;size_t count,capacity;} SABPaths;
static int SABPathAdd(SABPaths *p,const char *path,const WSLimits *l){
    const char **items;size_t cap;
    if(!GIValidPath(path) || !strcmp(path,GI_MAC_NAMESPACE) || !strncmp(path,GI_MAC_NAMESPACE "/",sizeof(GI_MAC_NAMESPACE)))return GS_FORMAT;
    if(strlen(path)>l->pathBytes || p->count>=l->files*8)return GB_SPACE;
    if(p->count==p->capacity){
        cap=p->capacity?(p->capacity>l->files*8/2?l->files*8:p->capacity*2):32;if(cap>l->files*8)cap=l->files*8;
        if(cap>(size_t)-1/sizeof(*items))return GB_SPACE;
        items=realloc(p->paths,cap*sizeof(*items));if(!items)return GB_MEMORY;p->paths=items;p->capacity=cap;
    }
    p->paths[p->count++]=path;return 0;
}
static int SABFileSame(const GRSnapshot *a,const GRFile *af,const GRSnapshot *b,const GRFile *bf){
    return af->mode==bf->mode && af->hasFinderInfo==bf->hasFinderInfo &&
        !memcmp(a->index.entries[af->entry].oid,b->index.entries[bf->entry].oid,20) &&
        (!af->hasFinderInfo || !memcmp(a->index.entries[af->metadataEntry].oid,b->index.entries[bf->metadataEntry].oid,20));
}
static int SABChanges(SABPaths *p,const GRSnapshot *a,const GRSnapshot *b,const WSLimits *l){
    size_t i=0,j=0;int result=0,order;
    while(!result && (i<a->count || j<b->count)){
        order=i==a->count?1:j==b->count?-1:strcmp(a->files[i].path,b->files[j].path);
        if(order<0)result=SABPathAdd(p,a->files[i++].path,l);
        else if(order>0)result=SABPathAdd(p,b->files[j++].path,l);
        else {if(!SABFileSame(a,a->files+i,b,b->files+j))result=SABPathAdd(p,a->files[i].path,l);++i;++j;}
    }return result;
}
static int SABOrder(const void *a,const void *b){return strcmp(*(const char *const *)a,*(const char *const *)b);}
static int SABPathsFinish(SABPaths *p,const WSLimits *l){
    size_t i,n=0;if(p->count)qsort(p->paths,p->count,sizeof(*p->paths),SABOrder);
    for(i=0;i<p->count;++i)if(!n || strcmp(p->paths[i],p->paths[n-1]))p->paths[n++]=p->paths[i];
    p->count=n;return n>l->paths?GB_SPACE:0;
}
static int SABIndexSame(const GIIndex *a,const GIIndex *b){
    size_t i;if(a->count!=b->count)return 0;
    for(i=0;i<a->count;++i){const GIEntry *x=a->entries+i,*y=b->entries+i;
        if(strcmp(x->path,y->path) || x->stat[6]!=y->stat[6] || memcmp(x->oid,y->oid,20) ||
           (x->flags&0xf000U)!=(y->flags&0xf000U) || x->extended!=y->extended)return 0;
    }return 1;
}
static int SABOverlap(const GRSnapshot *s,const char *path){
    size_t lo=0,hi=s->count,m,i,n=strlen(path);int cmp;
    while(lo<hi){m=lo+(hi-lo)/2;cmp=strcmp(s->files[m].path,path);if(cmp<0)lo=m+1;else hi=m;}
    if(lo<s->count && !strncmp(s->files[lo].path,path,n) && (!s->files[lo].path[n] || s->files[lo].path[n]=='/'))return 1;
    for(i=0;i<n;++i)if(path[i]=='/'){
        lo=0;hi=s->count;
        while(lo<hi){size_t length;m=lo+(hi-lo)/2;length=strlen(s->files[m].path);cmp=memcmp(s->files[m].path,path,length<i?length:i);
            if(!cmp)cmp=length<i?-1:length>i?1:0;if(!cmp)return 1;if(cmp<0)lo=m+1;else hi=m;}
    }return 0;
}
static int SABUntracked(GIIndex *working,const GRSnapshot *w,const GRSnapshot *s,const GRSnapshot *u,GQError *why){
    size_t i;const GIEntry *version,*old,*e;int result=0,haveVersion;
    for(i=0;i<u->count;++i)if(SABOverlap(w,u->files[i].path) || SABOverlap(s,u->files[i].path)){
        if(why){why->reason=GQ_UNTRACKED;strncpy(why->path,u->files[i].path,sizeof(why->path)-1);why->path[sizeof(why->path)-1]=0;}return GS_CONFLICT;
    }
    version=GIFind(&u->index,GI_MAC_NAMESPACE "/version",0);old=GIFind(working,GI_MAC_NAMESPACE "/version",0);
    haveVersion=old!=NULL;
    if(version && old && (version->stat[6]!=old->stat[6] || memcmp(version->oid,old->oid,20)))return GS_CONFLICT;
    for(i=0;!result && i<u->index.count;++i){e=u->index.entries+i;
        if(!strcmp(e->path,GI_MAC_NAMESPACE "/version") && haveVersion)continue;
        result=GISet(working,e->path,e->stat[6],e->oid,e->stat[9]);
    }return result;
}
static int SABSeal(const SAReview *review,int pop,const char *branch,GQPlan *p,const void *index,size_t in,int ip){
    const GCMetadata *m,*existing;size_t i;char ref[64];int result=GSRefKey(branch,ref);
    if(!result && (review->removal.metadataCount!=7 || p->transaction.metadataCount!=4))result=GS_FORMAT;
    for(i=0;!result && i<review->removal.metadataCount;++i){
        m=review->removal.metadata+i;existing=SABMeta(&p->transaction,m->path);
        if(existing){
            if(!SABBefore(existing,m)){result=GS_CONFLICT;break;}
            if(!strcmp(m->path,"index"))result=SABMetaSet(&p->transaction,m->path,m->before,m->beforeLength,m->beforePresent,index,in,ip);
            else if(!strcmp(m->path,"HEAD") || !strcmp(m->path,ref))
                result=SABMetaSet(&p->transaction,m->path,m->before,m->beforeLength,m->beforePresent,m->before,m->beforeLength,m->beforePresent);
            else if(strcmp(m->path,"ghclient-map"))result=GS_FORMAT;
        }else result=SABMetaSet(&p->transaction,m->path,m->before,m->beforeLength,m->beforePresent,
            pop?m->after:m->before,pop?m->afterLength:m->beforeLength,pop?m->afterPresent:m->beforePresent);
    }
    if(!result)p->transaction.generation=review->removal.generation;return result;
}
int SABuild(GSRepository *source,const SAReview *review,const TMResolution *workingChoices,size_t wc,
    const TMResolution *stagedChoices,size_t sc,int pop,const GQWork *inventory,size_t count,const WSLimits *l,
    GPEqual eq,void *eqContext,GDProgress tick,void *context,SAPlan *out,GQError *why){
    SAPlan next;SABIO io;GSRepository r;TMDraft working,staged;GRSnapshot w,s;GIIndex current,merged;
    SABPaths paths;GQProtection protectedPaths;const GCMetadata *head,*index;char *branch=NULL;
    unsigned char *wire=NULL,*encoded=NULL;size_t n=0,en=0,i,bn;int result,choice,ip=1;const void *indexWire=NULL;size_t indexLength=0;
    if(!source || !source->read || !source->replace || !review || !eq || !out || (void *)out==(const void *)review ||
       (pop!=0 && pop!=1) || (wc && !workingChoices) || (sc && !stagedChoices) || !l || l->stateBytes<160 ||
       !l->files || l->files>(size_t)-1/8 || !l->paths || !l->pathBytes || !l->forkBytes || !l->workBytes || !l->entries ||
       count>l->files || (count && !inventory))return GB_BAD;
    if(why)memset(why,0,sizeof(*why));
    SAPlanInit(&next);TMDraftInit(&working);TMDraftInit(&staged);GRInit(&w);GRInit(&s);GIInit(&current);GIInit(&merged);
    memset(&paths,0,sizeof(paths));memset(&io,0,sizeof(io));io.source=source;io.stateBytes=l->stateBytes;io.tick=tick;io.context=context;
    result=GOReadStart(source,&review->working.limits.read,tick,context,&io.bounds,&io.objects);
    r.context=&io;r.read=SABRead;r.replace=SABPut;
    if(!result)result=SABFresh(&r,&review->removal);
    head=SABMeta(&review->removal,"HEAD");index=SABMeta(&review->removal,"index");
    if(!result && (!head || !index || !head->beforePresent || head->beforeLength<7 || head->beforeLength>1030 ||
       memcmp(head->before,"ref: ",5) || head->before[head->beforeLength-1]!='\n'))result=GS_FORMAT;
    if(!result){bn=head->beforeLength-6;branch=malloc(bn+1);if(!branch)result=GB_MEMORY;
        else {memcpy(branch,head->before+5,bn);branch[bn]=0;if(memchr(branch,0,bn) || !GSValidRef(branch))result=GS_FORMAT;}}
    if(!result)result=TMBuildResolvedIndex(&r,&review->working,workingChoices,wc,tick,context,&working);
    if(!result)result=TMBuildResolvedIndex(&r,&review->staged,stagedChoices,sc,tick,context,&staged);
    if(!result && (working.unresolved || staged.unresolved))result=GI_UNMERGED;
    if(!result)result=TMStoreObjects(&r,&working,tick,context);
    if(!result)result=TMStoreObjects(&r,&staged,tick,context);
    if(!result)result=GRFromIndex(&r,&working.index,&w);
    if(!result)result=GRFromIndex(&r,&staged.index,&s);
    if(!result)result=SABUntracked(&working.index,&w,&s,&review->untracked,why);
    if(!result)result=SABChanges(&paths,review->working.snapshots,review->working.snapshots+2,l);
    if(!result)result=SABChanges(&paths,review->staged.snapshots,review->staged.snapshots+2,l);
    if(!result)result=SABChanges(&paths,review->staged.snapshots+1,&s,l);
    for(i=0;!result && i<review->untracked.count;++i)result=SABPathAdd(&paths,review->untracked.files[i].path,l);
    if(!result)result=SABPathsFinish(&paths,l);
    protectedPaths.paths=paths.paths;protectedPaths.count=paths.count;protectedPaths.changed=0;
    if(!result && index->beforePresent)result=GIParse(index->before,index->beforeLength,&current);
    if(!result)result=WRMergeIndex(&r,&staged.index,&review->staged.snapshots[1].index,&current,&protectedPaths,l,&merged,&choice,why);
    if(!result)result=GIWriteTree(&r,&working.index,next.workingTree);
    if(!result)result=GIWriteTree(&r,&staged.index,next.stagedTree);
    if(!result)result=GSWriteCommitObject(&r,next.workingTree,review->current,1,
        "GitHub Classic <stash@localhost>","GitHub Classic <stash@localhost>","0","+0000","GitHub Classic stash workspace",next.workspace);
    protectedPaths.changed=1;
    if(!result)result=GQToCommitProtected(&r,branch,review->current,next.workspace,inventory,count,&protectedPaths,eq,eqContext,&next.checkout,why);
    if(!result){
        if(SABIndexSame(&merged,&current)){indexWire=index->before;indexLength=index->beforeLength;ip=index->beforePresent;}
        else {result=GIEncode(&merged,&wire,&n);indexWire=wire;indexLength=n;}
    }
    if(!result)result=SABSeal(review,pop,branch,&next.checkout,indexWire,indexLength,ip);
    if(!result){GIFree(&next.checkout.index);next.checkout.index=merged;GIInit(&merged);}
    if(!result)result=GCEncode(&next.checkout.transaction,eq,eqContext,&encoded,&en);
    if(!result && en>l->stateBytes)result=GB_SPACE;
    if(!result)result=SABTick(&io);
    if(!result)result=SABFresh(&r,&review->removal);
    if(!result){next.pop=pop;next.encodedReadBytes=io.bounds.bytes;next.expandedReadBytes=io.bounds.expanded;next.readCount=io.bounds.reads;SAPlanFree(out);*out=next;SAPlanInit(&next);}
    free(paths.paths);free(branch);free(wire);free(encoded);TMDraftFree(&working);TMDraftFree(&staged);GRFree(&w);GRFree(&s);GIFree(&current);GIFree(&merged);SAPlanFree(&next);return result;
}
