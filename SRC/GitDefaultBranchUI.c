/* Local update from the last observed origin default. Included after network UI. */
typedef struct {
    FSSpec folder;GUDefaultChoice choice;
    char local[1025],repository[256],legacy[1025],routeKey[80];
    unsigned char current[20],*origin,*observation,*route;
    size_t originLength,observationLength,routeLength;
    short volume;long directory;
} DefaultReview;
static void DefaultReviewFree(DefaultReview *review) {
    free(review->origin);free(review->observation);free(review->route);free(review);
}
static int DefaultCheck(void *context,GSMacStore *store) {
    DefaultReview *review=(DefaultReview *)context;int result;
    if(!store->leaseHeld || store->volume!=review->volume || store->directory!=review->directory)return GS_CONFLICT;
    result=NetExact(store,"ghclient-origin",review->origin,review->originLength);
    if(!result)result=NetExact(store,"ghclient-default",review->observation,review->observationLength);
    if(!result && review->routeKey[0])result=NetExact(store,review->routeKey,review->route,review->routeLength);
    return result;
}
static void DefaultGuard(DefaultReview *review) {
    gUICheckout.precondition=review?DefaultCheck:NULL;gUICheckout.preconditionContext=review;
}
static int DefaultReadReview(DefaultReview *review) {
    CUIBranches branches;GSRepository reader;int result,closed;
    memset(&branches,0,sizeof(branches));result=CUILoadNamed(&branches,0);
    if(!result)result=CheckoutAttach(&review->folder);
    if(!result)result=GSMacEnter(&gUICheckout.store,0);
    if(!result){NetReader(&reader,&gUICheckout.store);result=NetHeadCheck(&reader,review->local,review->current,1);}
    if(!result)result=NetOriginRead(&gUICheckout.store,review->repository,review->legacy,&review->origin,&review->originLength);
    if(!result)result=NetRead(&gUICheckout.store,"ghclient-default",&review->observation,&review->observationLength);
    if(!result)result=GUDefaultParse(review->observation,review->observationLength,&review->choice.observed);
    if(!result)result=GUDefaultSelect(&reader,review->repository,review->legacy,(const char *const *)branches.names,branches.count,&review->choice);
    if(!result && review->choice.source!=GU_DEFAULT_REMOTE) {
        result=GUUpstreamKey(review->choice.reference,review->routeKey);
        if(!result)result=NetRead(&gUICheckout.store,review->routeKey,&review->route,&review->routeLength);
        if(result==GS_NOT_FOUND && review->choice.upstreamSource!=GU_UPSTREAM_EXPLICIT)result=0;
    }
    if(!result) {
        review->volume=gUICheckout.store.volume;review->directory=gUICheckout.store.directory;
        result=DefaultCheck(review,&gUICheckout.store);
    }
    closed=CheckoutRelease();if(!result)result=closed;CUIFree(&branches);return result;
}
static int DefaultRefreshConfirm(const DefaultReview *review,int updating) {
    OperationPrompt prompt;memset(&prompt,0,sizeof(prompt));
    prompt.title=updating?"Refresh Default Branch":"Fetch Default Branch";prompt.primary="Fetch Default";prompt.canPrimary=1;
    prompt.repository=review->repository;prompt.state=updating?"Default-branch information or history is unavailable locally.":"Refresh GitHub's default-branch name and fetched history.";
    prompt.primaryText="Contact GitHub to discover and fetch the origin default branch. The current branch's pull and push upstream stays in place.";
    prompt.secondaryText="Keep all local branches, upstream settings and working files in place.";
    prompt.footer=updating?"After fetching, a separate review asks before merging or advancing the current branch.":
        "Stores fetched history in origin's tracking branch. This action does not merge, switch branches or change working files.";
    prompt.labels[0]="Current local branch";prompt.values[0]=review->local;
    if(review->choice.observed.known){prompt.labels[1]="Last observed default";prompt.values[1]=review->choice.observed.branch;}
    return OperationConfirm(&prompt)==1;
}
static int DefaultRefresh(DefaultReview *review) {
    char branch[1025];unsigned char tip[20];int result,saved=0;
    if(!review->repository[0]) {
        Message("Origin Not Configured","Use Fetch Origin to configure this repository's origin, then try updating from its default branch.");return GS_NOT_FOUND;
    }
    if(gDone || !DefaultRefreshConfirm(review,1))return GS_NOT_FOUND;
    result=NetFetchDefaultFolder(&review->folder,review->repository,branch,tip,&saved);
    if(result)return result;
    free(review->origin);review->origin=NULL;review->originLength=0;
    free(review->observation);review->observation=NULL;review->observationLength=0;
    free(review->route);review->route=NULL;review->routeLength=0;review->routeKey[0]=0;
    memset(&review->choice,0,sizeof(review->choice));
    return DefaultReadReview(review);
}
static int DefaultConfirm(const DefaultReview *review,const MMPlan *plan) {
    OperationPrompt prompt;char repository[256],state[620],tip[41];
    memset(&prompt,0,sizeof(prompt));MUIOperationContext(&review->folder,plan->branch,plan->otherRef,repository,state,&prompt);
    GBOIDFormat(plan->tips+20,tip);
    prompt.title="Update from Default Branch";prompt.primary=plan->kind==MM_CONFLICT?"Review Conflicts":plan->kind==MM_FAST_FORWARD?"Advance Branch":"Merge Changes";prompt.canPrimary=1;
    prompt.labels[2]="Last observed default";prompt.values[2]=review->choice.observed.branch;
    prompt.labels[3]="Selected default commit";prompt.values[3]=tip;
    prompt.primaryText=plan->kind==MM_CONFLICT?"Start a saved merge review of the default branch. Save conflict choices, then Continue to finish the update.":
        plan->kind==MM_FAST_FORWARD?"Advance the current branch to the selected default-branch commit. No merge commit is created.":
        "Merge the selected default-branch history into the current branch. Both histories remain in the new commit.";
    prompt.secondaryText="Keep the current branch, staged changes and working files in place.";
    prompt.footer=review->choice.source==GU_DEFAULT_REMOTE?"Uses the last fetched origin default. This review makes no network request. Use Fetch Default Branch explicitly to refresh its remote history.":
        "Uses a local default branch and the last observed origin default name. This review makes no network request.";
    return OperationConfirm(&prompt)==1;
}
/* Explicit refresh is independent of selection among local default branches. */
static void FetchDefaultCommand(void) {
    DefaultReview *review;GSRepository reader;char branch[1025],status[768];unsigned char tip[20];int result,closed,saved=0;
    if(!gLocal || gBusy || gLocalBlocked || gMergePending)return;
    LocalRefresh();if(gDone || gLocalBlocked || !gWork.haveHead || !gWork.branch || strlen(gWork.branch)>1024)return;
    review=(DefaultReview *)calloc(1,sizeof(*review));if(!review){CheckoutError("Fetch Default Branch",GB_MEMORY);return;}
    review->folder=gWork.folder;strcpy(review->local,gWork.branch);memcpy(review->current,gWork.tip,20);
    result=CheckoutAttach(&review->folder);if(!result)result=GSMacEnter(&gUICheckout.store,0);
    if(!result){NetReader(&reader,&gUICheckout.store);result=NetHeadCheck(&reader,review->local,review->current,1);}
    if(!result)result=NetOriginRead(&gUICheckout.store,review->repository,review->legacy,&review->origin,&review->originLength);
    if(!result) {
        result=NetRead(&gUICheckout.store,"ghclient-default",&review->observation,&review->observationLength);
        if(result==GS_NOT_FOUND)result=0;
        else if(!result) {
            result=GUDefaultParse(review->observation,review->observationLength,&review->choice.observed);
            if(!result && strcmp(review->repository,review->choice.observed.repository))GUDefaultInit(&review->choice.observed);
        }
    }
    closed=CheckoutRelease();if(!result)result=closed;
    if(result==GS_NOT_FOUND){Message("Origin Not Configured","Use Fetch Origin to configure this repository's origin, then fetch its default branch.");goto done;}
    if(result){CheckoutError("Fetch Default Branch",result);goto done;}
    if(gDone || !DefaultRefreshConfirm(review,0)){if(!gDone)SetStatus("Default fetch cancelled. Local branches, upstream settings and working files were kept.");goto done;}
    result=NetFetchDefaultFolder(&review->folder,review->repository,branch,tip,&saved);
    if(result && !gDone)Message("Fetch Default Branch",gStatus);
done:
    snprintf(status,sizeof(status),"%s",gStatus);DefaultReviewFree(review);gBusy=0;
    if(!gDone){LocalRefresh();NetworkHeader();SetStatus(status);}
}
static void UpdateDefaultCommand(void) {
    DefaultReview *review;MMLimits limits;MSLimits sl;MMPlan plan;MSChoices none;GQError why;
    unsigned char oid[20];unsigned long macTime;MachineLocation location;long delta;
    char message[768],display[256],seconds[32];int result,closed,performed=0,started=0,advanced=0,refreshed=0;
    if(!gLocal || gBusy)return;
    if(gMergePending){if(MergeManage(&gWork.folder)){gMergePending=0;LocalRefresh();}else MergePaused();return;}
    LocalRefresh();if(gDone || gLocalBlocked || !gWork.haveHead || !gWork.branch || strlen(gWork.branch)>1024)return;
    review=(DefaultReview *)calloc(1,sizeof(*review));if(!review){CheckoutError("Update Default Branch",GB_MEMORY);return;}
    review->folder=gWork.folder;strcpy(review->local,gWork.branch);memcpy(review->current,gWork.tip,20);
    MMInit(&plan);MSChoicesInit(&none);NativeMergeLimits(&limits);MUIStateLimits(&sl);
    result=DefaultReadReview(review);
    if(result==GS_NOT_FOUND) {
        refreshed=1;result=DefaultRefresh(review);if(result==GS_NOT_FOUND)goto done;
    }
    if(result)goto failed;
prepare:
    result=CheckoutAttach(&review->folder);
    if(!result) {
        CheckoutBegin("Reviewing the local default-branch update... Escape cancels.");DefaultGuard(review);
        result=GXMergePrepare(&gUICheckout,review->local,review->current,review->choice.reference,review->choice.tip,0,'\n',&limits,&plan);
    }
    DefaultGuard(NULL);closed=CheckoutRelease();if(!result)result=closed;gBusy=0;
    if(result==GS_NOT_FOUND && !refreshed) {
        refreshed=1;result=DefaultRefresh(review);if(result==GS_NOT_FOUND)goto done;
        if(!result){MMFree(&plan);MMInit(&plan);goto prepare;}
    }
    if(result)goto failed;
    if(plan.kind==MM_UPTODATE){Message("Already Up to Date",refreshed?
        "The fetched default-branch history is already included in this branch. No working-file change was made.":
        "The selected default-branch history is already included in this branch. No network request or working-file change was made.");goto done;}
    if(plan.kind==MM_MULTIPLE_BASES || plan.kind==MM_UNRELATED) {
        Message("Default Update Needs More Support",plan.kind==MM_MULTIPLE_BASES?"These histories have multiple best common ancestors. This update needs recursive merge-base support and has not been started.":
            "These histories have no common ancestor. Updating unrelated histories is not enabled; your branches and files were kept.");goto done;
    }
    if(gDone || !DefaultConfirm(review,&plan))goto done;
    if(plan.kind!=MM_CONFLICT && plan.kind!=MM_FAST_FORWARD && !LocalAuthor(0))goto done;
    if(gDone)goto done;
    result=CheckoutAttach(&review->folder);
    if(!result) {
        CheckoutBegin(plan.kind==MM_CONFLICT?"Saving a recoverable default-branch review...":"Updating from the default branch...");DefaultGuard(review);performed=1;
        if(plan.kind==MM_CONFLICT) {
            result=MSPlanID(&plan,none.planID);if(!result)result=GXMergeBegin(&gUICheckout,&plan,&none,&sl,&why,&started);
        } else {
            GetDateTime(&macTime);ReadLocation(&location);delta=location.u.gmtDelta & 0x00ffffffL;if(delta & 0x00800000L)delta|=0xff000000L;
            snprintf(seconds,sizeof(seconds),"%lu",macTime-delta-2082844800UL);LocalDisplayPath(review->choice.observed.branch+11,display);
            snprintf(message,sizeof(message),"Update from default %.255s",display);
            result=GXMergeApply(&gUICheckout,&plan,gLocalIdentity,gLocalIdentity,seconds,"+0000",message,&why,&advanced,oid);
        }
    }
    DefaultGuard(NULL);closed=CheckoutRelease();if(!result)result=closed;
    if(result)goto failed;
    goto done;
failed:
    CheckoutError("Update Default Branch",result);
done:
    DefaultGuard(NULL);closed=CheckoutRelease();if(!result)result=closed;gBusy=0;
    MMFree(&plan);MSChoicesFree(&none);DefaultReviewFree(review);
    if(!gDone) {
        LocalRefresh();
        if(!result && performed) {
            if(started){if(gMergePending)SetStatus("Default-branch review paused. Reopen it to resolve conflicts, Continue or Abort.");}
            else SetStatus(advanced?"Default-branch update complete. The current branch and both Macintosh forks were updated locally.":"The selected default-branch history is already included. Working files were kept.");
        }
    }
}
