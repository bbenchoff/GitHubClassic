/* Developer-only real HFS merge runs on fresh GH Merge fixture media. */
#include <Processes.h>
static GXCheckout gMergeProbe;
static void NativeMergeLimits(MMLimits *l) {
    memset(l,0,sizeof(*l));l->stateBytes=4UL*1024*1024;
    l->graph.commits=4096;l->graph.parents=65536;l->graph.objectBytes=2UL*1024*1024;
    l->graph.encodedBytes=3UL*1024*1024;l->graph.readBytes=64UL*1024*1024;l->graph.reads=32768;
    l->tree.read.objectBytes=2UL*1024*1024;l->tree.read.encodedBytes=3UL*1024*1024;
    l->tree.read.readBytes=64UL*1024*1024;l->tree.read.reads=32768;
    l->tree.file.text.outputBytes=2UL*1024*1024;l->tree.file.text.conflicts=8192;l->tree.file.resourceBytes=2UL*1024*1024;
    l->tree.entries=8192;l->tree.depth=64;l->tree.pathBytes=1024;l->tree.nodes=8192;
    l->tree.retainedBytes=32UL*1024*1024;l->tree.pathChecks=1048576UL;
}
static void TestMergeCheckout(void) {
    static const char *names[6]={"Merge","Forward","Forced","Conflict","Stale","Current"};
    static const int kinds[6]={MM_MERGE,MM_FAST_FORWARD,MM_MERGE,MM_CONFLICT,MM_MERGE,MM_UPTODATE};
    ProcessSerialNumber psn;
    ProcessInfoRec process;
    Str255 processName;
    FSSpec app,folder;
    MMPlan plan;
    MMLimits limits;
    GQError why;
    unsigned char inputs[68],actual[20],resultOID[20];
    char application[256],path[256],before[41],incoming[41],after[41],status[256],*branch=NULL;
    const char *slot=NULL;
    FILE *log=NULL,*file;
    int i,error,prepared,applied,advanced,closed,expected,passed=0,readBack;
    OSErr osError;
    MMInit(&plan);NativeMergeLimits(&limits);memset(&process,0,sizeof(process));
    process.processInfoLength=sizeof(process);process.processName=processName;process.processAppSpec=&app;
    osError=GetCurrentProcess(&psn);
    if(!osError)osError=GetProcessInformation(&psn,&process);
    if(osError){SetStatus("Could not identify the native test application.");return;}
    memcpy(application,app.name+1,app.name[0]);application[app.name[0]]=0;
    if(!strcmp(application,"MacOS Toolbox PPC"))slot="PPC";
    else if(!strcmp(application,"MacOS Toolbox 68K"))slot="68K";
    else if(!strcmp(application,"640by480") || !strcmp(application,"Classic Github"))slot="FAT";
    if(!slot){SetStatus("Run a named exported development application for this fixture check.");return;}
    sprintf(path,"GH Merge:%s Merge Results",slot);file=fopen(path,"rb");
    if(file){fclose(file);SetStatus("These merge fixtures have already run. Stage fresh test media.");return;}
    log=fopen(path,"wb");
    if(!log){SetStatus("Mount fresh GH Merge development fixtures before running this check.");return;}
    fprintf(log,"GHClient native merge checkout v1\rapplication=%s\r",application);
#if defined(__MC68K__)
    fprintf(log,"application_slice=68K\r");
#else
    fprintf(log,"application_slice=PowerPC\r");
#endif
    gBusy=1;gCheckoutStopped=0;SetStatus("Checking merge, fast-forward and refusal paths on isolated HFS fixtures...");Draw();
    error=GXClose(&gMergeProbe);
    for(i=0;!error && i<6;++i) {
        memset(actual,0,20);memset(resultOID,0xa5,20);advanced=0;prepared=applied=closed=readBack=0;
        sprintf(path,"GH Merge:%s %s Inputs",slot,names[i]);file=fopen(path,"rb");
        if(!file){error=GS_NOT_FOUND;break;}
        if(fread(inputs,1,sizeof(inputs),file)!=sizeof(inputs) || fgetc(file)!=EOF || memcmp(inputs,"GHMERGE1",8))error=GS_FORMAT;
        if(fclose(file) && !error)error=GS_IO;
        if(error)break;
        sprintf(path,"GH Merge:%s %s",slot,names[i]);Pascal(path,processName);
        osError=FSMakeFSSpec(0,0,processName,&folder);
        if(osError){error=GS_IO;break;}
        prepared=GXAttach(&gMergeProbe,&folder);
        if(!prepared) {
            gMergeProbe.checkpoint=CheckoutProgress;
            prepared=GXMergePrepare(&gMergeProbe,"refs/heads/main",inputs+8,"refs/remotes/origin/topic",inputs+28,
                i==2?MM_NO_FF:0,'\n',&limits,&plan);
        }
        if(!prepared && i==4)prepared=GSUpdateRef(&gMergeProbe.raw,"refs/remotes/origin/topic",inputs+28,inputs+48);
        if(!prepared)applied=GXMergeApply(&gMergeProbe,&plan,"GHClient Test <test@example.invalid>",
            "GHClient Test <test@example.invalid>","1792018800","-0700","Native merge checkout",&why,&advanced,resultOID);
        if(gMergeProbe.state)readBack=GSHead(&gMergeProbe.raw,&branch,actual);else readBack=GS_IO;
        free(branch);branch=NULL;closed=GXClose(&gMergeProbe);
        expected=i==3?GI_UNMERGED:i==4?GS_CONFLICT:0;
        GBOIDFormat(inputs+8,before);GBOIDFormat(inputs+28,incoming);GBOIDFormat(actual,after);
        fprintf(log,"case=%s prepare=%d kind=%d apply=%d advanced=%d read=%d close=%d current=%s incoming=%s after=%s\r",
            names[i],prepared,plan.kind,applied,advanced,readBack,closed,before,incoming,after);
        if(prepared || applied!=expected || advanced!=(i<3) || readBack || closed || plan.kind!=kinds[i])error=GS_FORMAT;
        if(!error && memcmp(actual,i<3?resultOID:inputs+8,20))error=GS_FORMAT;
        if(!error)++passed;
        MMFree(&plan);
    }
    closed=GXClose(&gMergeProbe);if(!error)error=closed;
    fprintf(log,"result=%d\rpassed=%d\r",error,passed);if(fclose(log) && !error)error=GS_IO;
    MMFree(&plan);gBusy=0;
    if(error)snprintf(status,sizeof(status),"Native merge check stopped: %d; %d cases passed. Keep the fixture media for review.",error,passed);
    else snprintf(status,sizeof(status),"Native merge checks passed: %d cases. Merge, FF, forced merge, conflict, stale and current.",passed);
    SetStatus(status);Draw();
}
