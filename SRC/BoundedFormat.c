/* Integer/string formats used by TLS diagnostics. C89 with bounded writes.
   Unsupported formats fail instead of consuming arguments with the wrong ABI. */
#include <stddef.h>
#include <stdarg.h>
#include <string.h>
#include <limits.h>
typedef struct { char *p; size_t capacity,used; } FormatOutput;
static void FormatPut(FormatOutput *o,char c) {
    if(o->capacity && o->used<o->capacity-1) o->p[o->used]=c;
    ++o->used;
}
int mac_vsnprintf(char *out,size_t capacity,const char *format,va_list args) {
    FormatOutput o; int bad=0;
    o.p=out; o.capacity=capacity; o.used=0;
    if(capacity && !out) return -1;
    while(*format && !bad) {
        int width=0,precision=-1,left=0,zero=0,longarg=0,negative=0;
        unsigned long value=0; unsigned int base=10; char kind;
        char digits[40]; const char *text; size_t count=0,i;
        if(*format!='%') { FormatPut(&o,*format++); continue; }
        ++format;
        if(*format=='%') { FormatPut(&o,*format++); continue; }
        while(*format=='-' || *format=='0') {
            if(*format=='-') left=1;
            if(*format=='0') zero=1;
            ++format;
        }
        if(*format=='*') { width=va_arg(args,int); ++format; if(width==INT_MIN) {bad=1;break;} if(width<0) {left=1;width=-width;} }
        else while(*format>='0' && *format<='9') { width=width*10+(*format++-'0'); if(width>4096) {bad=1;break;} }
        if(bad || width>4096) {bad=1;break;}
        if(*format=='.') {
            ++format; precision=0;
            if(*format=='*') {precision=va_arg(args,int);++format;}
            else while(*format>='0' && *format<='9') {precision=precision*10+(*format++-'0');if(precision>4096) {bad=1;break;} }
        }
        if(bad || precision>4096) {bad=1;break;}
        if(*format=='l') {longarg=1;++format;}
        kind=*format; if(!kind) {bad=1;break;} ++format;
        if(kind=='s' && !longarg) {
            text=va_arg(args,const char*);if(!text) text="(null)";
            while(text[count] && (precision<0 || count<(size_t)precision)) ++count;
        } else if(kind=='c' && !longarg) {
            digits[0]=(char)va_arg(args,int);text=digits;count=1;
        } else if(kind=='d' || kind=='i' || kind=='u' || kind=='x' || kind=='X') {
            if(kind=='d' || kind=='i') {
                long signedValue=longarg ? va_arg(args,long) : (long)va_arg(args,int);
                negative=signedValue<0;value=negative ? 0UL-(unsigned long)signedValue : (unsigned long)signedValue;
            } else value=longarg ? va_arg(args,unsigned long) : (unsigned long)va_arg(args,unsigned int);
            if(kind=='x' || kind=='X') base=16;
            do {unsigned int d=(unsigned int)(value%base);digits[count++]=(char)(d<10 ? '0'+d : (kind=='X'?'A':'a')+d-10);value/=base;} while(value);
            for(i=0;i<count/2;++i) {char c=digits[i];digits[i]=digits[count-1-i];digits[count-1-i]=c;}
            text=digits;
        } else {bad=1;break;}
        if(negative && zero && !left) {FormatPut(&o,'-');negative=0;if(width) --width;}
        if(!left) for(i=count+(negative?1:0);i<(size_t)width;++i) FormatPut(&o,zero?'0':' ');
        if(negative) FormatPut(&o,'-');
        for(i=0;i<count;++i) FormatPut(&o,text[i]);
        if(left) for(i=count+(negative?1:0);i<(size_t)width;++i) FormatPut(&o,' ');
    }
    if(capacity) out[o.used<capacity ? o.used : capacity-1]=0;
    return bad || o.used>INT_MAX ? -1 : (int)o.used;
}
int mac_snprintf(char *out,size_t size,const char *format,...) {
    va_list args;int n;va_start(args,format);n=mac_vsnprintf(out,size,format,args);va_end(args);return n;
}
