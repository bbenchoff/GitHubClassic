/* Encrypted NV-seed reservation, not an entropy source. The seed MUST begin
   with unique trusted randomness. Whole-vault/VM rollback and cloning require
   fresh provisioning; counters/clock/device traits cannot supply entropy. */
#include "GHStartupVault.h"
#include "GHVault.h"
#include "ctr_drbg.h"
#include <stdlib.h>
#include <string.h>
static void SCPut(unsigned char *p,unsigned long n) {
    p[0]=(unsigned char)(n>>24);p[1]=(unsigned char)(n>>16);p[2]=(unsigned char)(n>>8);p[3]=(unsigned char)n;
}
static unsigned long SCWord(const unsigned char *p) {
    return ((unsigned long)p[0]<<24)|((unsigned long)p[1]<<16)|((unsigned long)p[2]<<8)|p[3];
}
static int SCCredentialShape(const void *credentials,size_t n) {
    return n && (!credentials || n<48 || memcmp(credentials,"GHAC0001",8));
}
int SCRead(const void *input,size_t length,SCView *out) {
    const unsigned char *p=(const unsigned char *)input;SCView view;unsigned long n;
    if(!p || !out || length<SC_HEADER || length>GV_MAX_PLAIN || memcmp(p,"GHSV0001",8) || SCWord(p+84))return SC_BAD;
    n=SCWord(p+80);if(n!=length-SC_HEADER || SCCredentialShape(p+SC_HEADER,(size_t)n))return SC_BAD;
    view.high=SCWord(p+8);view.low=SCWord(p+12);view.seed=p+16;
    view.credentials=n?p+SC_HEADER:NULL;view.credentialLength=(size_t)n;
    *out=view;return 0;
}
int SCPack(const unsigned char seed[64],unsigned long high,unsigned long low,
           const void *credentials,size_t n,unsigned char **out,size_t *outLength) {
    unsigned char *p;
    if(!seed || !out || !outLength || n>GV_MAX_PLAIN-SC_HEADER ||
       (!n && credentials) || SCCredentialShape(credentials,n))return SC_BAD;
    p=(unsigned char *)malloc(SC_HEADER+n);if(!p)return SC_MEMORY;
    memcpy(p,"GHSV0001",8);SCPut(p+8,high);SCPut(p+12,low);memcpy(p+16,seed,64);
    SCPut(p+80,(unsigned long)n);SCPut(p+84,0);if(n)memcpy(p+SC_HEADER,credentials,n);
    *out=p;*outLength=SC_HEADER+n;return 0;
}
typedef struct {const unsigned char *seed;size_t left;} SCSeed;
static int SCEntropy(void *context,unsigned char *out,size_t n) {
    SCSeed *input=(SCSeed *)context;
    if(n>input->left)return SC_BAD;
    memcpy(out,input->seed,n);input->seed+=n;input->left-=n;return 0;
}
static int SCNoReseed(void *context,unsigned char *out,size_t n) {
    (void)context;(void)out;(void)n;return SC_BAD;
}
static int SCMaterial(const unsigned char seed[64],unsigned long high,unsigned long low,unsigned char operation,const unsigned char *additional,unsigned char bytes[156]) {
    static const char domain[]="GitHub Classic startup vault v1";
    unsigned char personal[sizeof(domain)+9];SCSeed input;mbedtls_ctr_drbg_context random;int error;
    memcpy(personal,domain,sizeof(domain));SCPut(personal+sizeof(domain),high);SCPut(personal+sizeof(domain)+4,low);
    personal[sizeof(domain)+8]=operation;
    input.seed=seed;input.left=64;mbedtls_ctr_drbg_init(&random);
    mbedtls_ctr_drbg_set_entropy_len(&random,64);error=mbedtls_ctr_drbg_set_nonce_len(&random,0);
    if(!error)error=mbedtls_ctr_drbg_seed(&random,SCEntropy,&input,personal,sizeof(personal));
    random.f_entropy=SCNoReseed;random.p_entropy=NULL;
    if(!error && additional)error=mbedtls_ctr_drbg_update_ret(&random,additional,64);
    if(!error)error=mbedtls_ctr_drbg_random(&random,bytes,156);
    mbedtls_ctr_drbg_free(&random);GVClear(personal,sizeof(personal));GVClear(&input,sizeof(input));
    return error?SC_BAD:0;
}
static void SCBytesFree(unsigned char *bytes,size_t n) {if(bytes){GVClear(bytes,n);free(bytes);}}
void SCFree(SCReservation *out) {
    if(!out)return;
    SCBytesFree(out->encoded,out->length);GVClear(out,sizeof(*out));
}
static int SCCommit(const void *before,size_t bn,const unsigned char material[156],
                    unsigned long high,unsigned long low,const void *credentials,size_t cn,
                    const unsigned char key[32],const unsigned char *pass,size_t passLength,
                    SCPublish publish,void *context,GVProgress progress,void *progressContext,SCReservation *out) {
    SCReservation next;unsigned char *plain=NULL;size_t pn=0;int error;
    memset(&next,0,sizeof(next));next.high=high;next.low=low;
    error=SCPack(material,high,low,credentials,cn,&plain,&pn);
    if(!error) {
        if(before) {
            error=GVResealWithKey(before,bn,key,plain,pn,material+144,&next.encoded,&next.length);
            if(!error)memcpy(next.key,key,32);
        }else error=GVSealRemember(plain,pn,pass,passLength,material+128,GV_MIN_ROUNDS,
                                   progress,progressContext,&next.encoded,&next.length,next.key);
    }
    SCBytesFree(plain,pn);
    if(!error)error=publish(context,before,bn,next.encoded,next.length);
    if(!error){memcpy(next.tlsSeed,material+64,64);*out=next;memset(&next,0,sizeof(next));}
    SCFree(&next);return error;
}
int SCInitializeProgress(const unsigned char *pass,size_t passLength,const unsigned char bootstrap[64],
                    SCPublish publish,void *context,GVProgress progress,void *progressContext,SCReservation *out) {
    unsigned char material[156];int error;
    if(!pass || !passLength || !bootstrap || !publish || !out)return SC_BAD;
    memset(material,0,sizeof(material));error=SCMaterial(bootstrap,0,0,2,NULL,material);
    if(!error)error=SCCommit(NULL,0,material,0,1,NULL,0,NULL,pass,passLength,publish,context,progress,progressContext,out);
    GVClear(material,sizeof(material));return error;
}
int SCInitialize(const unsigned char *pass,size_t passLength,const unsigned char bootstrap[64],
                    SCPublish publish,void *context,SCReservation *out) {
    return SCInitializeProgress(pass,passLength,bootstrap,publish,context,NULL,NULL,out);
}
int SCMigrate(const void *before,size_t bn,const unsigned char key[32],const unsigned char bootstrap[64],
                    SCPublish publish,void *context,SCReservation *out) {
    unsigned char *plain=NULL,material[156];size_t pn=0;int error;
    if(!key || !bootstrap || !publish || !out)return SC_BAD;
    memset(material,0,sizeof(material));error=GVOpenWithKey(before,bn,key,&plain,&pn);
    if(!error && SCCredentialShape(plain,pn))error=SC_BAD;
    if(!error)error=SCMaterial(bootstrap,0,0,3,NULL,material);
    if(!error)error=SCCommit(before,bn,material,0,1,plain,pn,key,NULL,0,publish,context,NULL,NULL,out);
    SCBytesFree(plain,pn);GVClear(material,sizeof(material));return error;
}
static int SCChange(const void *before,size_t bn,const unsigned char key[32],int keep,const unsigned char *additional,
                    SCPublish publish,void *context,SCReservation *out) {
    unsigned char *plain=NULL,material[156];size_t pn=0;SCView view;int error;
    if(!key || !publish || !out)return SC_BAD;
    memset(material,0,sizeof(material));error=GVOpenWithKey(before,bn,key,&plain,&pn);
    if(!error)error=SCRead(plain,pn,&view);
    if(!error && view.high==0xffffffffUL && view.low==0xffffffffUL)error=SC_EXHAUSTED;
    if(!error) {
        error=SCMaterial(view.seed,view.high,view.low,keep?0:1,additional,material);
        if(!error) {
            if(view.low==0xffffffffUL){++view.high;view.low=0;}else ++view.low;
            error=SCCommit(before,bn,material,view.high,view.low,keep?view.credentials:NULL,
                keep?view.credentialLength:0,key,NULL,0,publish,context,NULL,NULL,out);
        }
    }
    SCBytesFree(plain,pn);GVClear(material,sizeof(material));return error;
}
int SCAdvance(const void *before,size_t bn,const unsigned char key[32],SCPublish publish,void *context,SCReservation *out) {
    return SCChange(before,bn,key,1,NULL,publish,context,out);
}
int SCAdvanceWithEntropy(const void *before,size_t bn,const unsigned char key[32],const unsigned char additional[64],
                    SCPublish publish,void *context,SCReservation *out) {
    if(!additional)return SC_BAD;
    return SCChange(before,bn,key,1,additional,publish,context,out);
}
int SCRemove(const void *before,size_t bn,const unsigned char key[32],SCPublish publish,void *context,SCReservation *out) {
    return SCChange(before,bn,key,0,NULL,publish,context,out);
}
int SCRekey(const void *before,size_t bn,const unsigned char key[32],const unsigned char *pass,size_t passLength,
                    const unsigned char random[GV_RANDOM],SCPublish publish,void *context,
                    GVProgress progress,void *progressContext,SCReservation *out) {
    unsigned char *plain=NULL;size_t pn=0;SCView view;SCReservation next;int result;
    if(!key || !pass || !passLength || !random || !publish || !out)return SC_BAD;
    memset(&next,0,sizeof(next));result=GVOpenWithKey(before,bn,key,&plain,&pn);
    if(!result)result=SCRead(plain,pn,&view);
    if(!result) {
        next.high=view.high;next.low=view.low;
        result=GVSealRemember(plain,pn,pass,passLength,random,GV_MIN_ROUNDS,
                             progress,progressContext,&next.encoded,&next.length,next.key);
    }
    if(!result)result=publish(context,before,bn,next.encoded,next.length);
    if(!result){*out=next;memset(&next,0,sizeof(next));}
    SCBytesFree(plain,pn);SCFree(&next);return result;
}
