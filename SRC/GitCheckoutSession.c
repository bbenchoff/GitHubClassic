#include "GitCheckoutSession.h"
#include <stdlib.h>
#include <string.h>

static GBWord GTWord(const unsigned char *p) {
    return ((GBWord)p[0] << 24) | ((GBWord)p[1] << 16) | ((GBWord)p[2] << 8) | p[3];
}
static void GTPut(unsigned char *p, GBWord n) {
    p[0] = (unsigned char)(n >> 24);
    p[1] = (unsigned char)(n >> 16);
    p[2] = (unsigned char)(n >> 8);
    p[3] = (unsigned char)n;
}
static void GTHash(const void *bytes, size_t n, unsigned char out[20]) {
    GBSHA1 h;
    GBSHA1Start(&h);
    GBSHA1Update(&h, bytes, n);
    GBSHA1Finish(&h, out);
}
static int GTBinding(const unsigned char *binding) {
    size_t i;
    if (!binding)
        return 0;
    for (i = 0; i < 32; ++i)
        if (binding[i])
            return 1;
    return 0;
}
int GTIntentEncode(const unsigned char binding[32], const GCTransaction *plan, GCEqual eq,
                   void *ctx, unsigned char **out, size_t *length) {
    GCTransaction initial;
    unsigned char *encoded = NULL, *bytes;
    size_t n;
    int result;
    if (!GTBinding(binding) || !plan || !out || !length)
        return GB_BAD;
    *out = NULL;
    *length = 0;
    initial = *plan;
    initial.phase = GC_PREPARE;
    initial.rollbackFrom = 0;
    result = GCEncode(&initial, eq, ctx, &encoded, &n);
    if (result)
        return result;
    if (n > (size_t)-1 - 64 || (GBWord)n != n) {
        free(encoded);
        return GB_SPACE;
    }
    bytes = (unsigned char *)malloc(n + 64);
    if (!bytes) {
        free(encoded);
        return GB_MEMORY;
    }
    memcpy(bytes, "GHCT0001", 8);
    memcpy(bytes + 8, binding, 32);
    GTPut(bytes + 40, (GBWord)n);
    memcpy(bytes + 44, encoded, n);
    GTHash(bytes, n + 44, bytes + n + 44);
    free(encoded);
    *out = bytes;
    *length = n + 64;
    return 0;
}
int GTIntentParse(const void *input, size_t length, const unsigned char binding[32], GCEqual eq,
                  void *ctx, GCTransaction *out) {
    const unsigned char *bytes = (const unsigned char *)input;
    unsigned char hash[20];
    GCTransaction t;
    size_t n;
    int result;
    if (!input || !out || !GTBinding(binding))
        return GB_BAD;
    if (length < 64 || memcmp(bytes, "GHCT0001", 8))
        return GS_FORMAT;
    n = (size_t)GTWord(bytes + 40);
    if (n != length - 64)
        return GS_FORMAT;
    GTHash(bytes, length - 20, hash);
    if (memcmp(hash, bytes + length - 20, 20))
        return GB_CHECKSUM;
    if (memcmp(bytes + 8, binding, 32))
        return GS_CONFLICT;
    GCInit(&t);
    result = GCParse(bytes + 44, n, eq, ctx, &t);
    if (!result && (t.phase != GC_PREPARE || t.rollbackFrom))
        result = GS_FORMAT;
    if (!result) {
        GCFree(out);
        *out = t;
        GCInit(&t);
    }
    GCFree(&t);
    return result;
}
static int GTIdle(GSRepository *r, GBWord *generation) {
    unsigned char *p = NULL, hash[20];
    size_t n = 0;
    int result;
    *generation = 0;
    result = r->read(r->context, "checkout-journal", &p, &n);
    if (result == GS_NOT_FOUND)
        return 0;
    if (!result) {
        if (n != 32 || memcmp(p, "GHCI0001", 8))
            result = GC_RECOVERY;
        else {
            GTHash(p, 12, hash);
            if (memcmp(hash, p + 12, 20))
                result = GB_CHECKSUM;
            else
                *generation = GTWord(p + 8);
        }
    }
    free(p);
    return result;
}
int GTWriteAllowed(GSRepository *r) {
    GBWord generation;
    unsigned char *p = NULL;
    size_t n = 0;
    int result;
    if (!r || !r->read)
        return GB_BAD;
    result = GTIdle(r, &generation);
    if (result)
        return result;
    result = r->read(r->context, "checkout-intent", &p, &n);
    free(p);
    return result == GS_NOT_FOUND ? 0 : result ? result : GC_RECOVERY;
}
int GTNormalWriteAllowed(GSRepository *r) {
    unsigned char *p=NULL;size_t n=0;int result=GTWriteAllowed(r);
    if(result)return result;
    result=r->read(r->context,"ghclient-merge",&p,&n);free(p);
    if(result!=GS_NOT_FOUND)return result?result:GT_MERGE_ACTIVE;
    p=NULL;n=0;result=r->read(r->context,"ghclient-rebase",&p,&n);free(p);
    return result==GS_NOT_FOUND?0:result?result:GT_REBASE_ACTIVE;
}
int GTNextGeneration(GSRepository *r,GBWord *out) {
    GBWord generation;int result;
    if(!out)return GB_BAD;
    result=GTWriteAllowed(r);if(!result)result=GTIdle(r,&generation);
    if(!result && generation==0xffffffffU)result=GB_SPACE;
    if(!result)*out=generation+1;
    return result;
}
static int GTValid(GSRepository *r, GCBackend *b, GTControl *c, const unsigned char binding[32],
                   GCEqual eq) {
    return r && r->read && r->replace && b && b->begin && b->inspect && b->prepare && b->move &&
           b->erase && b->finish && c && c->enter && c->leave && c->owner && c->guard &&
           GTBinding(binding) && eq;
}
/* Used only by the engine invocation below, inside the already-held lease. */
static int GTAlreadyLocked(void *context) {
    (void)context;
    return 0;
}
static void GTKeepLocked(void *context) { (void)context; }
static int GTCanonicalMatch(const GCTransaction *initial, const GCTransaction *active, GCEqual eq,
                            void *ctx) {
    GCTransaction t = *active;
    unsigned char *p = NULL;
    size_t n = 0;
    int result;
    t.phase = GC_PREPARE;
    t.rollbackFrom = 0;
    result = GCEncode(&t, eq, ctx, &p, &n);
    if (!result && (n != initial->originalLength || memcmp(p, initial->original, n)))
        result = GS_CONFLICT;
    free(p);
    return result;
}
typedef struct {
    GSRepository *raw;
    const GCTransaction *initial;
    const unsigned char *intent;
    size_t length;
    GCEqual equal;
    void *equalContext;
} GTRepository;
static int GTSessionRead(void *context, const char *key, unsigned char **p, size_t *n) {
    GTRepository *s = (GTRepository *)context;
    return s->raw->read(s->raw->context, key, p, n);
}
static int GTSessionReplace(void *context, const char *key, const void *old, size_t oldLength,
                            const void *bytes, size_t length) {
    GTRepository *s = (GTRepository *)context;
    GCTransaction t;
    unsigned char *intent = NULL, digest[20];
    const unsigned char *p = (const unsigned char *)bytes;
    size_t n = 0;
    int result = 0;
    if (!strcmp(key, "checkout-journal")) {
        result = s->raw->read(s->raw->context, "checkout-intent", &intent, &n);
        if (!result && (n != s->length || memcmp(intent, s->intent, n)))
            result = GS_CONFLICT;
        free(intent);
        if (result)
            return result;
        GCInit(&t);
        if (length == 32 && !memcmp(p, "GHCI0001", 8)) {
            GTHash(p, 12, digest);
            if (memcmp(digest, p + 12, 20))
                result = GB_CHECKSUM;
            else if (GTWord(p + 8) != s->initial->generation)
                result = GS_CONFLICT;
        } else {
            result = GCParse(bytes, length, s->equal, s->equalContext, &t);
            if (!result)
                result = GTCanonicalMatch(s->initial, &t, s->equal, s->equalContext);
        }
        GCFree(&t);
        if (result)
            return result;
    }
    return s->raw->replace(s->raw->context, key, old, oldLength, bytes, length);
}
static void GTSessionRepository(GTRepository *context, GSRepository *out, GSRepository *raw,
                                const GCTransaction *initial, const unsigned char *intent,
                                size_t length, GCEqual eq, void *equalContext) {
    context->raw = raw;
    context->initial = initial;
    context->intent = intent;
    context->length = length;
    context->equal = eq;
    context->equalContext = equalContext;
    out->context = context;
    out->read = GTSessionRead;
    out->replace = GTSessionReplace;
}
/* Never remove an intent while an active journal exists. While idle, only an
   unstarted next generation or this completed generation is eligible. Unknown
   guards remain untouched: they may belong to a legacy writer after completion. */
static int GTCleanup(GSRepository *r, GCBackend *b, GTControl *c, const GCTransaction *t,
                     const unsigned char *intent, size_t length) {
    unsigned char *p = NULL;
    size_t n = 0, i;
    GBWord generation;
    int result = GTIdle(r, &generation);
    if (result)
        return result;
    if (generation != t->generation &&
        (generation == 0xffffffffU || generation + 1 != t->generation))
        return GS_CONFLICT;
    result = r->read(r->context, "checkout-intent", &p, &n);
    if (result == GS_NOT_FOUND)
        return 0;
    if (!result && (n != length || memcmp(p, intent, n)))
        result = GS_CONFLICT;
    free(p);
    if (result)
        return result;
    for (i = 0; i < t->metadataCount; ++i) {
        result = c->guard(c->context, t->metadata[i].path, GT_VERIFY);
        if (result == GS_NOT_FOUND || result == GS_CONFLICT)
            continue;
        if (result)
            return result;
        result = c->guard(c->context, t->metadata[i].path, GT_RELEASE);
        if (result)
            return result;
    }
    return b->erase(b->context, "checkout-intent", intent, length);
}
static int GTStartCore(GSRepository *r, GCBackend *b, GTControl *c, const unsigned char binding[32],
            GCEqual eq, void *ctx, GBWord expected, const GCTransaction *plan) {
    GCTransaction candidate, t;
    GCBackend engine;
    GTRepository repositoryContext;
    GSRepository repository;
    unsigned char *intent = NULL;
    size_t length = 0, i;
    GBWord generation;
    int result, cleanup, closed, owner = 0;
    if (!GTValid(r, b, c, binding, eq) || !plan)
        return GB_BAD;
    GCInit(&t);
    result = c->enter(c->context);
    if (result)
        return result;
    result = GTWriteAllowed(r);
    if (!result)
        result = GTIdle(r, &generation);
    if (!result && generation == 0xffffffffU)
        result = GB_SPACE;
    if (!result && expected && generation + 1 != expected)
        result = GS_CONFLICT;
    if (result)
        goto done;
    candidate = *plan;
    candidate.generation = generation + 1;
    result = GTIntentEncode(binding, &candidate, eq, ctx, &intent, &length);
    if (!result)
        result = GTIntentParse(intent, length, binding, eq, ctx, &t);
    if (!result)
        result = c->owner(c->context, t.token);
    if (result)
        goto done;
    owner = 1;
    result = r->replace(r->context, "checkout-intent", NULL, 0, intent, length);
    for (i = 0; !result && i < t.metadataCount; ++i)
        result = c->guard(c->context, t.metadata[i].path, GT_CLAIM);
    if (!result) {
        engine = *b;
        engine.lock = GTAlreadyLocked;
        engine.unlock = GTKeepLocked;
        GTSessionRepository(&repositoryContext, &repository, r, &t, intent, length, eq, ctx);
        result = GCStart(&repository, &engine, eq, ctx, &t);
    }
    /* Also inspect after an uncertain callback failure: publication may have
       happened even if replace/erase reported an error after the mutation. */
    if (owner) {
        cleanup = GTCleanup(r, b, c, &t, intent, length);
        if (!result)
            result = cleanup;
    }
done:
    closed = c->leave(c->context);
    if (!result)
        result = closed;
    free(intent);
    GCFree(&t);
    return result;
}
int GTStart(GSRepository *r,GCBackend *b,GTControl *c,const unsigned char binding[32],
            GCEqual eq,void *ctx,const GCTransaction *plan) {
    return GTStartCore(r,b,c,binding,eq,ctx,0,plan);
}
int GTStartAtGeneration(GSRepository *r,GCBackend *b,GTControl *c,const unsigned char binding[32],
            GCEqual eq,void *ctx,GBWord expected,const GCTransaction *plan) {
    if(!expected)return GB_BAD;
    return GTStartCore(r,b,c,binding,eq,ctx,expected,plan);
}
int GTResume(GSRepository *r, GCBackend *b, GTControl *c, const unsigned char binding[32],
             GCEqual eq, void *ctx, int rollback) {
    GCTransaction initial, active;
    GCBackend engine;
    GTRepository repositoryContext;
    GSRepository repository;
    unsigned char *intent = NULL, *journal = NULL;
    size_t length = 0, n = 0, i;
    GBWord generation;
    int result, idle, found, closed, cleanup;
    if (!GTValid(r, b, c, binding, eq))
        return GB_BAD;
    GCInit(&initial);
    GCInit(&active);
    result = c->enter(c->context);
    if (result)
        return result;
    idle = GTIdle(r, &generation);
    if (idle && idle != GC_RECOVERY) {
        result = idle;
        goto done;
    }
    found = r->read(r->context, "checkout-intent", &intent, &length);
    if (found == GS_NOT_FOUND) {
        result = idle ? GC_RECOVERY : 0;
        goto done;
    }
    if (found) {
        result = found;
        goto done;
    }
    result = GTIntentParse(intent, length, binding, eq, ctx, &initial);
    if (!result)
        result = c->owner(c->context, initial.token);
    if (result)
        goto done;
    if (idle == GC_RECOVERY) {
        result = r->read(r->context, "checkout-journal", &journal, &n);
        if (!result)
            result = GCParse(journal, n, eq, ctx, &active);
        if (!result)
            result = GTCanonicalMatch(&initial, &active, eq, ctx);
        if (result)
            goto done;
        if (active.phase != GC_COMMITTED && active.phase != GC_ROLLED_BACK)
            for (i = 0; !result && i < initial.metadataCount; ++i) {
                result = c->guard(c->context, initial.metadata[i].path, GT_VERIFY);
                if (result == GS_NOT_FOUND)
                    result = GS_CONFLICT;
            }
        if (result)
            goto done;
        engine = *b;
        engine.lock = GTAlreadyLocked;
        engine.unlock = GTKeepLocked;
        GTSessionRepository(&repositoryContext, &repository, r, &initial, intent, length, eq, ctx);
        result = GCResume(&repository, &engine, eq, ctx, rollback);
    }
    cleanup = GTCleanup(r, b, c, &initial, intent, length);
    if (!result)
        result = cleanup;
done:
    closed = c->leave(c->context);
    if (!result)
        result = closed;
    free(intent);
    free(journal);
    GCFree(&initial);
    GCFree(&active);
    return result;
}
