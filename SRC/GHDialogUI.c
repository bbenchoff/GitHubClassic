/* Shared native visual vocabulary; included after GitLocalUI.c. Keep drawing
   state local so a user-item update cannot alter other controls or dialogs. */
static UserItemUPP gPreferencesArt;
static int gPreferencesSaved;
static UserItemUPP gDialogChrome;
static UserItemUPP gSettingsArt;
static UserItemUPP gAboutArt;
/* A single native user item supplies the typography and existing application
   artwork. Keep the button a standard Dialog Manager control; all text and
   separators remain legible when Color() selects the one-bit palette. */
static pascal void AboutDraw(DialogPtr dialog,short number) {
    GrafPtr previous;PenState pen;RGBColor foreground,background,white={65535,65535,65535};
    short font,size;Style face;Rect logo;Handle version;unsigned char *data;SignedByte state;
    char label[80];size_t length;
    (void)number;
    GetPort(&previous);SetPort((GrafPtr)dialog);
    font=((GrafPtr)dialog)->txFont;size=((GrafPtr)dialog)->txSize;face=((GrafPtr)dialog)->txFace;
    GetPenState(&pen);GetForeColor(&foreground);GetBackColor(&background);PenNormal();RGBBackColor(&white);
    Box(0,0,480,246,255,255,255);Box(0,0,480,112,244,240,248);
    SetRect(&logo,26,25,90,89);Color(0,0,0);
    if(gMonochrome)MonoIcon(128,&logo);else if(gWelcomeIcon)PlotCIcon(&logo,gWelcomeIcon);
    TextFont(gGeneva);TextSize(24);TextFace(bold);Color(80,40,104);
    MoveTo(110,55);DrawText("Classic Github",0,14);
    /* Read the same short version as Finder's Get Info; do not invent a second
       application version in the About artwork. */
    strcpy(label,"Development build");version=GetResource('vers',1);
    if(version && GetHandleSize(version)>=7) {
        state=HGetState(version);HLock(version);data=(unsigned char *)*version;length=data[6];
        if(length && length<32 && GetHandleSize(version)>=(long)(7+length)) {
            strcpy(label,"Version ");memcpy(label+8,data+7,length);
            strcpy(label+8+length,"  /  Development build");
        }
        HSetState(version,state);
    }
    Text(111,78,label,gGeneva,9,64,64,64);
    Color(80,40,104);MoveTo(0,112);LineTo(479,112);
    Text(28,145,"Git for your Macintosh.",gGeneva,12,0,0,0);
    Text(28,166,"System 7.5.3 target  /  68K + PowerPC",gGeneva,9,64,64,64);
    Text(28,202,"http://github.com/bbenchoff/GitHubClassic",gGeneva,12,0,0,0);
    Text(28,222,"MacSSL  /  Open Transport  /  QuickDraw",gGeneva,9,64,64,64);
    Color(96,96,96);MoveTo(28,240);LineTo(452,240);
    Text(28,269,"Open source. Built for classic Mac OS.",gGeneva,9,64,64,64);
    RGBForeColor(&foreground);RGBBackColor(&background);SetPenState(&pen);
    TextFont(font);TextSize(size);TextFace(face);SetPort(previous);
}
static int PrepareAboutArt(DialogPtr dialog) {
    short kind;Handle item;Rect r;
    if(!gAboutArt)gAboutArt=NewUserItemProc(AboutDraw);
    if(!gAboutArt)return 0;
    GetDialogItem(dialog,2,&kind,&item,&r);SetDialogItem(dialog,2,kind,(Handle)gAboutArt,&r);
    return 1;
}
static void DialogSection(short top,short bottom,const char *title) {
    Rect box;short width;
    SetRect(&box,18,top,530,bottom);Color(96,96,96);FrameRect(&box);
    TextFont(gGeneva);TextSize(9);TextFace(bold);width=TextWidth(title,0,(short)strlen(title));
    Box(28,(short)(top-6),(short)(40+width),(short)(top+7),255,255,255);
    Text(34,(short)(top+3),title,gGeneva,9,64,64,64);
}
static void DialogHeading(const Rect *r,const char *title,const char *subtitle) {
    Rect logo;
    SetRect(&logo,r->left,(short)(r->top+2),(short)(r->left+32),(short)(r->top+34));
    if(gMonochrome)MonoIcon(128,&logo);else if(gWelcomeIcon)PlotCIcon(&logo,gWelcomeIcon);
    TextFont(gGeneva);TextSize(18);TextFace(bold);Color(80,40,104);
    MoveTo((short)(r->left+46),(short)(r->top+19));DrawText(title,0,(short)strlen(title));
    if(subtitle && subtitle[0])Text((short)(r->left+46),(short)(r->top+36),subtitle,gGeneva,9,64,64,64);
}
/* Each dialog owns its title. No shared mutable title or modal refCon is used,
   so messages opened from another panel cannot overwrite its heading/state. */
static pascal void DialogChromeDraw(DialogPtr dialog,short number) {
    GrafPtr previous;PenState pen;RGBColor foreground;short font,size,kind;Style face;Rect r;Handle item;Str255 title;char name[256];
    GetPort(&previous);SetPort((GrafPtr)dialog);font=((GrafPtr)dialog)->txFont;size=((GrafPtr)dialog)->txSize;face=((GrafPtr)dialog)->txFace;
    GetPenState(&pen);GetForeColor(&foreground);PenNormal();GetDialogItem(dialog,number,&kind,&item,&r);
    if(r.bottom-r.top>2) {
        GetWTitle((WindowPtr)dialog,title);memcpy(name,title+1,title[0]);name[title[0]]=0;
        DialogHeading(&r,name,"");
    } else {Color(96,96,96);MoveTo(r.left,r.top);LineTo(r.right,r.top);}
    RGBForeColor(&foreground);SetPenState(&pen);TextFont(font);TextSize(size);TextFace(face);SetPort(previous);
}
static int PrepareDialogChrome(DialogPtr dialog,short heading,short footer) {
    short kind;Handle item;Rect r;
    if(!gDialogChrome)gDialogChrome=NewUserItemProc(DialogChromeDraw);
    if(!gDialogChrome)return 0;
    GetDialogItem(dialog,heading,&kind,&item,&r);SetDialogItem(dialog,heading,kind,(Handle)gDialogChrome,&r);
    GetDialogItem(dialog,footer,&kind,&item,&r);SetDialogItem(dialog,footer,kind,(Handle)gDialogChrome,&r);
    return 1;
}
/* First-install provisioning is a graphical file choice, never a typed HFS
   path. StartupReadInput owns validation; opening a picker consumes nothing. */
static int StartupChooseProvisionFile(FSSpec *spec) {
    DialogPtr d;StandardFileReply reply;short hit=0;int accepted=0;
    d=GetNewDialog(158,NULL,(WindowPtr)-1);if(!d)return 0;
    if(!PrepareDialogChrome(d,5,6))goto done;
    PrepareDialog(d,1,2);
    while(!gDone && hit!=1 && hit!=2)RunModalDialog(gDialogFilter,&hit);
    if(hit==1 && !gDone)accepted=1;
done:
    DisposeDialog(d);SetPort(gWindow);
    if(!accepted)return 0;
    ++gModalDepth;StandardGetFile(NULL,-1,NULL,&reply);--gModalDepth;
    if(gDone || !reply.sfGood || reply.sfIsFolder || reply.sfIsVolume)return 0;
    *spec=reply.sfFile;return 1;
}
static void DialogPlaceControl(DialogPtr dialog,short number,const Rect *bounds) {
    short kind;Handle item;Rect old;
    GetDialogItem(dialog,number,&kind,&item,&old);
    MoveControl((ControlHandle)item,bounds->left,bounds->top);
    SizeControl((ControlHandle)item,(short)(bounds->right-bounds->left),(short)(bounds->bottom-bounds->top));
    SetDialogItem(dialog,number,kind,item,bounds);
}
static pascal void PreferencesDraw(DialogPtr dialog,short number) {
    GrafPtr previous;PenState pen;RGBColor foreground;short font,size,kind;Style face;Rect r;Handle item;
    GetPort(&previous);SetPort((GrafPtr)dialog);font=((GrafPtr)dialog)->txFont;size=((GrafPtr)dialog)->txSize;face=((GrafPtr)dialog)->txFace;
    GetPenState(&pen);GetForeColor(&foreground);PenNormal();GetDialogItem(dialog,number,&kind,&item,&r);
    if(number==11)DialogHeading(&r,"Preferences","Classic Github on this Macintosh");
    else if(number==13) {
        DialogSection(70,164,"GITHUB ACCOUNT");DialogSection(184,308,"SAVED LOGIN");DialogSection(316,368,"COMMIT IDENTITY");
        Color(96,96,96);MoveTo(18,380);LineTo(530,380);
    } else if(number==5) {
        FitText(34,104,gUser[0]?gUser:"Not signed in",gGeneva,14,470,0,0,0);
        Text(34,122,gCredentials.bound?"Verified with GitHub.":"Connect an account to browse and synchronize repositories.",gGeneva,9,64,64,64);
    } else if(number==10) {
        Text(34,214,gPreferencesSaved<0?"Saved login needs attention":gPreferencesSaved?"Login saved on this Macintosh":"No login saved",gGeneva,12,0,0,0);
        Text(34,234,gPreferencesSaved<0?"The saved file could not be read. Your current session is unchanged.":gPreferencesSaved?"Encrypted in System Folder:Preferences. Unlock once per Macintosh session.":"Save your authorization to reconnect after quitting Classic Github.",gGeneva,9,64,64,64);
    } else if(number==6) {
        FitText(34,344,gLocal?(gLocalIdentity[0]?gLocalIdentity:"No commit author set for this repository."):
            "Choose a local repository to set its commit author.",gGeneva,9,302,0,0,0);
    }
    RGBForeColor(&foreground);SetPenState(&pen);TextFont(font);TextSize(size);TextFace(face);SetPort(previous);
}
static int PreparePreferencesArt(DialogPtr dialog,int saved) {
    short kind,i;Handle item;Rect r;Str255 label;static const short parts[]={5,6,10,11,13};
    if(!gPreferencesArt)gPreferencesArt=NewUserItemProc(PreferencesDraw);
    if(!gPreferencesArt)return 0;
    gPreferencesSaved=saved;
    for(i=0;i<5;++i){GetDialogItem(dialog,parts[i],&kind,&item,&r);SetDialogItem(dialog,parts[i],kind,(Handle)gPreferencesArt,&r);}
    GetDialogItem(dialog,2,&kind,&item,&r);Pascal(gUser[0]?"Change Account...":"Sign In...",label);SetControlTitle((ControlHandle)item,label);
    if(!gUser[0])HideDialogItem(dialog,3);
    return 1;
}
static pascal void SettingsDraw(DialogPtr dialog,short number) {
    GrafPtr previous;PenState pen;RGBColor foreground;short font,size;Style face;char name[256];
    GetPort(&previous);SetPort((GrafPtr)dialog);font=((GrafPtr)dialog)->txFont;size=((GrafPtr)dialog)->txSize;face=((GrafPtr)dialog)->txFace;
    GetPenState(&pen);GetForeColor(&foreground);PenNormal();
    if(number==4) {
        memcpy(name,gWork.folder.name+1,gWork.folder.name[0]);name[gWork.folder.name[0]]=0;
        FitText(34,88,name,gGeneva,14,480,0,0,0);
        Text(34,105,"Settings stored with this local repository",gGeneva,9,64,64,64);
    } else if(number==5) {
        FitText(34,149,gLocalIdentity[0]?gLocalIdentity:"No commit author set.",gGeneva,12,302,0,0,0);
        Text(34,173,"Recorded in commits; separate from GitHub sign-in.",gGeneva,9,64,64,64);
    } else if(number==6) {
        Text(34,229,"Filter untracked files in Changes.",gGeneva,12,0,0,0);
        Text(34,253,"Shared .gitignore; tracked files are unaffected.",gGeneva,9,64,64,64);
    } else if(number==10) {
        DialogSection(120,184,"COMMIT IDENTITY");DialogSection(200,264,"IGNORED FILES");DialogSection(280,344,"UPSTREAM BRANCH");
    } else if(number==11) {
        FitText(34,309,gUpstreamText[0]?gUpstreamText:"No upstream configured.",gGeneva,12,302,0,0,0);
        Text(34,333,"Fetch, Pull and Push target for this local branch.",gGeneva,9,64,64,64);
    }
    RGBForeColor(&foreground);SetPenState(&pen);TextFont(font);TextSize(size);TextFace(face);SetPort(previous);
}
static void PrepareSettingsArt(DialogPtr dialog) {
    short kind,i;Handle item;Rect r;static const short parts[]={4,5,6,10,11};
    PrepareDialogChrome(dialog,7,8);
    if(!gSettingsArt)gSettingsArt=NewUserItemProc(SettingsDraw);
    if(!gSettingsArt)return;
    for(i=0;i<5;++i){GetDialogItem(dialog,parts[i],&kind,&item,&r);SetDialogItem(dialog,parts[i],kind,(Handle)gSettingsArt,&r);}
}
/* A read-only native TextEdit view keeps long help/diagnostic messages usable.
   Copy still exports the complete original message, independent of scrolling. */
static TEHandle gMessageEdit;
static ControlHandle gMessageScroll;
static Rect gMessageWell,gMessageView;
static UserItemUPP gMessageArt;
static ControlActionUPP gMessageAction;
static ModalFilterUPP gMessageFilter;
static int gMessageScrollable;
static void MessageScrollSync(void) {
    long height=(long)(*gMessageEdit)->nLines*(*gMessageEdit)->lineHeight;
    short maximum=(short)(height>gMessageView.bottom-gMessageView.top?height-(gMessageView.bottom-gMessageView.top):0);
    SetControlMaximum(gMessageScroll,maximum);
    SetControlValue(gMessageScroll,(short)(gMessageView.top-(*gMessageEdit)->destRect.top));
    HiliteControl(gMessageScroll,maximum?0:255);
}
static void MessageMove(short delta) {
    TEPinScroll(0,delta,gMessageEdit);MessageScrollSync();
}
static pascal void MessageScrollAction(ControlHandle control,short part) {
    short delta=(*gMessageEdit)->lineHeight;
    (void)control;
    if(part!=kControlUpButtonPart && part!=kControlDownButtonPart && part!=kControlPageUpPart && part!=kControlPageDownPart)return;
    if(part==kControlPageUpPart || part==kControlPageDownPart)delta=(short)(gMessageView.bottom-gMessageView.top-delta);
    if(part==kControlDownButtonPart || part==kControlPageDownPart)delta=(short)-delta;
    MessageMove(delta);
}
static pascal void MessageBodyDraw(DialogPtr dialog,short number) {
    GrafPtr saved;RGBColor foreground,background,white={65535,65535,65535};PenState pen;
    (void)number;GetPort(&saved);SetPort((GrafPtr)dialog);GetForeColor(&foreground);GetBackColor(&background);GetPenState(&pen);
    PenNormal();RGBBackColor(&white);Color(255,255,255);PaintRect(&gMessageWell);Color(96,96,96);FrameRect(&gMessageWell);
    Color(0,0,0);TEUpdate(&gMessageView,gMessageEdit);if(gMessageScrollable)Draw1Control(gMessageScroll);
    SetPenState(&pen);RGBForeColor(&foreground);RGBBackColor(&background);SetPort(saved);
}
static pascal Boolean MessageBodyFilter(DialogPtr dialog,EventRecord *event,short *item) {
    GrafPtr saved;Point point;ControlHandle control;short part,before;unsigned char key;Boolean handled=false;
    GetPort(&saved);SetPort((GrafPtr)dialog);
    if(event->what==keyDown || event->what==autoKey) {
        key=(unsigned char)(event->message&charCodeMask);
        if(!(event->modifiers&cmdKey)) {
            if(key==30 || key==31){MessageMove((short)((key==30?1:-1)*(*gMessageEdit)->lineHeight));handled=true;}
            else if(key==11 || key==12){MessageMove((short)((key==11?1:-1)*(gMessageView.bottom-gMessageView.top-(*gMessageEdit)->lineHeight)));handled=true;}
            else if(key==1 || key==4){MessageMove(key==1?30000:-30000);handled=true;}
        }
    } else if(event->what==mouseDown) {
        point=event->where;GlobalToLocal(&point);part=FindControl(point,(WindowPtr)dialog,&control);
        if(part && control==gMessageScroll) {
            before=GetControlValue(control);
            if(part==kControlIndicatorPart){TrackControl(control,point,NULL);MessageMove((short)(before-GetControlValue(control)));}
            else TrackControl(control,point,gMessageAction);
            handled=true;
        }
    }
    if(handled)*item=0;else handled=NativeDialogFilter(dialog,event,item);
    SetPort(saved);return handled;
}
static int PrepareMessageBody(DialogPtr dialog,const char *text) {
    GrafPtr saved;short kind,font,size,lineHeight,rows,maximum,number;Style face;Handle item;Rect scroll,bounds;long height;
    size_t length=strlen(text),i,shown=0;char *display=NULL;
    if(gMessageEdit)return 0;
    if(!gMessageArt)gMessageArt=NewUserItemProc(MessageBodyDraw);
    if(!gMessageAction)gMessageAction=NewControlActionProc(MessageScrollAction);
    if(!gMessageFilter)gMessageFilter=NewModalFilterProc(MessageBodyFilter);
    if(!gMessageArt || !gMessageAction || !gMessageFilter)return 0;
    GetPort(&saved);SetPort((GrafPtr)dialog);font=((GrafPtr)dialog)->txFont;size=((GrafPtr)dialog)->txSize;face=((GrafPtr)dialog)->txFace;
    GetDialogItem(dialog,3,&kind,&item,&gMessageWell);gMessageView=gMessageWell;InsetRect(&gMessageView,6,5);scroll=gMessageWell;
    scroll.left=(short)(scroll.right-16);gMessageView.right=(short)(scroll.left-5);
    TextFont(gGeneva);TextSize(12);TextFace(0);gMessageEdit=TENew(&gMessageView,&gMessageView);
    gMessageScroll=NewControl((WindowPtr)dialog,&scroll,"\p",true,0,0,0,scrollBarProc,0);
    TextFont(font);TextSize(size);TextFace(face);
    if(!gMessageEdit || !gMessageScroll){if(gMessageEdit)TEDispose(gMessageEdit);gMessageEdit=NULL;SetPort(saved);return 0;}
    if(length<=32767) {
        /* TextEdit needs CR line breaks. Normalize its private display copy,
           leaving the caller's bytes intact for the complete Copy action. */
        if(memchr(text,'\n',length)) {
            display=malloc(length?length:1);
            if(!display){TEDispose(gMessageEdit);gMessageEdit=NULL;SetPort(saved);return 0;}
            for(i=0;i<length;++i) {
                if(text[i]=='\n' && i && text[i-1]=='\r')continue;
                display[shown++]=text[i]=='\n'?'\r':text[i];
            }
            TESetText(display,(long)shown,gMessageEdit);free(display);
        } else TESetText(text,(long)length,gMessageEdit);
    }
    height=(long)(*gMessageEdit)->nLines*(*gMessageEdit)->lineHeight;
    if(length>32767 || height>30000) {
        text="This message exceeds the native viewer's size limit. Choose Copy to export its complete text.";
        TESetText(text,(long)strlen(text),gMessageEdit);
    }
    TESetSelect(0,0,gMessageEdit);
    lineHeight=(*gMessageEdit)->lineHeight;
    if(lineHeight<1 || lineHeight>24){TEDispose(gMessageEdit);gMessageEdit=NULL;SetPort(saved);return 0;}
    maximum=(short)((gMessageWell.bottom-gMessageWell.top-10)/lineHeight);
    gMessageScrollable=(*gMessageEdit)->nLines>maximum;
    if(!gMessageScrollable) {
        /* Short notices use the full text width and no disabled scrollbar. */
        gMessageView.right=(short)(gMessageWell.right-6);
        (*gMessageEdit)->viewRect.right=(*gMessageEdit)->destRect.right=gMessageView.right;
        TECalText(gMessageEdit);HideControl(gMessageScroll);
    }
    rows=(*gMessageEdit)->nLines;if(rows<3)rows=3;if(rows>maximum)rows=maximum;
    gMessageWell.bottom=(short)(gMessageWell.top+rows*lineHeight+10);
    gMessageView.bottom=(short)(gMessageView.top+rows*lineHeight);
    (*gMessageEdit)->viewRect=(*gMessageEdit)->destRect=gMessageView;
    scroll.bottom=gMessageWell.bottom;
    MoveControl(gMessageScroll,scroll.left,scroll.top);SizeControl(gMessageScroll,(short)(scroll.right-scroll.left),(short)(scroll.bottom-scroll.top));
    SetDialogItem(dialog,3,kind,(Handle)gMessageArt,&gMessageWell);
    GetDialogItem(dialog,5,&kind,&item,&bounds);bounds.top=(short)(gMessageWell.bottom+10);bounds.bottom=(short)(bounds.top+1);
    SetDialogItem(dialog,5,kind,item,&bounds);
    for(number=1;number<=2;++number) {
        GetDialogItem(dialog,number,&kind,&item,&bounds);bounds.top=(short)(gMessageWell.bottom+22);bounds.bottom=(short)(bounds.top+22);
        DialogPlaceControl(dialog,number,&bounds);
    }
    SizeWindow((WindowPtr)dialog,(short)(((WindowPtr)dialog)->portRect.right-((WindowPtr)dialog)->portRect.left),(short)(gMessageWell.bottom+64),false);
    MessageScrollSync();SetPort(saved);return 1;
}
static void CloseMessageBody(void) {
    if(gMessageEdit)TEDispose(gMessageEdit);
    gMessageEdit=NULL;gMessageScroll=NULL;gMessageScrollable=0;
}

/* Shared single-selection list. Keep List Manager's signed-short data Handle
   bounded while the caller's immutable vector remains the selection authority. */
#define CHOICE_PAGE 32
#define CHOICE_MAX 16384
typedef int (*ChoiceRowProc)(void *,size_t,char[256],char[256],char[256]);
/* A false result disables approval. A caller may still supply a readable
   label/name/reason for a protected row, such as the current branch. */
typedef char *(*ChoiceDetailsProc)(void *,size_t);
typedef struct {
    void *context;
    size_t count,initial;
    ChoiceRowProc row;
    ChoiceDetailsProc details;
    const char *title,*description,*action,*noun;
} NativeChoices;
typedef struct {short action,selection,list,status,previous,next,details;} ChoiceItems;
static const NativeChoices *gChoices;
static ChoiceItems gChoiceItems;
static ListHandle gChoiceList;
static UserItemUPP gChoiceArt;
static ModalFilterUPP gChoiceFilter;
static size_t gChoiceFirst,gChoiceSelected;
static short gChoiceRows,gChoiceVisibleRows;
static int gChoiceValid,gChoiceActionEnabled;
static char gChoiceName[256],gChoiceSearch[128];
static unsigned long gChoiceSearchTick;
static void ChoiceEnable(DialogPtr d,short number,int enabled) {
    Handle item;short kind;Rect bounds;
    GetDialogItem(d,number,&kind,&item,&bounds);
    if((unsigned char)(*(ControlHandle)item)->contrlHilite!=(enabled?0:255))HiliteControl((ControlHandle)item,enabled?0:255);
}
static pascal void ChoiceDraw(DialogPtr d,short number) {
    GrafPtr previous;PenState pen;RGBColor foreground;short font,size,kind;Style face;Rect bounds;Handle item;char label[280];
    if(!gChoiceList)return;
    GetPort(&previous);SetPort((GrafPtr)d);font=((GrafPtr)d)->txFont;size=((GrafPtr)d)->txSize;face=((GrafPtr)d)->txFace;
    GetPenState(&pen);GetForeColor(&foreground);PenNormal();GetDialogItem(d,number,&kind,&item,&bounds);
    if(number==gChoiceItems.selection) {
        Box(bounds.left,bounds.top,bounds.right,bounds.bottom,255,255,255);
        snprintf(label,sizeof(label),"Selected: %s",gChoiceName);
        FitText(bounds.left,(short)(bounds.top+14),label,gGeneva,12,(short)(bounds.right-bounds.left),0,0,0);
    } else {
        Color(0,0,0);FrameRect(&bounds);TextFont(gGeneva);TextSize(12);TextFace(0);LUpdate(((WindowPtr)d)->visRgn,gChoiceList);
    }
    RGBForeColor(&foreground);SetPenState(&pen);TextFont(font);TextSize(size);TextFace(face);SetPort(previous);
}
static void ChoiceEraseView(void) {
    Rect view=(*gChoiceList)->rView;RGBColor foreground;
    GetForeColor(&foreground);Box(view.left,view.top,view.right,view.bottom,255,255,255);RGBForeColor(&foreground);
}
static void ChoiceSelect(DialogPtr d,size_t selected) {
    Cell cell;size_t first,at;short rows,i;char label[256],name[256],info[256],status[256];int changed=selected!=gChoiceSelected;
    if(selected>=gChoices->count)return;
    SetPort((GrafPtr)d);first=selected/CHOICE_PAGE*CHOICE_PAGE;
    if(first!=gChoiceFirst || !gChoiceRows) {
        LSetDrawingMode(false,gChoiceList);if(gChoiceRows)LDelRow(gChoiceRows,0,gChoiceList);
        rows=(short)(gChoices->count-first>CHOICE_PAGE?CHOICE_PAGE:gChoices->count-first);
        LAddRow(rows,0,gChoiceList);gChoiceFirst=first;gChoiceRows=rows;
        for(i=0;i<rows;++i) {
            at=first+i;label[0]=name[0]=info[0]=0;
            if(!gChoices->row(gChoices->context,at,label,name,info) && !label[0])strcpy(label,"[Unavailable]");
            cell.h=0;cell.v=i;LSetCell(label,(short)strlen(label),cell,gChoiceList);
        }
        /* LUpdate draws cells, but does not erase old cells below a shorter
           replacement page. Clear only on page replacement, never on idle. */
        ChoiceEraseView();LSetDrawingMode(true,gChoiceList);changed=1;
    } else if(gChoiceSelected>=first && gChoiceSelected<first+(size_t)gChoiceRows) {
        cell.h=0;cell.v=(short)(gChoiceSelected-first);LSetSelect(false,cell,gChoiceList);
    }
    gChoiceSelected=selected;cell.h=0;cell.v=(short)(selected-first);LSetSelect(true,cell,gChoiceList);
    if(changed)LAutoScroll(gChoiceList);
    label[0]=info[0]=gChoiceName[0]=0;
    gChoiceValid=gChoices->row(gChoices->context,selected,label,gChoiceName,info);
    snprintf(status,sizeof(status),"%s %lu-%lu of %lu\r%.180s",gChoices->noun,(unsigned long)(first+1),
        (unsigned long)(first+gChoiceRows),(unsigned long)gChoices->count,info);
    DialogText(d,gChoiceItems.status,status);ChoiceEnable(d,gChoiceItems.action,gChoiceValid && gChoiceActionEnabled);
    ChoiceEnable(d,gChoiceItems.details,gChoiceValid && gChoices->details!=NULL);
    ChoiceEnable(d,gChoiceItems.previous,first>0);ChoiceEnable(d,gChoiceItems.next,first+gChoiceRows<gChoices->count);
    ChoiceDraw(d,gChoiceItems.selection);ChoiceDraw(d,gChoiceItems.list);
}
static void ChoiceRefresh(DialogPtr d) {
    char status[256],label[256],name[256],info[256];Cell cell;short i;
    /* Persistent callers can change row status without changing page or
       selection. Refresh cells explicitly, retaining the current viewport. */
    if(gChoiceRows) {
        SetPort((GrafPtr)d);LSetDrawingMode(false,gChoiceList);
        for(i=0;i<gChoiceRows;++i) {
            label[0]=name[0]=info[0]=0;
            if(!gChoices->row(gChoices->context,gChoiceFirst+i,label,name,info) && !label[0])strcpy(label,"[Unavailable]");
            cell.h=0;cell.v=i;LSetCell(label,(short)strlen(label),cell,gChoiceList);
        }
        LSetDrawingMode(true,gChoiceList);
    }
    if(gChoices->count){ChoiceSelect(d,gChoiceSelected<gChoices->count?gChoiceSelected:0);return;}
    gChoiceSelected=(size_t)-1;gChoiceValid=0;strcpy(gChoiceName,"No selection");
    snprintf(status,sizeof(status),"%s: none",gChoices->noun);DialogText(d,gChoiceItems.status,status);
    ChoiceEnable(d,gChoiceItems.action,0);ChoiceEnable(d,gChoiceItems.details,0);
    ChoiceEnable(d,gChoiceItems.previous,0);ChoiceEnable(d,gChoiceItems.next,0);
    ChoiceDraw(d,gChoiceItems.selection);ChoiceDraw(d,gChoiceItems.list);
}
static int ChoicePrefix(const char *name,const char *prefix) {
    unsigned char a,b;
    while(*prefix){a=(unsigned char)*name++;b=(unsigned char)*prefix++;if(a>='A' && a<='Z')a+=32;if(b>='A' && b<='Z')b+=32;if(a!=b)return 0;}
    return 1;
}
static pascal Boolean ChoiceFilter(DialogPtr d,EventRecord *event,short *hit) {
    Point point;Rect bounds;Handle item;Cell cell;short kind;size_t next=gChoiceSelected,i,n;unsigned char key;int doubled;
    char label[256],name[256],info[256];
    *hit=0;
    if(event->what==nullEvent || event->what==activateEvt)ChoiceEnable(d,gChoiceItems.action,gChoiceValid && gChoiceActionEnabled);
    if(event->what==mouseDown) {
        SetPort((GrafPtr)d);point=event->where;GlobalToLocal(&point);GetDialogItem(d,gChoiceItems.list,&kind,&item,&bounds);
        if(PtInRect(point,&bounds)) {
            TextFont(gGeneva);TextSize(12);TextFace(0);doubled=LClick(point,event->modifiers,gChoiceList);cell.h=cell.v=0;
            if(LGetSelect(true,&cell,gChoiceList))ChoiceSelect(d,gChoiceFirst+cell.v);
            else ChoiceSelect(d,gChoiceSelected); /* Retain one explicit selection on a blank click. */
            if(doubled){if(gChoiceValid && gChoiceActionEnabled)*hit=gChoiceItems.action;else SysBeep(1);}return true;
        }
    }
    if(event->what==keyDown || event->what==autoKey) {
        key=(unsigned char)(event->message&charCodeMask);
        if(!(event->modifiers&cmdKey)) {
            if(key==13 || key==3) {
                if(!gChoices->count)return NativeDialogFilter(d,event,hit);
                if(gChoiceValid && gChoiceActionEnabled)*hit=gChoiceItems.action;else SysBeep(1);
                return true;
            }
            if(!gChoices->count && (key==30 || key==31 || key==1 || key==4 || key==11 || key==12 || key==8 || (key>=32 && key!=127))) {
                SysBeep(1);return true;
            }
            if(key==30)next=next?next-1:0;
            else if(key==31){if(next+1<gChoices->count)++next;}
            else if(key==1)next=0;
            else if(key==4)next=gChoices->count-1;
            else if(key==11)next=next>(size_t)gChoiceVisibleRows?next-gChoiceVisibleRows:0;
            else if(key==12)next=gChoices->count-1-next>(size_t)gChoiceVisibleRows?next+gChoiceVisibleRows:gChoices->count-1;
            else if((key>=32 && key!=127) || key==8) {
                if((unsigned long)(event->when-gChoiceSearchTick)>60)gChoiceSearch[0]=0;
                gChoiceSearchTick=event->when;n=strlen(gChoiceSearch);
                if(key==8){if(n)gChoiceSearch[--n]=0;}
                else if(n+1<sizeof(gChoiceSearch)){gChoiceSearch[n++]=(char)key;gChoiceSearch[n]=0;}
                if(n) {
                    for(i=0;i<gChoices->count;++i) {
                        label[0]=name[0]=info[0]=0;
                        if(gChoices->row(gChoices->context,i,label,name,info)) {
                            const char *leaf=strrchr(name,'/');
                            if(ChoicePrefix(name,gChoiceSearch) || (leaf && ChoicePrefix(leaf+1,gChoiceSearch))){next=i;break;}
                        }
                    }
                    if(i==gChoices->count)SysBeep(1);
                }
            } else return NativeDialogFilter(d,event,hit);
            ChoiceSelect(d,next);return true;
        }
    }
    return NativeDialogFilter(d,event,hit);
}
static void ChoiceDetails(void) {
    char *text;
    if(!gChoiceValid || !gChoices->details)return;
    text=gChoices->details(gChoices->context,gChoiceSelected);
    if(!text){SysBeep(1);return;}
    Message("Selection Details",text);free(text);
}
static char *ChoiceIdentityDetails(const char *heading,const char *identity) {
    const unsigned char *p=(const unsigned char *)identity;char *text,*out;size_t length=strlen(identity),prefix=strlen(heading);
    /* Match checkout's complete path bound. Escaping can exceed TextEdit's
       viewer limit; Message still offers Copy of the complete owned text. */
    if(length>16384 || prefix>1024)return NULL;
    text=(char *)malloc(prefix+length*4+128);if(!text)return NULL;
    strcpy(text,heading);strcat(text,"\r\rFull identity (non-ASCII/control bytes and backslash use \\xNN escapes):\r\r");out=text+strlen(text);
    while(*p){if(*p>=32 && *p<127 && *p!='\\')*out++=(char)*p;else {sprintf(out,"\\x%02X",(unsigned)*p);out+=4;}++p;}
    *out=0;return text;
}
static void ChoiceDispose(void) {
    if(gChoiceList)LDispose(gChoiceList);gChoiceList=NULL;gChoices=NULL;gChoiceRows=0;
    if(gChoiceArt)DisposeRoutineDescriptor((UniversalProcPtr)gChoiceArt);
    if(gChoiceFilter)DisposeRoutineDescriptor((UniversalProcPtr)gChoiceFilter);
    gChoiceArt=NULL;gChoiceFilter=NULL;
}
/* Bind the same list controller into a picker or a persistent workflow panel.
   The caller owns its dialog, default/cancel action and immutable row vector. */
static int ChoiceCreate(DialogPtr d,const NativeChoices *choices,const ChoiceItems *items,int actionEnabled) {
    Rect bounds,view,data;Point cellSize;short kind;Handle item;
    if(gChoices || !choices || !choices->row || choices->count>CHOICE_MAX)return 0;
    gChoiceArt=NewUserItemProc(ChoiceDraw);gChoiceFilter=NewModalFilterProc(ChoiceFilter);
    gChoiceItems=*items;gChoiceActionEnabled=actionEnabled;
    gChoices=choices;gChoiceRows=0;gChoiceFirst=gChoiceSelected=(size_t)-1;gChoiceValid=0;gChoiceSearch[0]=gChoiceName[0]=0;gChoiceSearchTick=0;
    GetDialogItem(d,items->list,&kind,&item,&bounds);view=bounds;InsetRect(&view,1,1);view.right-=15;
    SetRect(&data,0,0,1,0);cellSize.h=(short)(view.right-view.left);cellSize.v=20;
    gChoiceVisibleRows=(short)((view.bottom-view.top)/cellSize.v);if(gChoiceVisibleRows<1)gChoiceVisibleRows=1;
    SetPort((GrafPtr)d);TextFont(gGeneva);TextSize(12);TextFace(0);
    gChoiceList=LNew(&view,&data,cellSize,0,(WindowPtr)d,false,false,false,true);
    if(!gChoiceArt || !gChoiceFilter || !gChoiceList){ChoiceDispose();return 0;}
    (*gChoiceList)->selFlags=lOnlyOne;(*gChoiceList)->listFlags|=lDoVAutoscroll;
    SetDialogItem(d,items->list,kind,(Handle)gChoiceArt,&bounds);
    GetDialogItem(d,items->selection,&kind,&item,&bounds);SetDialogItem(d,items->selection,kind,(Handle)gChoiceArt,&bounds);
    return 1;
}
static size_t PickNativeChoice(const NativeChoices *choices) {
    const ChoiceItems items={1,4,5,7,9,10,11};
    DialogPtr d;Rect bounds;short kind,hit=0;Handle item;Str255 title;size_t selected=(size_t)-1;
    if(!choices || !choices->count)return selected;
    d=GetNewDialog(148,NULL,(WindowPtr)-1);if(!d)return selected;
    Pascal(choices->title,title);SetWTitle((WindowPtr)d,title);PrepareDialogChrome(d,6,8);DialogText(d,3,choices->description);
    GetDialogItem(d,1,&kind,&item,&bounds);Pascal(choices->action,title);SetControlTitle((ControlHandle)item,title);
    if(!ChoiceCreate(d,choices,&items,1)){DisposeDialog(d);SetPort(gWindow);return selected;}
    PrepareDialog(d,1,2);ChoiceSelect(d,choices->initial<choices->count?choices->initial:0);DrawDialog(d);
    while(!gDone) {
        hit=0;RunModalDialog(gChoiceFilter,&hit);if(hit==2 || gDone)break;
        if(hit==1 && gChoiceValid){selected=gChoiceSelected;break;}
        if(hit==9 && gChoiceFirst)ChoiceSelect(d,gChoiceFirst-CHOICE_PAGE);
        if(hit==10 && gChoiceFirst+gChoiceRows<choices->count)ChoiceSelect(d,gChoiceFirst+CHOICE_PAGE);
        if(hit==11){ChoiceDetails();SetPort((GrafPtr)d);InvalRect(&((WindowPtr)d)->portRect);}
    }
    ChoiceDispose();
    DisposeDialog(d);SetPort(gWindow);return selected;
}
/* Recovery/merge/push decisions share a deliberate, contextual panel. Its
   strings belong to the caller until it closes; read-only Details is nested. */
typedef struct {
    const char *title,*repository,*state,*primary,*primaryText,*secondary,*secondaryText,*footer;
    const char *labels[4],*values[4];
    int canPrimary,canSecondary;
} OperationPrompt;
static const OperationPrompt *gOperationPrompt;
static UserItemUPP gOperationArt;
static void OperationWrapped(const Rect *r,const char *text,short font,short size) {
    size_t at=0,start,end,space;short y=(short)(r->top+size+1),step=(short)(size+3),width=(short)(r->right-r->left);
    if(!text)return;TextFont(font);TextSize(size);TextFace(0);Color(0,0,0);
    while(text[at] && y<r->bottom) {
        start=at;end=at;space=at;
        while(text[end] && text[end]!='\r' && TextWidth(text+start,0,(short)(end-start+1))<=width) {
            if(text[end]==' ')space=end;++end;
        }
        if(!text[end] || text[end]=='\r')at=text[end]?end+1:end;
        else if(space>start){end=space;at=space+1;}else {if(end==start)++end;at=end;}
        MoveTo(r->left,y);DrawText(text+start,0,(short)(end-start));y=(short)(y+step);
    }
}
static pascal void OperationDraw(DialogPtr dialog,short number) {
    const OperationPrompt *p=gOperationPrompt;GrafPtr previous;PenState pen;RGBColor foreground;
    short font,size,kind;Style face;Rect r,text;Handle item;const char *heading,*body;char line[700],*second;
    if(!p)return;GetPort(&previous);SetPort((GrafPtr)dialog);font=((GrafPtr)dialog)->txFont;
    size=((GrafPtr)dialog)->txSize;face=((GrafPtr)dialog)->txFace;GetPenState(&pen);GetForeColor(&foreground);PenNormal();
    GetDialogItem(dialog,number,&kind,&item,&r);Box(r.left,r.top,r.right,r.bottom,255,255,255);
    if(number==4) {
        Text(r.left,(short)(r.top+10),"REPOSITORY",gGeneva,9,64,64,64);
        FitText(r.left,(short)(r.top+30),p->repository?p->repository:"(unavailable)",gGeneva,14,(short)(r.right-r.left),0,0,0);
    } else if(number==5) {
        snprintf(line,sizeof(line),"%s",p->state?p->state:"");second=strchr(line,'\r');if(second)*second++=0;
        FitText(r.left,(short)(r.top+13),line,gGeneva,12,(short)(r.right-r.left),0,0,0);
        if(second)FitText(r.left,(short)(r.top+30),second,gGeneva,12,(short)(r.right-r.left),0,0,0);
    }
    else if(number==6 || number==7) {
        heading=number==6?p->primary:p->secondary?p->secondary:"Cancel";
        body=number==6?p->primaryText:p->secondaryText?p->secondaryText:"Return to the previous window. Nothing is approved.";
        if(heading) {
            Text(r.left,(short)(r.top+12),heading,gGeneva,12,39,72,132);
            text=r;text.top=(short)(r.top+20);OperationWrapped(&text,body,gGeneva,9);
        }
    } else OperationWrapped(&r,p->footer,gGeneva,9);
    RGBForeColor(&foreground);SetPenState(&pen);TextFont(font);TextSize(size);TextFace(face);SetPort(previous);
}
static char *OperationDetails(const OperationPrompt *p) {
    char *parts[5],*text=NULL;const char *bodies[5];size_t i,length=64;
    memset(parts,0,sizeof(parts));parts[0]=ChoiceIdentityDetails("Repository",p->repository?p->repository:"(unavailable)");
    if(!parts[0])goto done;
    for(i=0;i<4;++i)if(p->labels[i] && p->values[i]) {
        parts[i+1]=ChoiceIdentityDetails(p->labels[i],p->values[i]);if(!parts[i+1])goto done;
    }
    bodies[0]=p->title;bodies[1]=p->state;bodies[2]=p->primaryText;bodies[3]=p->secondaryText;bodies[4]=p->footer;
    for(i=0;i<5;++i){if(parts[i])length+=strlen(parts[i])+4;if(bodies[i])length+=strlen(bodies[i])+4;}
    text=(char *)malloc(length);if(!text)goto done;text[0]=0;
    for(i=0;i<5;++i)if(bodies[i]){strcat(text,bodies[i]);strcat(text,"\r\r");}
    for(i=0;i<5;++i)if(parts[i]){strcat(text,parts[i]);strcat(text,"\r\r");}
done:
    for(i=0;i<5;++i)free(parts[i]);return text;
}
static int OperationConfirm(const OperationPrompt *p) {
    DialogPtr dialog;short hit=0,i,kind;Handle item;Rect r;Str255 title;char *details;int answer=0;
    if(gDone || gOperationPrompt || !p || !p->title || !p->primary)return 0;
    dialog=GetNewDialog(142,NULL,(WindowPtr)-1);if(!dialog)return 0;
    if(!gOperationArt)gOperationArt=NewUserItemProc(OperationDraw);
    if(!gOperationArt || !PrepareDialogChrome(dialog,10,11))goto done;
    Pascal(p->title,title);SetWTitle((WindowPtr)dialog,title);CheckoutButtonTitle(dialog,1,p->primary);
    CheckoutEnable(dialog,1,p->canPrimary);if(p->secondary){CheckoutButtonTitle(dialog,2,p->secondary);CheckoutEnable(dialog,2,p->canSecondary);}else HideDialogItem(dialog,2);
    for(i=4;i<=8;++i){GetDialogItem(dialog,i,&kind,&item,&r);SetDialogItem(dialog,i,kind,(Handle)gOperationArt,&r);}
    gOperationPrompt=p;PrepareDialog(dialog,3,3);DrawDialog(dialog);
    while(!gDone) {
        hit=0;RunModalDialog(gDialogFilter,&hit);if(gDone || hit==3)break;
        if(hit==1 && p->canPrimary){answer=1;break;}
        if(hit==2 && p->secondary && p->canSecondary){answer=2;break;}
        if(hit==9) {
            details=OperationDetails(p);if(details){Message("Operation Details",details);free(details);}else SysBeep(1);
            SetPort((GrafPtr)dialog);InvalRect(&((WindowPtr)dialog)->portRect);
        }
    }
done:
    gOperationPrompt=NULL;DisposeDialog(dialog);SetPort(gWindow);return gDone?0:answer;
}
