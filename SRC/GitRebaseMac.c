/* Included at the end of GitCheckoutMac.c to reuse its private GT adapter. */
void GXRebaseReviewInit(GXRebaseReview *r){memset(r,0,sizeof(*r));}
void GXRebaseReviewFree(GXRebaseReview *r){RQFree(&r->review);GXRebaseReviewInit(r);}
static int GXRebaseProgress(void *context){return GXPoint((GXCheckout *)context,"replay branch");}
int GXRebasePrepare(GXCheckout *x,const char *branch,const unsigned char head[20],const char *ontoRef,
    const unsigned char onto[20],char newline,const RQLimits *limits,GXRebaseReview *destination) {
    GXRebaseReview *next;GSRepository reader;unsigned char binding[32];int result,closed;
    if(!x || !x->state || !destination || x->store.leaseHeld || x->held.haveData || x->held.haveResource)return GB_BAD;
    next=(GXRebaseReview *)calloc(1,sizeof(*next));if(!next)return GB_MEMORY;reader=x->raw;reader.read=GXMergeRead;
    result=GSMacEnter(&x->store,0);if(!result)result=GXCheckCondition(x);
    if(!result)result=GXBinding(x,NULL,next->repositoryBinding);
    if(!result)result=RQPrepare(&reader,branch,head,ontoRef,onto,newline,limits,GXRebaseProgress,x,&next->review);
    if(!result)result=GXBinding(x,NULL,binding);
    if(!result && memcmp(binding,next->repositoryBinding,32))result=GS_CONFLICT;
    if(!result)result=GXCheckCondition(x);
    if(x->store.leaseHeld){closed=GSMacLeave(&x->store);if(!result)result=closed;}
    if(!result){GXRebaseReviewFree(destination);*destination=*next;GXRebaseReviewInit(next);}GXRebaseReviewFree(next);free(next);return result;
}
int GXRebaseApply(GXCheckout *x,const GXRebaseReview *review,const char *committer,const char *seconds,
    const char *zone,GQError *why,GXRebaseOutcome *destination) {
    RQCheckout *candidate;GFInventory inventory;GPMap map;GXState *s;GSRepository reader,r;GCBackend backend;GTControl control;
    GXRebaseOutcome next;unsigned char binding[32];size_t i;int result,closed;
    if(!x || !x->state || !review || !destination || x->store.leaseHeld || x->held.haveData || x->held.haveResource)return GB_BAD;
    candidate=(RQCheckout *)calloc(1,sizeof(*candidate));if(!candidate)return GB_MEMORY;
    if(why)memset(why,0,sizeof(*why));s=x->state;GXClearPlan(s);GFInit(&inventory);GPInit(&map);memset(&next,0,sizeof(next));
    reader=x->raw;reader.read=GXMergeRead;result=GSMacEnter(&x->store,0);if(!result)result=GXCheckCondition(x);
    if(!result)result=GXBinding(x,NULL,binding);
    if(!result && memcmp(binding,review->repositoryBinding,32))result=GS_CONFLICT;
    if(!result)result=RQRecheck(&reader,&review->review);
    if(!result)result=GPLoad(&reader,GWMacNameEqual,NULL,&map);
    if(!result)result=GFCollect(&x->root,&map,&inventory,&x->lastError);
    if(!result)result=RQBuildCheckout(&reader,&review->review,inventory.items,inventory.count,GWMacNameEqual,NULL,
        committer,seconds,zone,GXRebaseProgress,x,candidate,why);
    if(!result) {
        next.kind=candidate->kind;next.completed=candidate->replay.completed;memcpy(next.tip,candidate->replay.tip,20);
        next.conflicts=candidate->replay.conflict.merge.conflicts;memcpy(next.conflict,candidate->replay.conflict.candidate,20);
        for(i=0;i<candidate->replay.completed;++i)next.droppedSignatures|=candidate->replay.items[i].droppedSignatures;
    }
    if(!result && candidate->kind==RQ_READY)result=GXStorage(x,1);
    if(!result)result=GXCheckCondition(x);
    if(!result && candidate->kind==RQ_READY) {
        x->store.recoveryOwner=1;s->handedLease=1;s->starting=1;s->candidate=&candidate->checkout;s->inventory=&inventory;
        GXCallbacks(x,&r,&backend,&control);result=GTStart(&r,&backend,&control,s->binding,GWMacNameEqual,NULL,&candidate->checkout.transaction);
        if(!result)next.advanced=1;
    }
    s->candidate=NULL;s->inventory=NULL;s->starting=0;s->handedLease=0;
    if(x->store.leaseHeld && !x->held.haveData && !x->held.haveResource){closed=GSMacLeave(&x->store);if(!result)result=closed;}
    if(!result)*destination=next;GPFree(&map);GFFree(&inventory);RQCheckoutFree(candidate);free(candidate);return result;
}
