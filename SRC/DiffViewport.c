#include "DiffViewport.h"
unsigned long DVColumns(const char *bytes, size_t length) {
    unsigned long columns = 0;
    size_t i;
    if (!bytes || length > 32000) return 0;
    for (i = 0; i < length; ++i)
        columns += bytes[i] == '\t' ? 8 - columns % 8 : 1;
    return columns;
}
size_t DVSlice(const char *bytes, size_t length, unsigned long first, size_t columns,
                  char *output, size_t capacity) {
    unsigned long column = 0, width, j;
    size_t i, used = 0;
    unsigned char ch;
    if (!output || !capacity) return 0;
    output[0] = 0;
    if (!bytes || length > 32000) return 0;
    for (i = 0; i < length && used < columns && used < capacity - 1; ++i) {
        ch = (unsigned char)bytes[i];
        width = ch == '\t' ? 8 - column % 8 : 1;
        if (ch == '\t') ch = ' ';
        else if (ch < 32 || ch == 127) ch = '?';
        for (j = 0; j < width; ++j, ++column)
            if (column >= first && used < columns && used < capacity - 1)
                output[used++] = (char)ch;
    }
    output[used] = 0;
    return used;
}
unsigned long DVUnit(unsigned long maximum) {
    return maximum ? 1 + (maximum - 1) / 32767UL : 1;
}
short DVMaximum(unsigned long maximum) {
    unsigned long unit = DVUnit(maximum);
    return (short)(maximum / unit + (maximum % unit != 0));
}
short DVValue(unsigned long position, unsigned long maximum) {
    if (position >= maximum) return DVMaximum(maximum);
    return (short)(position / DVUnit(maximum));
}
unsigned long DVPosition(short value, unsigned long maximum) {
    unsigned long position;
    if (value <= 0) return 0;
    if (value >= DVMaximum(maximum)) return maximum;
    position = (unsigned long)value * DVUnit(maximum);
    return position > maximum ? maximum : position;
}
