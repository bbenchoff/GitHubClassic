#include "GitRebaseCheckpoint.h"
#include <stdlib.h>
#include <string.h>

void RKInit(RKState *s){memset(s,0,sizeof(*s));}
void RKFree(RKState *s) {
    size_t i;RZFree(&s->replay);free(s->workIndex.bytes);free(s->index.bytes);free(s->mapping.bytes);
    for(i=0;i<s->affectedCount;++i)free(s->affected[i]);free(s->affected);free(s->original);RKInit(s);
}
static int RKLimits(const RZLimits *l) {
    return l && l->records.bytes && l->records.bytes<=16777216UL && l->records.pathBytes && l->records.pathBytes<=4096 && l->records.paths && l->records.paths<=65536UL;
}
static int RKZero(const unsigned char *p,size_t n){size_t i;for(i=0;i<n;++i)if(p[i])return 0;return 1;}
static int RKIndex(const MSBytes *b,int stages) {
    GIIndex index;size_t i;int result;GIInit(&index);result=GIParse(b->bytes,b->length,&index);
    for(i=0;!result && i<index.count;++i) {
        if(index.entries[i].extended&0x6000)result=GI_UNSUPPORTED;
        else if(!stages && (index.entries[i].flags&0x3000))result=GI_UNMERGED;
    }
    GIFree(&index);return result;
}
static int RKShape(const RKState *s,const RZLimits *l,GPEqual eq,void *ctx) {
    const MSBytes *b;size_t i,n;char key[96];GPMap map;int result;
    if(!s || !RKLimits(l) || !eq || RKZero(s->workspace,20) || !s->affectedCount || s->affectedCount>l->records.paths || !s->affected)return GB_BAD;
    for(i=0;i<3;++i){b=i==0?&s->workIndex:i==1?&s->index:&s->mapping;if(b->present!=1 || !b->bytes || !b->length)return GB_BAD;if(b->length>l->records.bytes)return GB_SPACE;}
    result=RKIndex(&s->workIndex,0);if(!result)result=RKIndex(&s->index,1);GPInit(&map);
    if(!result)result=GPParse(s->mapping.bytes,s->mapping.length,eq,ctx,&map);GPFree(&map);if(result)return result;
    for(i=0;i<s->affectedCount;++i){if(!s->affected[i])return GB_BAD;n=strlen(s->affected[i]);if(n>l->records.pathBytes)return GB_SPACE;
        if(GIMacMetadataPath(s->affected[i],key) || (i && strcmp(s->affected[i-1],s->affected[i])>=0))return GB_BAD;}
    return 0;
}
static int RKAdd(size_t *total,size_t n,size_t maximum){if(n>maximum-*total)return GB_SPACE;*total+=n;return 0;}
static void RKWord(unsigned char *p,GBWord v){p[0]=(unsigned char)(v>>24);p[1]=(unsigned char)(v>>16);p[2]=(unsigned char)(v>>8);p[3]=(unsigned char)v;}
static GBWord RKGet(const unsigned char *p){return ((GBWord)p[0]<<24)|((GBWord)p[1]<<16)|((GBWord)p[2]<<8)|p[3];}
static void RKPut(unsigned char *p,size_t *at,const void *data,size_t n){RKWord(p+*at,(GBWord)n);*at+=4;if(n)memcpy(p+*at,data,n);*at+=n;}
int RKEncode(const RKState *s,const RZLimits *l,GPEqual eq,void *ctx,unsigned char **out,size_t *length) {
    unsigned char *inner=NULL,*raw=NULL,digest[20];size_t in=0,total=68,at=28,i,n;const MSBytes *b;GBSHA1 hash;int result;
    if(!out || !length)return GB_BAD;result=RKShape(s,l,eq,ctx);if(result)return result;
    result=RZEncode(&s->replay,l,eq,ctx,&inner,&in);if(result)return result;
    if(total>l->records.bytes)result=GB_SPACE;if(!result)result=RKAdd(&total,in,l->records.bytes);
    for(i=0;!result && i<3;++i){b=i==0?&s->workIndex:i==1?&s->index:&s->mapping;result=RKAdd(&total,b->length,l->records.bytes);}
    for(i=0;!result && i<s->affectedCount;++i){n=strlen(s->affected[i]);result=RKAdd(&total,4+n,l->records.bytes);}
    if(!result){raw=(unsigned char *)malloc(total);if(!raw)result=GB_MEMORY;}
    if(!result) {
        memcpy(raw,"GHRW0001",8);memcpy(raw+8,s->workspace,20);RKPut(raw,&at,inner,in);
        for(i=0;i<3;++i){b=i==0?&s->workIndex:i==1?&s->index:&s->mapping;RKPut(raw,&at,b->bytes,b->length);}
        RKWord(raw+at,(GBWord)s->affectedCount);at+=4;for(i=0;i<s->affectedCount;++i)RKPut(raw,&at,s->affected[i],strlen(s->affected[i]));
        if(at!=total-20)result=GS_FORMAT;
        else {GBSHA1Start(&hash);GBSHA1Update(&hash,raw,at);GBSHA1Finish(&hash,digest);memcpy(raw+at,digest,20);*out=raw;*length=total;raw=NULL;}
    }
    free(raw);free(inner);return result;
}
typedef struct {const unsigned char *p;size_t n,at;int error;} RKReader;
static GBWord RKReadWord(RKReader *r) {
    GBWord word;if(r->error)return 0;if(r->n-r->at<4){r->error=GS_FORMAT;return 0;}word=RKGet(r->p+r->at);r->at+=4;return word;
}
static const unsigned char *RKField(RKReader *r,size_t *n) {
    const unsigned char *p;GBWord word=RKReadWord(r);if(r->error)return NULL;if(word>r->n-r->at){r->error=GS_FORMAT;return NULL;}
    p=r->p+r->at;r->at+=word;*n=word;return p;
}
int RKParse(const void *raw,size_t n,const RZLimits *l,GPEqual eq,void *ctx,RKState *out) {
    RKState next;RKReader r;GBSHA1 hash;unsigned char digest[20];const unsigned char *p=(const unsigned char *)raw,*field;MSBytes *b;size_t i,fn=0;GBWord count;int result;
    if(!raw || !out || !RKLimits(l) || !eq || n<68)return GB_BAD;if(n>l->records.bytes)return GB_SPACE;
    if(memcmp(raw,"GHRW0001",8))return GS_FORMAT;GBSHA1Start(&hash);GBSHA1Update(&hash,raw,n-20);GBSHA1Finish(&hash,digest);if(memcmp(digest,p+n-20,20))return GB_CHECKSUM;
    RKInit(&next);memcpy(next.workspace,p+8,20);r.p=p;r.at=28;r.n=n-20;r.error=0;
    field=RKField(&r,&fn);result=r.error;if(!result)result=RZParse(field,fn,l,eq,ctx,&next.replay);
    for(i=0;!result && i<3;++i) {
        field=RKField(&r,&fn);result=r.error;if(result)break;b=i==0?&next.workIndex:i==1?&next.index:&next.mapping;
        b->bytes=(unsigned char *)malloc(fn?fn:1);if(!b->bytes)result=GB_MEMORY;else {if(fn)memcpy(b->bytes,field,fn);b->length=fn;b->present=1;}
    }
    count=RKReadWord(&r);if(!result)result=r.error;
    if(!result && (!count || count>l->records.paths || count>(r.n-r.at)/5))result=GS_FORMAT;
    if(!result){next.affected=(char **)calloc(count,sizeof(*next.affected));if(!next.affected)result=GB_MEMORY;else next.affectedCount=count;}
    for(i=0;!result && i<next.affectedCount;++i) {
        field=RKField(&r,&fn);result=r.error;if(!result && (!fn || fn>l->records.pathBytes || memchr(field,0,fn)))result=GS_FORMAT;
        if(!result){next.affected[i]=(char *)malloc(fn+1);if(!next.affected[i])result=GB_MEMORY;else {memcpy(next.affected[i],field,fn);next.affected[i][fn]=0;}}
    }
    if(!result && r.at!=r.n)result=GS_FORMAT;if(!result)result=RKShape(&next,l,eq,ctx);
    if(!result){next.original=(unsigned char *)malloc(n);if(!next.original)result=GB_MEMORY;else {memcpy(next.original,raw,n);next.originalLength=n;}}
    if(!result){RKFree(out);*out=next;RKInit(&next);}RKFree(&next);return result;
}
