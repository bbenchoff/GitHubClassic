#include "GitRebaseProof.h"
#include <stdlib.h>
#include <string.h>

static int RYWrite(void *context,const char *key,const void *old,size_t on,const void *next,size_t nn) {
    GOReader *state=(GOReader *)context;
    if(strncmp(key,"objects/",8) || old || on || !next || !nn)return GB_BAD;
    return state->source->replace(state->source->context,key,NULL,0,next,nn);
}
static int RYPlan(const RSStep *s,const char *branch,const char *ontoRef,MMPlan *p,unsigned char id[20]) {
    int result=RZStepID(s,branch,ontoRef,id);if(result)return result;
    memset(p,0,sizeof(*p));p->kind=MM_CONFLICT;p->branch=(char *)branch;p->otherRef=(char *)ontoRef;
    memcpy(p->tips,s->candidate,20);memcpy(p->tips+20,s->onto,20);memcpy(p->trees,s->trees,60);p->haveBase=1;p->newline=s->merge.newline;
    p->files=s->merge;p->limits.tree=s->merge.limits;p->limits.stateBytes=s->merge.limits.read.objectBytes;return 0;
}
int RYMakeProof(GSRepository *source,const RSStep *step,const char *branch,const char *ontoRef,const TMResolution *input,size_t count,
    const RZLimits *limits,GDProgress progress,void *context,MSChoices *out,unsigned char proof[20]) {
    MMPlan plan;MSChoices next;GOReader state;GSRepository writer;unsigned char identity[20],oid[20],*raw=NULL;size_t n=0;int result;
    if(!source || !source->read || !source->replace || !out || !proof || (count && !input))return GB_BAD;
    result=RYPlan(step,branch,ontoRef,&plan,identity);if(result)return result;
    result=GOReadStart(source,&step->merge.limits.read,progress,context,&state,&writer);if(result)return result;
    writer.replace=RYWrite;MSChoicesInit(&next);result=MSMakeChoices(&writer,&plan,input,count,progress,context,&next);
    if(!result){memcpy(next.planID,identity,20);result=RZChoicesEncode(&next,limits,&raw,&n);}
    if(!result && n>step->merge.limits.read.objectBytes)result=GB_SPACE;
    if(!result)result=GSPutObject(&writer,"blob",raw,n,oid);
    if(!result && progress)result=progress(context);
    if(!result){MSChoicesFree(out);*out=next;MSChoicesInit(&next);memcpy(proof,oid,20);}
    free(raw);MSChoicesFree(&next);return result;
}
int RYReadChoices(GSRepository *source,const RSStep *step,const char *branch,const char *ontoRef,const MSChoices *choices,
    GDProgress progress,void *context,MSValues *out) {
    MMPlan plan;MSChoices borrowed;GOReader state;GSRepository reader;unsigned char identity[20];int result;
    if(!source || !source->read || !choices || !out)return GB_BAD;
    result=RYPlan(step,branch,ontoRef,&plan,identity);if(result)return result;
    if(memcmp(identity,choices->planID,20))return GS_CONFLICT;
    borrowed=*choices;result=MSPlanID(&plan,borrowed.planID);
    if(!result)result=GOReadStart(source,&step->merge.limits.read,progress,context,&state,&reader);
    if(!result)result=MSReadChoices(&reader,&plan,&borrowed,progress,context,out);return result;
}
int RYLoadProof(GSRepository *source,const RSStep *step,const char *branch,const char *ontoRef,const unsigned char proof[20],
    const RZLimits *limits,GDProgress progress,void *context,MSChoices *out,MSValues *values) {
    MSChoices next;MSValues loaded;GOReader state;GSRepository reader;unsigned char *raw=NULL;size_t n=0;char type[7];int result;
    if(!source || !source->read || !step || !proof || !out || !values)return GB_BAD;
    result=GOReadStart(source,&step->merge.limits.read,progress,context,&state,&reader);if(result)return result;
    MSChoicesInit(&next);MSValuesInit(&loaded);result=GSGetObject(&reader,proof,type,&raw,&n);
    if(!result && strcmp(type,"blob"))result=GS_FORMAT;
    if(!result)result=RZChoicesParse(raw,n,limits,&next);
    if(!result)result=RYReadChoices(&reader,step,branch,ontoRef,&next,progress,context,&loaded);
    if(!result && progress)result=progress(context);
    if(!result){MSChoicesFree(out);*out=next;MSChoicesInit(&next);MSValuesFree(values);*values=loaded;MSValuesInit(&loaded);}
    free(raw);MSChoicesFree(&next);MSValuesFree(&loaded);return result;
}
int RYBuildWorkspace(GSRepository *source,const RSStep *step,const char *branch,const char *ontoRef,const MSChoices *choices,
    GDProgress progress,void *context,MSWorkspace *out) {
    MMPlan plan;MSChoices borrowed;GOReader state;GSRepository reader;unsigned char identity[20];int result;
    if(!source || !source->read || !choices || !out)return GB_BAD;
    result=RYPlan(step,branch,ontoRef,&plan,identity);if(result)return result;
    if(memcmp(identity,choices->planID,20))return GS_CONFLICT;
    borrowed=*choices;result=MSPlanID(&plan,borrowed.planID);
    if(!result)result=GOReadStart(source,&step->merge.limits.read,progress,context,&state,&reader);
    if(!result)result=MSBuildWorkspace(&reader,&plan,&borrowed,progress,context,out);return result;
}
