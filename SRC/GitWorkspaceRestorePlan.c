/* General completed-discard inverse. Read-only planning; GC/GT publishes it. */
#include "GitWorkspaceRestore.h"
#include "GitCheckoutSession.h"
#include "GitHistory.h"
#include <stdlib.h>
#include <string.h>

static void *WRPCopy(const void *p,size_t n) {
    void *q=malloc(n?n:1);if(q && n)memcpy(q,p,n);return q;
}
static int WRPFail(GQError *why,int reason,const char *path) {
    size_t n;if(why){why->reason=reason;n=strlen(path);if(n>=sizeof(why->path))n=sizeof(why->path)-1;
        memcpy(why->path,path,n);why->path[n]=0;}return GS_CONFLICT;
}
static int WRPNoWrite(void *c,const char *key,const void *a,size_t an,const void *b,size_t bn) {
    (void)c;(void)key;(void)a;(void)an;(void)b;(void)bn;return GS_FORMAT;
}
static int WRPBelow(const char *parent,const char *child,int separator) {
    size_t n=strlen(parent);return !strncmp(parent,child,n) && child[n]==separator;
}
static const GCMetadata *WRPMeta(const GCTransaction *t,const char *key) {
    size_t i;for(i=0;i<t->metadataCount;++i)if(!strcmp(t->metadata[i].path,key))return t->metadata+i;return NULL;
}
static const GRFile *WRPFile(const GRSnapshot *s,const char *path) {
    size_t i;for(i=0;i<s->count;++i)if(!strcmp(s->files[i].path,path))return s->files+i;return NULL;
}
static const GPEntry *WRPNative(const GPMap *m,const char *native) {
    size_t i;for(i=0;i<m->count;++i)if(!strcmp(m->entries[i].native,native))return m->entries+i;return NULL;
}
static const GQWork *WRPWork(const GQWork *w,size_t n,const char *path) {
    size_t i;for(i=0;i<n;++i)if(!strcmp(w[i].path,path))return w+i;return NULL;
}
static int WRPIdentity(GSRepository *r,const GRSnapshot *s,const GRFile *f,GCFile *out) {
    GRContents c;int result;memset(out,0,sizeof(*out));if(!f)return 0;
    GRContentsInit(&c);result=GRReadFile(r,s,(size_t)(f-s->files),&c);
    if(!result){out->present=1;memcpy(out->dataOID,s->index.entries[f->entry].oid,20);
        result=GBObjectID("blob",c.resource,c.resourceLength,out->resourceOID);
        if(c.hasFinderInfo)memcpy(out->finderInfo,c.finderInfo,32);else memcpy(out->finderInfo,"????????",8);
        out->finderInfo[8]&=(unsigned char)~1U;memset(out->finderInfo+10,0,6);memset(out->finderInfo+28,0,4);}
    GRContentsFree(&c);return result;
}
static int WRPSnapshot(GSRepository *r,const unsigned char oid[20],const WSLimits *l,GRSnapshot *out) {
    unsigned char *p=NULL;size_t n=0;char type[7];GHCommitInfo info;GIReadLimits bounds;int result;
    memset(&bounds,0,sizeof(bounds));bounds.entries=l->files*4;bounds.depth=128;bounds.pathBytes=l->pathBytes;
    result=GSGetObjectLimit(r,oid,type,&p,&n,l->stateBytes);
    if(!result && strcmp(type,"commit"))result=GS_FORMAT;
    if(!result)result=GHCommitParse(p,n,&info);
    if(!result)result=GRFromTreeBounded(r,info.tree,out,&bounds);
    free(p);return result;
}
static int WRPAddMeta(GCTransaction *t,const char *key,const void *a,size_t an,int ap,const void *b,size_t bn,int bp) {
    GCMetadata *m;
    if(t->metadataCount>=(size_t)-1/sizeof(*m))return GB_SPACE;
    m=(GCMetadata *)realloc(t->metadata,(t->metadataCount+1)*sizeof(*m));if(!m)return GB_MEMORY;
    t->metadata=m;m+=t->metadataCount++;memset(m,0,sizeof(*m));
    m->path=(char *)WRPCopy(key,strlen(key)+1);m->beforePresent=ap;m->afterPresent=bp;
    m->beforeLength=an;m->afterLength=bn;
    if(ap)m->before=(unsigned char *)WRPCopy(a,an);
    if(bp)m->after=(unsigned char *)WRPCopy(b,bn);
    return !m->path || (ap && !m->before) || (bp && !m->after)?GB_MEMORY:0;
}
static int WRPListGuard(GSRepository *r,const unsigned char oid[20],const WSLimits *l,GCTransaction *t) {
    WSList list;size_t i;int result,found=0;
    WSListInit(&list);result=WSListRead(r,l,&list);
    for(i=0;!result && i<list.count;++i)if(!memcmp(list.ids[i],oid,20))found=1;
    if(!result && !found)result=GS_CONFLICT;
    if(!result)result=WRPAddMeta(t,WS_LIST_KEY,list.original,list.originalLength,1,
                               list.original,list.originalLength,1);
    WSListFree(&list);return result;
}
static int WRPGuard(GSRepository *r,const GCMetadata *m,GCTransaction *t) {
    unsigned char *p=NULL;size_t n=0;int result,present;
    result=r->read(r->context,m->path,&p,&n);present=!result;if(result==GS_NOT_FOUND)result=0;
    if(!result && (present!=m->afterPresent || n!=m->afterLength || (n && memcmp(p,m->after,n))))result=GS_CONFLICT;
    if(!result)result=WRPAddMeta(t,m->path,p,n,present,p,n,present);
    free(p);return result;
}
static int WRPGuardCurrent(GSRepository *r,const char *key,const WSLimits *l,GCTransaction *t) {
    unsigned char *p=NULL;size_t n=0;int result,present;
    result=r->read(r->context,key,&p,&n);present=!result;if(result==GS_NOT_FOUND)result=0;
    if(!result && n>l->stateBytes)result=GB_SPACE;
    if(!result && present && n && !p)result=GS_FORMAT;
    if(!result)result=WRPAddMeta(t,key,p,n,present,p,n,present);
    free(p);return result;
}
int WRPrepareDrop(GSRepository *source,const unsigned char oid[20],const unsigned char binding[32],
    const WSLimits *l,GPEqual eq,void *ctx,GQPlan *out) {
    GSRepository r;GQPlan next;WSRecord record;WSList list,view;const GCMetadata *m;
    unsigned char tip[20],*wire=NULL,*sealed=NULL;char *branch=NULL,key[64],hex[41];
    size_t i,selected=0,n=0,sn=0,bn;int result,found=0,haveTip;
    if(!source || !source->read || !oid || !binding || !l || l->stateBytes<160 || !l->entries ||
       !l->files || !l->paths || !l->pathBytes || !l->forkBytes || !l->workBytes || !eq || !out)return GB_BAD;
    r=*source;r.replace=WRPNoWrite;GQInit(&next);WSInit(&record);WSListInit(&list);WSListInit(&view);
    result=GTNormalWriteAllowed(&r);
    if(!result)result=WSListRead(&r,l,&list);
    for(i=0;!result && i<list.count;++i)if(!memcmp(list.ids[i],oid,20)){found=1;selected=i;}
    if(!result && !found)result=GS_CONFLICT;
    if(!result)result=WSOpen(&r,oid,l,eq,ctx,&record);
    if(!result && memcmp(record.binding,binding,32))result=GS_CONFLICT;
    if(!result) {
        memset(tip,0,20);result=GSHead(&r,&branch,tip);haveTip=!result;
        if(result==GS_NOT_FOUND && branch)result=0;
        if(!result && (!GSValidRef(branch) || strlen(branch)>1024))result=GS_FORMAT;
        if(!result)result=WRPGuardCurrent(&r,"HEAD",l,&next.transaction);
        m=!result?WRPMeta(&next.transaction,"HEAD"):NULL;bn=branch?strlen(branch):0;
        if(!result && (!m->beforePresent || m->beforeLength!=bn+6 || memcmp(m->before,"ref: ",5) ||
            memcmp(m->before+5,branch,bn) || m->before[bn+5]!='\n'))result=GS_CONFLICT;
        if(!result)result=GSRefKey(branch,key);
        if(!result)result=WRPGuardCurrent(&r,key,l,&next.transaction);
        if(!result) {
            m=WRPMeta(&next.transaction,key);GBOIDFormat(tip,hex);
            if(m->beforePresent!=haveTip || (haveTip && (m->beforeLength!=bn+42 ||
                memcmp(m->before,branch,bn+1) || memcmp(m->before+bn+1,hex,40) ||
                m->before[bn+41]!='\n')))result=GS_CONFLICT;
        }
    }
    if(!result)result=WRPGuardCurrent(&r,"index",l,&next.transaction);
    if(!result)result=WRPGuardCurrent(&r,"ghclient-map",l,&next.transaction);
    if(!result) {
        /* Compact our private decoded vector; the captured original wire stays
           intact as the CAS baseline. All other entry order is retained. */
        if(selected+1<list.count)memmove(list.ids+selected,list.ids+selected+1,(list.count-selected-1)*20);
        view.ids=list.ids;view.count=list.count-1;result=WSListEncode(&view,l,&wire,&n);
    }
    if(!result)result=WRPAddMeta(&next.transaction,WS_LIST_KEY,list.original,list.originalLength,1,wire,n,1);
    if(!result)result=GTNextGeneration(&r,&next.transaction.generation);
    next.transaction.phase=GC_PREPARE;
    if(!result)result=GCEncode(&next.transaction,eq,ctx,&sealed,&sn);
    if(!result && sn>l->stateBytes)result=GB_SPACE;
    if(!result){GQFree(out);*out=next;GQInit(&next);}
    free(branch);free(wire);free(sealed);WSListFree(&list);WSFree(&record);GQFree(&next);return result;
}
static int WRPProtect(GSRepository *r,const WSRecord *saved,const GRSnapshot *base,const GPMap *after,
    const GQWork *work,size_t count,GQError *why) {
    size_t i;GCFile expected;const GRFile *f;const GPEntry *e;const GQWork *w;int result;
    for(i=0;i<saved->pathCount;++i) {
        const char *path=saved->paths[i];f=WRPFile(base,path);e=GPFind(after,path);w=WRPWork(work,count,path);
        if(f) {
            if(!e)return GS_FORMAT;
            result=WRPIdentity(r,base,f,&expected);if(result)return result;
            if(!w || w->file.present!=1 || strcmp(w->native,e->native) || !GCFileEqual(&w->file,&expected))return WRPFail(why,GQ_DIRTY,path);
        }else if(w) {
            if(w->file.present!=2 || !e || e->mode!=GP_DIRECTORY || strcmp(w->native,e->native))return WRPFail(why,GQ_UNTRACKED,path);
        }else if(e && e->mode==GP_DIRECTORY)return WRPFail(why,GQ_DIRECTORY,path);
    }
    return 0;
}
/* Invert working file operations using the WORKING/untracked snapshots, never
   the staged snapshot. A staged-only path may have no file operation at all. */
static int WRPInvert(const WSRecord *record,const GRSnapshot *working,const GRSnapshot *untracked,GCTransaction *t) {
    size_t i;const GCOperation *old;GCOperation *op;const GPEntry *e;const GRFile *f;const GRSnapshot *s;
    if(record->discard.fileCount>(size_t)-1/sizeof(*op))return GB_SPACE;
    if(record->discard.fileCount){t->files=(GCOperation *)calloc(record->discard.fileCount,sizeof(*op));if(!t->files)return GB_MEMORY;}
    for(i=0;i<record->discard.fileCount;++i) {
        old=record->discard.files+i;op=t->files+t->fileCount++;
        op->oldFile=old->newFile;op->newFile=old->oldFile;
        if(old->newPath){op->oldPath=(char *)WRPCopy(old->newPath,strlen(old->newPath)+1);if(!op->oldPath)return GB_MEMORY;}
        if(old->oldPath) {
            op->newPath=(char *)WRPCopy(old->oldPath,strlen(old->oldPath)+1);if(!op->newPath)return GB_MEMORY;
            e=WRPNative(&record->aliases,old->oldPath);if(!e)return GS_FORMAT;
            s=working;f=WRPFile(s,e->path);if(!f){s=untracked;f=WRPFile(s,e->path);}if(!f)return GS_FORMAT;
            op->mode=f->mode;if(f->hasFinderInfo)memcpy(op->metadataOID,s->index.entries[f->metadataEntry].oid,20);
        }
    }
    return 0;
}
static int WRPPostParent(const WSRecord *record,const char *native) {
    size_t i;for(i=0;i<record->discard.fileCount;++i) {
        const char *child=record->discard.files[i].newPath;
        if(child && WRPBelow(native,child,':'))return 1;
    }return 0;
}
static int WRPInventories(const WSRecord *record,const GQWork *work,size_t count,const WSLimits *l,
    GCTransaction *t,GQWork **final,size_t *finalCount,GQError *why) {
    unsigned char *removed=NULL;GQWork *out=NULL;size_t i,j,n=0,capacity;int result=0;const GPEntry *e;
    if(count>(size_t)-1/sizeof(*t->directories) || l->files>(size_t)-1/sizeof(*out))return GB_SPACE;
    capacity=count+record->discard.fileCount+record->discard.directoryCount;
    if(capacity>l->files)capacity=l->files;
    removed=(unsigned char *)calloc(count?count:1,1);out=(GQWork *)calloc(capacity?capacity:1,sizeof(*out));
    if(!removed || !out){result=GB_MEMORY;goto done;}
    if(count){t->directories=(char **)calloc(count,sizeof(*t->directories));if(!t->directories){result=GB_MEMORY;goto done;}}
    for(i=0;!result && i<t->fileCount;++i)if(t->files[i].oldPath) {
        for(j=0;j<count && strcmp(work[j].native,t->files[i].oldPath);++j){}
        if(j==count || work[j].file.present!=1 || !GCFileEqual(&work[j].file,&t->files[i].oldFile))result=WRPFail(why,GQ_DIRTY,t->files[i].oldPath);
        else removed[j]=1;
    }
    for(i=0;!result && i<count;++i)if(work[i].file.present==2) {
        for(j=0;j<t->fileCount;++j)if(t->files[j].newPath &&
            (!strcmp(t->files[j].newPath,work[i].native) || WRPBelow(t->files[j].newPath,work[i].native,':')))break;
        if(j==t->fileCount)continue;
        if(!WRPPostParent(record,work[i].native)){result=WRPFail(why,GQ_DIRECTORY,work[i].path);break;}
        t->directories[t->directoryCount]=(char *)WRPCopy(work[i].native,strlen(work[i].native)+1);
        if(!t->directories[t->directoryCount]){result=GB_MEMORY;break;}
        ++t->directoryCount;removed[i]=1;
    }
    for(i=0;!result && i<t->directoryCount;++i)
        for(j=0;j<count;++j)if(!removed[j] && WRPBelow(t->directories[i],work[j].native,':')){result=WRPFail(why,GQ_UNTRACKED,work[j].path);break;}
    for(i=0;!result && i<count;++i)if(!removed[i])out[n++]=work[i];
    for(i=0;!result && i<t->fileCount;++i)if(t->files[i].newPath) {
        e=WRPNative(&record->aliases,t->files[i].newPath);if(!e){result=GS_FORMAT;break;}
        if(n>=l->files){result=GB_SPACE;break;}
        out[n].path=e->path;out[n].native=t->files[i].newPath;out[n++].file=t->files[i].newFile;
    }
    if(!result && record->discard.directoryCount && !record->completeDirectories)result=GI_UNSUPPORTED;
    if(!result && record->discard.directoryCount) {
        if(record->discard.directoryCount>(size_t)-1/sizeof(*t->createdDirectories)){result=GB_SPACE;goto done;}
        t->createdDirectories=(GCDirectory *)calloc(record->discard.directoryCount,sizeof(*t->createdDirectories));if(!t->createdDirectories){result=GB_MEMORY;goto done;}
    }
    for(i=0;!result && i<record->discard.directoryCount;++i) {
        GCDirectory *d=t->createdDirectories+t->createdDirectoryCount++;const WSDirectory *old=record->directories+i;
        d->path=(char *)WRPCopy(record->discard.directories[i],strlen(record->discard.directories[i])+1);if(!d->path){result=GB_MEMORY;break;}
        d->attributes=old->attributes;d->created=old->created;d->modified=old->modified;d->backup=old->backup;memcpy(d->finderInfo,old->finderInfo,32);
        e=WRPNative(&record->aliases,d->path);if(!e){result=GS_FORMAT;break;}
        if(n>=l->files){result=GB_SPACE;break;}
        out[n].path=e->path;out[n].native=d->path;out[n++].file.present=2;
    }
    if(!result){*final=out;*finalCount=n;out=NULL;}
done:
    free(removed);free(out);return result;
}
static int WRPMapOrder(const void *a,const void *b) {return strcmp(((const GPEntry *)a)->path,((const GPEntry *)b)->path);}
static int WRPNeeded(const WSRecord *record,const char *path) {
    size_t i;for(i=0;i<record->pathCount;++i)if(!strcmp(path,record->paths[i]) || WRPBelow(path,record->paths[i],'/'))return 1;return 0;
}
static int WRPMapSame(const GPEntry *a,const GPEntry *b) {
    return (!a && !b) || (a && b && !strcmp(a->native,b->native) && a->mode==b->mode && a->flags==b->flags &&
        !memcmp(a->dataOID,b->dataOID,20) && !memcmp(a->metadataOID,b->metadataOID,20) && !memcmp(a->finderInfo,b->finderInfo,32));
}
static int WRPMapAppend(GPMap *m,const GPEntry *e,const WSLimits *l,size_t *cost) {
    GPEntry *p;size_t a=strlen(e->path),b=strlen(e->native);
    if(m->count>=l->paths || a>l->pathBytes || b>l->pathBytes || a>l->stateBytes || b>l->stateBytes-a ||
        l->stateBytes-a-b<88 || *cost>l->stateBytes-a-b-88 || m->count>=(size_t)-1/sizeof(*p))return GB_SPACE;
    p=(GPEntry *)realloc(m->entries,(m->count+1)*sizeof(*p));if(!p)return GB_MEMORY;
    m->entries=p;p+=m->count++;*p=*e;p->path=p->native=NULL;
    p->path=(char *)WRPCopy(e->path,a+1);p->native=(char *)WRPCopy(e->native,b+1);
    if(!p->path || !p->native)return GB_MEMORY;
    *cost+=88+a+b;return 0;
}
static int WRPMaps(const WSRecord *record,const GPMap *before,const GPMap *after,const GPMap *current,
    const GQWork *final,size_t fn,const WSLimits *l,GPEqual eq,void *ctx,GPMap *out,
    unsigned char **wire,size_t *wn,int *present) {
    GPMap next;unsigned char *encoded=NULL;size_t n=0,i,cost=52;int result,exact;
    for(i=0;i<after->count;++i)if(WRPNeeded(record,after->entries[i].path) &&
        !WRPMapSame(after->entries+i,GPFind(current,after->entries[i].path)))return GS_CONFLICT;
    for(i=0;i<current->count;++i)if(WRPNeeded(record,current->entries[i].path) &&
        !WRPMapSame(current->entries+i,GPFind(after,current->entries[i].path)))return GS_CONFLICT;
    GPInit(&next);exact=current->originalLength==after->originalLength &&
        (!!current->original)==(!!after->original) && (!current->originalLength || !memcmp(current->original,after->original,current->originalLength));
    if(exact) {
        result=GQCheckInventory(before,final,fn,eq,ctx,1);
        if(result!=GS_CONFLICT && result)return result;
        if(!result) {
            if(before->original)result=GPParse(before->original,before->originalLength,eq,ctx,&next);
            if(!result && before->original){encoded=(unsigned char *)WRPCopy(before->original,before->originalLength);if(!encoded)result=GB_MEMORY;else n=before->originalLength;}
            if(!result)*present=before->original!=NULL;
            goto ready;
        }
    }
    result=0;memcpy(next.tree,current->tree,20);
    for(i=0;!result && i<current->count;++i)if(!WRPNeeded(record,current->entries[i].path))result=WRPMapAppend(&next,current->entries+i,l,&cost);
    for(i=0;!result && i<before->count;++i)if(WRPNeeded(record,before->entries[i].path))result=WRPMapAppend(&next,before->entries+i,l,&cost);
    if(!result && next.count)qsort(next.entries,next.count,sizeof(*next.entries),WRPMapOrder);
    if(!result)result=GPEncode(&next,eq,ctx,&encoded,&n);
    if(!result && n>l->stateBytes)result=GB_SPACE;
    if(!result)result=GQCheckInventory(&next,final,fn,eq,ctx,1);
    if(!result)*present=1;
ready:
    if(!result) {
        free(next.original);next.original=NULL;next.originalLength=0;
        if(current->original){next.original=(unsigned char *)WRPCopy(current->original,current->originalLength);if(!next.original)result=GB_MEMORY;else next.originalLength=current->originalLength;}
    }
    if(!result){GPFree(out);*out=next;GPInit(&next);*wire=encoded;*wn=n;encoded=NULL;}
    free(encoded);GPFree(&next);return result;
}
int WRPrepareRestore(GSRepository *source,const unsigned char oid[20],const unsigned char binding[32],
    const GQWork *work,size_t count,const WSLimits *l,GPEqual eq,void *ctx,GQPlan *out,GQError *why) {
    GSRepository r;WSRecord record;GQPlan next;GIIndex original,expected,current;
    GPMap before,after,live;GRSnapshot working,untracked,base;GQWork *final=NULL;GQProtection selected;
    const GCMetadata *m,*indexMeta,*mapMeta;unsigned char *wire=NULL,*sealed=NULL;size_t wn=0,sn=0,fn=0,i;
    int result,choice=0,mapPresent=0;const void *indexWire=NULL;size_t indexLength=0;int indexPresent=0;
    if(!source || !source->read || !oid || !binding || !out || !eq || !l || l->stateBytes<160 || !l->files ||
        l->files>(size_t)-1/4 || !l->paths || !l->pathBytes || !l->forkBytes || !l->workBytes || !l->entries ||
        count>l->files || (count && !work))return GB_BAD;
    for(i=0;i<count;++i)if(!work[i].path || !work[i].native || strlen(work[i].path)>l->pathBytes || strlen(work[i].native)>l->pathBytes)return GB_BAD;
    r=*source;r.replace=WRPNoWrite;WSInit(&record);GQInit(&next);GIInit(&original);GIInit(&expected);GIInit(&current);
    GPInit(&before);GPInit(&after);GPInit(&live);GRInit(&working);GRInit(&untracked);GRInit(&base);
    result=GTNormalWriteAllowed(&r);
    if(!result)result=WSOpen(&r,oid,l,eq,ctx,&record);
    if(!result && memcmp(binding,record.binding,32))result=GS_CONFLICT;
    for(i=0;!result && i<record.discard.metadataCount;++i) {
        m=record.discard.metadata+i;
        if(strcmp(m->path,"index") && strcmp(m->path,"ghclient-map"))result=WRPGuard(&r,m,&next.transaction);
    }
    if(!result)result=WRPListGuard(&r,oid,l,&next.transaction);
    indexMeta=WRPMeta(&record.discard,"index");mapMeta=WRPMeta(&record.discard,"ghclient-map");
    if(!result && (!indexMeta || !mapMeta))result=GS_FORMAT;
    if(!result && indexMeta->beforePresent)result=GIParse(indexMeta->before,indexMeta->beforeLength,&original);
    if(!result && indexMeta->afterPresent)result=GIParse(indexMeta->after,indexMeta->afterLength,&expected);
    if(!result)result=GILoad(&r,&current);
    selected.paths=(const char *const *)record.paths;selected.count=record.pathCount;selected.changed=0;
    if(!result)result=WRMergeIndex(&r,&original,&expected,&current,&selected,l,&next.index,&choice,why);
    if(!result && mapMeta->beforePresent)result=GPParse(mapMeta->before,mapMeta->beforeLength,eq,ctx,&before);
    if(!result && mapMeta->afterPresent)result=GPParse(mapMeta->after,mapMeta->afterLength,eq,ctx,&after);
    if(!result)result=GPLoad(&r,eq,ctx,&live);
    if(!result && (live.originalLength>l->stateBytes || live.count>l->paths))result=GB_SPACE;
    if(!result)result=GQCheckInventory(&live,work,count,eq,ctx,1);
    if(!result && record.haveBase)result=WRPSnapshot(&r,record.base,l,&base);
    if(!result)result=WRPSnapshot(&r,record.working,l,&working);
    if(!result)result=WSReadUntracked(&r,&record,l,&untracked);
    if(!result)result=WRPProtect(&r,&record,&base,&after,work,count,why);
    if(!result)result=WRPInvert(&record,&working,&untracked,&next.transaction);
    if(!result)result=WRPInventories(&record,work,count,l,&next.transaction,&final,&fn,why);
    if(!result)result=WRPMaps(&record,&before,&after,&live,final,fn,l,eq,ctx,&next.mapping,&wire,&wn,&mapPresent);
    if(!result)result=WRPAddMeta(&next.transaction,"ghclient-map",live.original,live.originalLength,live.original!=NULL,wire,wn,mapPresent);
    free(wire);wire=NULL;wn=0;
    if(!result) {
        if(choice==WR_ORIGINAL_INDEX){indexWire=indexMeta->before;indexLength=indexMeta->beforeLength;indexPresent=indexMeta->beforePresent;}
        else if(choice==WR_CURRENT_INDEX){indexWire=current.original;indexLength=current.originalLength;indexPresent=current.original!=NULL;}
        else {result=GIEncode(&next.index,&wire,&wn);indexWire=wire;indexLength=wn;indexPresent=1;}
    }
    if(!result)result=WRPAddMeta(&next.transaction,"index",current.original,current.originalLength,current.original!=NULL,indexWire,indexLength,indexPresent);
    if(!result)result=GTNextGeneration(&r,&next.transaction.generation);
    next.transaction.phase=GC_PREPARE;
    if(!result)result=GCEncode(&next.transaction,eq,ctx,&sealed,&sn);
    if(!result && sn>l->stateBytes)result=GB_SPACE;
    if(!result){GQFree(out);*out=next;GQInit(&next);}
    free(wire);free(sealed);free(final);WSFree(&record);GQFree(&next);GIFree(&original);GIFree(&expected);GIFree(&current);
    GPFree(&before);GPFree(&after);GPFree(&live);GRFree(&working);GRFree(&untracked);GRFree(&base);return result;
}
