#include "GitRebaseResolve.h"
#include <string.h>

static int RXWrite(void *context,const char *key,const void *old,size_t on,const void *next,size_t nn) {
    GOReader *state=(GOReader *)context;
    if(strncmp(key,"objects/",8) || old || on || !next || !nn)return GB_BAD;
    return state->source->replace(state->source->context,key,NULL,0,next,nn);
}
static int RXSameIndex(const GIIndex *a,const GIIndex *b) {
    size_t i;const GIEntry *left,*right;if(a->count!=b->count)return 0;
    for(i=0;i<a->count;++i) {
        left=a->entries+i;right=b->entries+i;
        if(strcmp(left->path,right->path) || left->stat[6]!=right->stat[6] ||
            memcmp(left->oid,right->oid,20) || ((left->flags|right->flags)&0x3000))return 0;
    }
    return 1;
}
int RXPublish(GSRepository *source,const RSStep *step,const TMResolution *choices,size_t count,
    const char *committer,const char *seconds,const char *zone,GDProgress progress,void *context,RPResult *destination) {
    GOReader state;GSRepository writer;RSStep prepared;TMDraft draft;int result;
    if(!source || !source->read || !source->replace || !step || !destination || (count && !choices))return GB_BAD;
    if(step->kind!=RS_CONFLICT || !step->merge.conflicts)return GB_BAD;
    result=GOReadStart(source,&step->merge.limits.read,progress,context,&state,&writer);if(result)return result;
    writer.replace=RXWrite;TMDraftInit(&draft);
    result=TMBuildResolvedIndex(&writer,&step->merge,choices,count,progress,context,&draft);
    if(!result && draft.unresolved)result=GI_UNMERGED;
    if(!result) {
        /* Borrow the verified proposal; never free or modify its owned plan.
           Only the fully validated explicit draft replaces the conflict. */
        prepared=*step;prepared.draft=draft;prepared.merge.conflicts=0;
        prepared.kind=RXSameIndex(&draft.index,&step->merge.snapshots[1].index)?RS_DROP_EMPTY:RS_APPLY;
        result=RPPublish(&writer,&prepared,committer,seconds,zone,progress,context,destination);
    }
    TMDraftFree(&draft);return result;
}
