#include "GitRestore.h"
#include "GitHistory.h"
#include <stdlib.h>
#include <string.h>

void GRInit(GRSnapshot *s) { memset(s, 0, sizeof(*s)); }
void GRFree(GRSnapshot *s) {
    GIFree(&s->index);
    free(s->files);
    GRInit(s);
}
void GRContentsInit(GRContents *c) { memset(c, 0, sizeof(*c)); }
void GRContentsFree(GRContents *c) {
    free(c->data);
    free(c->metadata);
    GRContentsInit(c);
}
static int GRReserved(const char *path) {
    size_t n = strlen(GI_MAC_NAMESPACE);
    return !strncmp(path, GI_MAC_NAMESPACE, n) && (!path[n] || path[n] == '/');
}
static GRFile *GRFind(GRSnapshot *s, const char *path) {
    size_t lo = 0, hi = s->count, mid;
    int order;
    while (lo < hi) {
        mid = lo + (hi - lo) / 2;
        order = strcmp(s->files[mid].path, path);
        if (order < 0)
            lo = mid + 1;
        else
            hi = mid;
    }
    return lo < s->count && !strcmp(s->files[lo].path, path) ? s->files + lo : NULL;
}
static int GRBlob(GSRepository *r, const GIEntry *entry, unsigned char **body, size_t *n) {
    char type[7];
    int result = GSGetObject(r, entry->oid, type, body, n);
    if (!result && strcmp(type, "blob")) {
        free(*body);
        *body = NULL;
        *n = 0;
        result = GS_FORMAT;
    }
    return result;
}
static int GRMetadata(GSRepository *r, const GIEntry *entry, const char *expected,
                      unsigned char **body, size_t *n, unsigned char info[32],
                      const unsigned char **resource, size_t *resourceLength) {
    char *path = NULL, physical[96];
    int result;
    if (entry->stat[6] != 0100644)
        return GS_FORMAT;
    result = GRBlob(r, entry, body, n);
    if (!result)
        result = GIMacDecode(*body, *n, &path, info, resource, resourceLength);
    if (!result)
        result = GIMacMetadataPath(path, physical);
    if (!result && (strcmp(entry->path, physical) || (expected && strcmp(path, expected))))
        result = GS_FORMAT;
    free(path);
    return result;
}
static int GRBuildSnapshot(GSRepository *r,GIIndex *index,const unsigned char *tree,GRSnapshot *destination) {
    GRSnapshot next;
    GRFile *file;
    const GIEntry *entry;
    unsigned char *body = NULL, info[32];
    const unsigned char *resource;
    char *path = NULL;
    size_t i, n, resourceLength;
    int result;
    if (!r || !index || !destination)
        return GB_BAD;
    GRInit(&next);
    next.index=*index;GIInit(index);result=0;
    for(i=0;!result && i<next.index.count;++i) {
        if((next.index.entries[i].flags>>12)&3)result=GI_UNMERGED;
        else if(next.index.entries[i].extended)result=GI_UNSUPPORTED;
    }
    if (!result)
        result = GIValidateMacNamespace(r, &next.index);
    if (result)
        goto done;
    for (i = 0; i < next.index.count; ++i)
        if (!GRReserved(next.index.entries[i].path))
            ++next.count;
    if (next.count > (size_t)-1 / sizeof(*next.files)) {
        result = GB_SPACE;
        goto done;
    }
    next.files = (GRFile *)calloc(next.count ? next.count : 1, sizeof(*next.files));
    if (!next.files) {
        result = GB_MEMORY;
        goto done;
    }
    n = 0;
    for (i = 0; i < next.index.count; ++i) {
        entry = next.index.entries + i;
        if (GRReserved(entry->path))
            continue;
        file = next.files + n++;
        file->path = entry->path;
        file->entry = i;
        file->mode = entry->stat[6];
        file->metadataEntry = (size_t)-1;
        if (file->mode != 0160000) {
            result = GRBlob(r, entry, &body, &file->dataLength);
            free(body);
            body = NULL;
            if (result)
                goto done;
        }
    }
    for (i = 0; i < next.index.count; ++i) {
        entry = next.index.entries + i;
        if (!GRReserved(entry->path))
            continue;
        if (!strcmp(entry->path, GI_MAC_NAMESPACE "/version")) {
            if (entry->stat[6] != 0100644) {
                result = GS_FORMAT;
                goto done;
            }
            continue;
        }
        result = GRMetadata(r, entry, NULL, &body, &n, info, &resource, &resourceLength);
        if (!result)
            result = GIMacDecode(body, n, &path, info, &resource, &resourceLength);
        if (result)
            goto done;
        file = GRFind(&next, path);
        if (!file || (file->mode != 0100644 && file->mode != 0100755) ||
            file->hasFinderInfo) {
            result = GS_FORMAT;
            goto done;
        }
        file->hasFinderInfo = 1;
        file->metadataEntry = i;
        file->resourceLength = resourceLength;
        memcpy(file->finderInfo, info, 32);
        free(path);
        path = NULL;
        free(body);
        body = NULL;
    }
    if(tree)memcpy(next.tree, tree, 20);
    GRFree(destination);
    *destination = next;
    GRInit(&next);
done:
    free(body);
    free(path);
    GRFree(&next);
    return result;
}
int GRFromTreeBounded(GSRepository *r,const unsigned char tree[20],GRSnapshot *out,const GIReadLimits *limits) {
    GIIndex index;int result;
    if(!r || !tree || !out)return GB_BAD;
    GIInit(&index);
    result=GIReadTreeBounded(r,tree,&index,limits);
    if(!result)result=GRBuildSnapshot(r,&index,tree,out);
    GIFree(&index);return result;
}
int GRFromIndex(GSRepository *r,const GIIndex *source,GRSnapshot *out) {
    GIIndex index;unsigned char *p=NULL;size_t n=0;int result;
    if(!r || !source || !out)return GB_BAD;
    GIInit(&index);
    result=GIEncode(source,&p,&n);
    if(!result)result=GIParse(p,n,&index);
    if(!result)result=GRBuildSnapshot(r,&index,NULL,out);
    free(p);GIFree(&index);return result;
}
int GRFromTree(GSRepository *r, const unsigned char tree[20], GRSnapshot *destination) {
    return GRFromTreeBounded(r, tree, destination, NULL);
}
int GRFromCommit(GSRepository *r, const unsigned char oid[20], GRSnapshot *destination) {
    GRSnapshot next;
    GHCommitInfo info;
    unsigned char *body;
    size_t n;
    char type[7];
    int result;
    if (!r || !oid || !destination)
        return GB_BAD;
    GRInit(&next);
    result = GSGetObject(r, oid, type, &body, &n);
    if (result)
        return result;
    result = strcmp(type, "commit") ? GS_FORMAT : GHCommitParse(body, n, &info);
    free(body);
    if (!result)
        result = GRFromTree(r, info.tree, &next);
    if (!result) {
        next.haveCommit = 1;
        memcpy(next.commit, oid, 20);
        GRFree(destination);
        *destination = next;
        GRInit(&next);
    }
    GRFree(&next);
    return result;
}
int GRReadFile(GSRepository *r, const GRSnapshot *s, size_t selected, GRContents *destination) {
    GRContents next;
    const GRFile *file;
    const GIEntry *entry;
    size_t n;
    int result;
    if (!r || !s || !destination || selected >= s->count)
        return GB_BAD;
    file = s->files + selected;
    if (file->mode == 0160000)
        return GI_UNSUPPORTED;
    if (file->entry >= s->index.count)
        return GS_FORMAT;
    entry = s->index.entries + file->entry;
    GRContentsInit(&next);
    result = GRBlob(r, entry, &next.data, &next.dataLength);
    if (!result && next.dataLength != file->dataLength)
        result = GS_FORMAT;
    if (!result && file->hasFinderInfo) {
        if (file->metadataEntry >= s->index.count)
            result = GS_FORMAT;
        else
            result = GRMetadata(r, s->index.entries + file->metadataEntry, file->path,
                                &next.metadata, &n, next.finderInfo, &next.resource,
                                &next.resourceLength);
        if (!result && (next.resourceLength != file->resourceLength ||
                        memcmp(next.finderInfo, file->finderInfo, 32)))
            result = GS_FORMAT;
        if (!result)
            next.hasFinderInfo = 1;
    }
    if (!result) {
        GRContentsFree(destination);
        *destination = next;
        GRContentsInit(&next);
    }
    GRContentsFree(&next);
    return result;
}
