#include "GitServer.h"
#include "GHCore.h"
#include "GitBytes.h"
#include <stdio.h>
#include <string.h>

static const char grMagic[] = "GHServer1\n";
static int GRLower(int c) { return c >= 'A' && c <= 'Z' ? c + 'a' - 'A' : c; }
static int GRAlnum(int c) {
    return (c >= 'a' && c <= 'z') || (c >= 'A' && c <= 'Z') || (c >= '0' && c <= '9');
}
static int GRPrefixMatch(const char *text, const char *prefix) {
    for (; *prefix; ++text, ++prefix) if (GRLower((unsigned char)*text) != *prefix) return 0;
    return 1;
}
static int GRValidHost(const char *host) {
    size_t i, n = strlen(host), label = 0;
    unsigned char c;
    if (!n || n > 253) return 0;
    for (i = 0; i < n; ++i) {
        c = (unsigned char)host[i];
        if (c == '.') { if (!label) return 0; label = 0; continue; }
        if ((!GRAlnum(c) && c != '-') || (c >= 'A' && c <= 'Z')) return 0;
        if (c == '-' && (!label || i + 1 == n || host[i + 1] == '.')) return 0;
        if (++label > 63) return 0;
    }
    return label != 0;
}
static int GRValidUser(const char *user) {
    size_t i, n = strlen(user);
    unsigned char c;
    if (n > 127) return 0;
    for (i = 0; i < n; ++i) {
        c = (unsigned char)user[i];
        if (!GRAlnum(c) && c != '.' && c != '_' && c != '-' && c != '+') return 0;
    }
    return 1;
}
/* Empty, or one or more /segment parts. No empty, "." or ".." segment. */
static int GRValidPrefix(const char *prefix) {
    size_t i = 0, start;
    unsigned char c;
    if (strlen(prefix) > 255) return 0;
    while (prefix[i]) {
        if (prefix[i++] != '/') return 0;
        start = i;
        while (prefix[i] && prefix[i] != '/') {
            c = (unsigned char)prefix[i++];
            if (!GRAlnum(c) && c != '.' && c != '_' && c != '-' && c != '~') return 0;
        }
        if (i == start || (i - start == 1 && prefix[start] == '.') ||
            (i - start == 2 && prefix[start] == '.' && prefix[start + 1] == '.')) return 0;
    }
    return 1;
}
static int GRValid(const GRServer *s) {
    if (!s) return 0;
    if (!s->custom) return 1;
    return (s->tls == 0 || s->tls == 1) && (s->dotGit == 0 || s->dotGit == 1) && s->port &&
           memchr(s->host, 0, sizeof(s->host)) && memchr(s->prefix, 0, sizeof(s->prefix)) &&
           memchr(s->user, 0, sizeof(s->user)) && GRValidHost(s->host) &&
           GRValidPrefix(s->prefix) && GRValidUser(s->user);
}
void GRReset(GRServer *server) { if (server) memset(server, 0, sizeof(*server)); }
int GRParseURL(const char *url, GRServer *out, char repository[256]) {
    GRServer s;
    const char *p, *slash, *at, *colon, *end, *name, *owner;
    char path[512];
    unsigned long port = 0;
    size_t n;
    if (!url || !out || !repository) return GB_BAD;
    memset(&s, 0, sizeof(s)); s.custom = 1; repository[0] = 0;
    if (GRPrefixMatch(url, "https://")) { s.tls = 1; p = url + 8; }
    else if (GRPrefixMatch(url, "http://")) p = url + 7;
    else return GB_BAD;
    slash = strchr(p, '/');
    if (!slash || slash == p) return GB_BAD;
    at = (const char *)memchr(p, '@', (size_t)(slash - p));
    if (at) {
        n = (size_t)(at - p);
        if (!n || n >= sizeof(s.user)) return GB_BAD;
        memcpy(s.user, p, n); s.user[n] = 0;
        if (!GRValidUser(s.user)) return GB_BAD; /* Includes user:password. */
        p = at + 1;
    }
    colon = (const char *)memchr(p, ':', (size_t)(slash - p));
    end = colon ? colon : slash;
    n = (size_t)(end - p);
    if (!n || n >= sizeof(s.host)) return GB_BAD;
    memcpy(s.host, p, n); s.host[n] = 0;
    for (n = 0; s.host[n]; ++n) s.host[n] = (char)GRLower((unsigned char)s.host[n]);
    if (!GRValidHost(s.host)) return GB_BAD;
    if (colon) {
        if (colon + 1 == slash || slash - colon > 6) return GB_BAD;
        for (p = colon + 1; p < slash; ++p) {
            if (*p < '0' || *p > '9') return GB_BAD;
            port = port * 10 + (unsigned long)(*p - '0');
        }
        if (!port || port > 65535UL) return GB_BAD;
        s.port = (unsigned short)port;
    } else s.port = (unsigned short)(s.tls ? 443 : 80);
    n = strlen(slash);
    while (n > 1 && slash[n - 1] == '/') --n;
    if (n < 4 || n >= sizeof(path)) return GB_BAD;
    memcpy(path, slash, n); path[n] = 0;
    if (n > 4 && !strcmp(path + n - 4, ".git")) { s.dotGit = 1; path[n - 4] = 0; }
    name = strrchr(path, '/');
    if (!name || name == path) return GB_BAD;
    for (owner = name - 1; owner > path && *owner != '/'; --owner) {}
    if (*owner != '/') return GB_BAD;
    if (!GHValidRepository(owner + 1)) return GB_BAD;
    n = (size_t)(owner - path);
    if (n >= sizeof(s.prefix)) return GB_BAD;
    memcpy(s.prefix, path, n); s.prefix[n] = 0;
    if (!GRValidPrefix(s.prefix)) return GB_BAD;
    strcpy(repository, owner + 1);
    *out = s;
    return 0;
}
int GRPack(const GRServer *s, char *out, size_t capacity, size_t *length) {
    int n;
    if (!s || !s->custom || !GRValid(s) || !out || !length) return GB_BAD;
    n = snprintf(out, capacity, "%s%s\n%s\n%u\n%s\n%d\n%s\n", grMagic, s->tls ? "https" : "http",
                 s->host, (unsigned)s->port, s->prefix, s->dotGit, s->user);
    if (n < 0 || (size_t)n >= capacity || n > GR_RECORD_LIMIT) return GB_BAD;
    *length = (size_t)n;
    return 0;
}
/* Copy one LF-terminated field; fields hold printable ASCII without spaces. */
static int GRField(const unsigned char **p, const unsigned char *end, char *out, size_t capacity) {
    const unsigned char *line = (const unsigned char *)memchr(*p, '\n', (size_t)(end - *p));
    size_t i, n;
    if (!line) return GB_BAD;
    n = (size_t)(line - *p);
    if (n >= capacity) return GB_BAD;
    for (i = 0; i < n; ++i) if ((*p)[i] < 33 || (*p)[i] > 126) return GB_BAD;
    memcpy(out, *p, n); out[n] = 0; *p = line + 1;
    return 0;
}
int GRUnpack(const unsigned char *bytes, size_t length, GRServer *out) {
    GRServer s;
    const unsigned char *p, *end;
    char scheme[8], port[8], flag[4], again[GR_RECORD_LIMIT + 1];
    unsigned long value = 0;
    size_t i, n = sizeof(grMagic) - 1;
    if (!bytes || !out || length <= n || length > GR_RECORD_LIMIT || memcmp(bytes, grMagic, n)) return GB_BAD;
    memset(&s, 0, sizeof(s)); s.custom = 1;
    p = bytes + n; end = bytes + length;
    if (GRField(&p, end, scheme, sizeof(scheme)) || GRField(&p, end, s.host, sizeof(s.host)) ||
        GRField(&p, end, port, sizeof(port)) || GRField(&p, end, s.prefix, sizeof(s.prefix)) ||
        GRField(&p, end, flag, sizeof(flag)) || GRField(&p, end, s.user, sizeof(s.user)) || p != end)
        return GB_BAD;
    if (!strcmp(scheme, "https")) s.tls = 1; else if (strcmp(scheme, "http")) return GB_BAD;
    if (!port[0] || port[0] == '0') return GB_BAD;
    for (i = 0; port[i]; ++i) {
        if (port[i] < '0' || port[i] > '9') return GB_BAD;
        value = value * 10 + (unsigned long)(port[i] - '0');
    }
    if (value > 65535UL) return GB_BAD;
    s.port = (unsigned short)value;
    if (strcmp(flag, "0") && strcmp(flag, "1")) return GB_BAD;
    s.dotGit = flag[0] == '1';
    /* Only the canonical encoding is accepted, so equal servers have equal bytes. */
    if (!GRValid(&s) || GRPack(&s, again, sizeof(again), &n) || n != length || memcmp(again, bytes, n))
        return GB_BAD;
    *out = s;
    return 0;
}
int GRPath(const GRServer *s, const char *repository, const char *service, char *out, size_t capacity) {
    int n;
    if (!s || !GRValid(s) || !repository || !GHValidRepository(repository) || !service || !out) return GB_BAD;
    n = s->custom ? snprintf(out, capacity, "%s/%s%s/%s", s->prefix, repository, s->dotGit ? ".git" : "", service)
                  : snprintf(out, capacity, "/%s.git/%s", repository, service);
    return n < 0 || (size_t)n >= capacity ? GB_BAD : 0;
}
int GRHostHeader(const GRServer *s, char *out, size_t capacity) {
    int n;
    if (!s || !GRValid(s) || !out) return GB_BAD;
    if (!s->custom) n = snprintf(out, capacity, "github.com");
    else if (s->port == (s->tls ? 443 : 80)) n = snprintf(out, capacity, "%s", s->host);
    else n = snprintf(out, capacity, "%s:%u", s->host, (unsigned)s->port);
    return n < 0 || (size_t)n >= capacity ? GB_BAD : 0;
}
int GRDisplay(const GRServer *s, const char *repository, char *out, size_t capacity) {
    char host[270];
    int n;
    if (!repository || !out || GRHostHeader(s, host, sizeof(host))) return GB_BAD;
    if (!s->custom) n = snprintf(out, capacity, "%s", repository);
    else n = snprintf(out, capacity, "%s://%s%s/%s%s", s->tls ? "https" : "http", host, s->prefix,
                      repository, s->dotGit ? ".git" : "");
    return n < 0 || (size_t)n >= capacity ? GB_BAD : 0;
}
int GRSame(const GRServer *a, const GRServer *b) {
    if (!a || !b) return 0;
    if (!a->custom || !b->custom) return !a->custom && !b->custom;
    return a->tls == b->tls && a->dotGit == b->dotGit && a->port == b->port &&
           !strcmp(a->host, b->host) && !strcmp(a->prefix, b->prefix) && !strcmp(a->user, b->user);
}
