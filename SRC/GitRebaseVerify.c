#include "GitRebaseVerify.h"
#include "GitHistory.h"
#include <stdlib.h>
#include <string.h>

void RVInit(RVVerified *v){memset(v,0,sizeof(*v));}
void RVFree(RVVerified *v){RBFree(&v->graph);GRFree(&v->original);RSFree(&v->conflict);MSValuesFree(&v->choices);RVInit(v);}
/* GSPutObject will read/decode/compare the expected existing object after this
   local refusal. The actual repository's replace callback is never invoked. */
static int RVExisting(void *ctx,const char *key,const void *old,size_t on,const void *next,size_t nn) {
    (void)ctx;if(strncmp(key,"objects/",8) || old || on || !next || !nn)return GB_BAD;return GS_CONFLICT;
}
static int RVZero(const unsigned char id[20]){size_t i;for(i=0;i<20;++i)if(id[i])return 0;return 1;}
static int RVHead(GSRepository *reader,const RZState *state,const TMLimits *limits,GDProgress fn,void *ctx,GRSnapshot *original) {
    unsigned char *raw=NULL;size_t n=0,i;char type[7];GHCommitInfo info;GIReadLimits traversal;GIIndex index;const GIEntry *a,*b;int result;
    GIInit(&index);memset(&traversal,0,sizeof(traversal));traversal.entries=limits->entries;traversal.depth=limits->depth;traversal.pathBytes=limits->pathBytes;traversal.progress=fn;traversal.context=ctx;
    result=GSGetObject(reader,state->head,type,&raw,&n);if(!result)result=strcmp(type,"commit")?GS_FORMAT:GHCommitParse(raw,n,&info);
    if(!result)result=GRFromTreeBounded(reader,info.tree,original,&traversal);
    if(!result)result=GIParse(state->before[2].bytes,state->before[2].length,&index);
    if(!result && index.count!=original->index.count)result=GS_CONFLICT;
    for(i=0;!result && i<index.count;++i) {
        a=index.entries+i;b=original->index.entries+i;
        if(strcmp(a->path,b->path) || a->stat[6]!=b->stat[6] || memcmp(a->oid,b->oid,20) || (a->flags&0x3000) || (a->extended&0x6000))result=GS_CONFLICT;
    }
    if(!result){original->haveCommit=1;memcpy(original->commit,state->head,20);}free(raw);GIFree(&index);return result;
}
int RVVerify(GSRepository *source,const RZState *state,const RZLimits *records,const RRLimits *limits,
    GPEqual eq,void *eqContext,GDProgress progress,void *context,RVVerified *destination) {
    RVVerified *next;GOReader reads;GSRepository reader;RSStep step;MSChoices proof;MSValues values;RPResult receipt;RCCommit validation;
    unsigned char *wire=NULL,tip[20],id[20];size_t n=0,i;int result;
    if(!source || !source->read || !state || !limits || !destination || !eq)return GB_BAD;
    result=RZEncode(state,records,eq,eqContext,&wire,&n);
    if(!result && state->original && (n!=state->originalLength || memcmp(wire,state->original,n)))result=GS_CONFLICT;
    free(wire);if(result)return result;
    result=GOReadStart(source,&limits->all,progress,context,&reads,&reader);if(result)return result;reader.replace=RVExisting;
    next=(RVVerified *)calloc(1,sizeof(*next));if(!next)return GB_MEMORY;RSInit(&step);MSChoicesInit(&proof);MSValuesInit(&values);RCInit(&validation);
    result=RBPrepare(&reader,state->head,state->onto,&limits->plan,progress,context,&next->graph);
    if(!result && (next->graph.kind!=RB_REPLAY || next->graph.count!=state->count || memcmp(next->graph.commits,state->commits,state->count*20)))result=GS_CONFLICT;
    if(!result)result=RVHead(&reader,state,&limits->step,progress,context,&next->original);
    memcpy(tip,state->onto,20);
    for(i=0;!result && i<state->completed;++i) {
        result=RSPrepare(&reader,state->commits[i],tip,state->newline,&limits->step,progress,context,&step);
        if(!result && RVZero(state->proofs[i])) {
            if(step.kind==RS_CONFLICT)result=GS_CONFLICT;
            else result=RPPublish(&reader,&step,state->committer,state->seconds,state->zone,progress,context,&receipt);
        } else if(!result) {
            if(step.kind!=RS_CONFLICT)result=GS_CONFLICT;
            else result=RYLoadProof(&reader,&step,state->branch,state->ontoRef,state->proofs[i],records,progress,context,&proof,&values);
            if(!result)result=RXPublish(&reader,&step,values.items,values.count,state->committer,state->seconds,state->zone,progress,context,&receipt);
        }
        if(!result && (memcmp(receipt.commit,state->receipts[i].tip,20) || receipt.kind!=state->receipts[i].kind || receipt.droppedSignatures!=state->receipts[i].droppedSignatures))result=GS_CONFLICT;
        if(!result)memcpy(tip,receipt.commit,20);
        RSFree(&step);MSChoicesFree(&proof);MSValuesFree(&values);
    }
    if(!result && memcmp(tip,state->tip,20))result=GS_CONFLICT;
    if(!result)result=RSPrepare(&reader,state->commits[state->completed],tip,state->newline,&limits->step,progress,context,&next->conflict);
    if(!result && next->conflict.kind!=RS_CONFLICT)result=GS_CONFLICT;
    if(!result)result=RCRewrite(next->conflict.original,next->conflict.originalLength,next->conflict.trees[1],state->tip,
        state->committer,state->seconds,state->zone,limits->step.read.objectBytes,&validation);
    if(!result)result=RZStepID(&next->conflict,state->branch,state->ontoRef,id);
    if(!result && memcmp(id,state->planID,20))result=GS_CONFLICT;
    if(!result)result=RYReadChoices(&reader,&next->conflict,state->branch,state->ontoRef,&state->choices,progress,context,&next->choices);
    if(!result && progress)result=progress(context);
    if(!result){next->encodedReadBytes=reads.bytes;next->expandedReadBytes=reads.expanded;next->readCount=reads.reads;RVFree(destination);*destination=*next;RVInit(next);}
    RCFree(&validation);RSFree(&step);MSChoicesFree(&proof);MSValuesFree(&values);RVFree(next);free(next);return result;
}
