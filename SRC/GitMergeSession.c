#include "GitMergeSession.h"
#include <stdlib.h>
#include <string.h>

void MSChoicesInit(MSChoices *c) { memset(c,0,sizeof(*c)); }
void MSChoicesFree(MSChoices *c) {
    size_t i,j;
    for(i=0;i<c->count;++i) { for(j=0;j<c->items[i].count;++j)free(c->items[i].files[j].path);free(c->items[i].files); }
    free(c->items);MSChoicesInit(c);
}
void MSInit(MSState *s) { memset(s,0,sizeof(*s)); }
static void MSBytesFree(MSBytes *b) { free(b->bytes);memset(b,0,sizeof(*b)); }
void MSFree(MSState *s) {
    size_t i;
    free(s->branch);free(s->otherRef);
    for(i=0;i<5;++i)MSBytesFree(s->before+i);
    MSBytesFree(&s->workIndex);MSBytesFree(&s->index);MSBytesFree(&s->mapping);
    MSChoicesFree(&s->choices);
    for(i=0;i<s->affectedCount;++i)free(s->affected[i]);
    free(s->affected);free(s->original);MSInit(s);
}
void MSValuesInit(MSValues *v) { memset(v,0,sizeof(*v)); }
void MSValuesFree(MSValues *v) {
    size_t i;
    for(i=0;i<v->fileCount;++i) { free((void *)v->files[i].path);GRContentsFree(v->contents+i); }
    free(v->items);free(v->files);free(v->contents);MSValuesInit(v);
}
static void *MSCopy(const void *p,size_t n) {
    void *copy=malloc(n?n:1);if(copy && n)memcpy(copy,p,n);return copy;
}
static char *MSString(const char *p) { return (char *)MSCopy(p,strlen(p)+1); }
static int MSZero(const unsigned char *p,size_t n) { size_t i;for(i=0;i<n;++i)if(p[i])return 0;return 1; }
static void MSPut(unsigned char p[4],GBWord v) {
    p[0]=(unsigned char)(v>>24);p[1]=(unsigned char)(v>>16);p[2]=(unsigned char)(v>>8);p[3]=(unsigned char)v;
}
static GBWord MSGet(const unsigned char p[4]) { return ((GBWord)p[0]<<24)|((GBWord)p[1]<<16)|((GBWord)p[2]<<8)|p[3]; }
static void MSHashWord(GBSHA1 *h,GBWord v) { unsigned char p[4];MSPut(p,v);GBSHA1Update(h,p,4); }
static void MSHashBytes(GBSHA1 *h,const void *p,size_t n) { MSHashWord(h,(GBWord)n);if(n)GBSHA1Update(h,p,n); }
int MSPlanID(const MMPlan *p,unsigned char output[20]) {
    GBSHA1 h;size_t i,j;const TMNode *n;const TMRenameGroup *g;const FMResult *f;
    if(!p || !output || p->kind!=MM_CONFLICT || !p->branch || !p->otherRef ||
        p->files.count>65536UL || p->files.groupCount>65536UL)return GB_BAD;
    GBSHA1Start(&h);GBSHA1Update(&h,"GHClient merge plan 1",sizeof("GHClient merge plan 1")-1);
    MSHashBytes(&h,p->branch,strlen(p->branch));MSHashBytes(&h,p->otherRef,strlen(p->otherRef));
    GBSHA1Update(&h,p->tips,40);GBSHA1Update(&h,p->trees,60);
    MSHashWord(&h,p->options);MSHashWord(&h,(unsigned char)p->newline);MSHashWord(&h,(GBWord)p->haveBase);
    MSHashWord(&h,(GBWord)p->files.count);MSHashWord(&h,(GBWord)p->files.groupCount);
    for(i=0;i<p->files.count;++i) {
        n=p->files.files+i;f=&n->proposal;MSHashBytes(&h,n->path,strlen(n->path));
        for(j=0;j<3;++j)MSHashWord(&h,n->source[j]==TM_NONE?0xffffffffU:(GBWord)n->source[j]);
        for(j=0;j<2;++j)MSHashWord(&h,(GBWord)n->ambiguity[j]);
        MSHashWord(&h,n->conflicts);MSHashWord(&h,n->renamed);MSHashWord(&h,(GBWord)(n->selected+2));
        MSHashWord(&h,(GBWord)(f->present+1));MSHashWord(&h,f->mode);MSHashWord(&h,f->conflicts);
        MSHashWord(&h,(GBWord)(f->hasFinderInfo+1));GBSHA1Update(&h,f->finderInfo,32);GBSHA1Update(&h,f->gitlink,20);
        MSHashWord(&h,f->data.bytes!=NULL);MSHashWord(&h,(GBWord)f->data.binary);MSHashWord(&h,(GBWord)f->data.coarse);
        MSHashBytes(&h,f->data.bytes,f->data.length);MSHashBytes(&h,f->resource,f->resourceLength);
        MSHashWord(&h,(GBWord)f->data.count);
        for(j=0;j<f->data.count;++j) {
            const GMTextConflict *c=f->data.conflicts+j;
            MSHashWord(&h,(GBWord)c->baseStart);MSHashWord(&h,(GBWord)c->baseEnd);
            MSHashWord(&h,(GBWord)c->currentStart);MSHashWord(&h,(GBWord)c->currentEnd);
            MSHashWord(&h,(GBWord)c->otherStart);MSHashWord(&h,(GBWord)c->otherEnd);
            MSHashWord(&h,(GBWord)c->outputStart);MSHashWord(&h,(GBWord)c->outputEnd);
        }
    }
    for(i=0;i<p->files.groupCount;++i) {
        g=p->files.groups+i;MSHashWord(&h,(GBWord)g->side);MSHashWord(&h,(GBWord)g->baseCount);MSHashWord(&h,(GBWord)g->addedCount);
        for(j=0;j<g->baseCount;++j)MSHashWord(&h,(GBWord)g->base[j]);
        for(j=0;j<g->addedCount;++j)MSHashWord(&h,(GBWord)g->added[j]);
    }
    GBSHA1Finish(&h,output);return 0;
}
int MSCapture(const MMPlan *p,MSState *out) {
    MSState s;size_t i;int error;
    if(!out)return GB_BAD;
    MSInit(&s);error=MSPlanID(p,s.planID);if(error)return error;
    s.branch=MSString(p->branch);s.otherRef=MSString(p->otherRef);
    if(!s.branch || !s.otherRef){error=GB_MEMORY;goto done;}
    memcpy(s.tips,p->tips,40);memcpy(s.trees,p->trees,60);memcpy(s.choices.planID,s.planID,20);
    s.options=p->options;s.newline=p->newline;s.haveBase=p->haveBase;
    for(i=0;i<5;++i) {
        s.before[i].present=p->guards[i].present;s.before[i].length=p->guards[i].length;
        if(s.before[i].present) { s.before[i].bytes=(unsigned char *)MSCopy(p->guards[i].bytes,p->guards[i].length);
            if(!s.before[i].bytes){error=GB_MEMORY;goto done;} }
    }
    MSFree(out);*out=s;MSInit(&s);
done:MSFree(&s);return error;
}

static int MSLimitsOK(const MSLimits *l) {
    return l && l->bytes && l->bytes<=16777216UL && l->choices<=65536UL && l->files<=65535UL &&
        l->paths<=65536UL && l->pathBytes && l->pathBytes<=65536UL;
}
static int MSPath(const char *p,const MSLimits *l) {
    char key[96];return p && strlen(p)<=l->pathBytes && !GIMacMetadataPath(p,key);
}
static int MSChoicesShape(const MSChoices *c,const MSLimits *l) {
    size_t i,j,total=0;const MSChoice *choice;const MSFile *f;
    if(!c || c->count>l->choices || (c->count && !c->items) || MSZero(c->planID,20))return GB_BAD;
    for(i=0;i<c->count;++i) {
        choice=c->items+i;
        if(choice->node>=65536UL || (i && c->items[i-1].node>=choice->node) ||
            choice->count>l->files-total || (choice->count && !choice->files))return GB_BAD;
        total+=choice->count;
        for(j=0;j<choice->count;++j) {
            f=choice->files+j;
            if(!MSPath(f->path,l) || (j && strcmp(choice->files[j-1].path,f->path)>=0) ||
                (f->mode!=0100644 && f->mode!=0100755 && f->mode!=0120000 && f->mode!=0160000) ||
                MSZero(f->dataOID,20) || ((f->mode&0170000)!=0100000 && !MSZero(f->metadataOID,20)))return GB_BAD;
        }
    }
    return 0;
}
static int MSIndexShape(const MSBytes *b,int unmerged) {
    GIIndex in;size_t i;int error;
    if(!b->present)return 0;
    GIInit(&in);error=GIParse(b->bytes,b->length,&in);
    for(i=0;!error && i<in.count;++i) {
        if((in.entries[i].flags&0xc000U) || in.entries[i].extended)error=GI_UNSUPPORTED;
        else if(!unmerged && (in.entries[i].flags&0x3000U))error=GI_UNMERGED;
    }
    GIFree(&in);return error;
}
static int MSRefBytes(const MSBytes *b,const char *name,const unsigned char tip[20]) {
    char hex[41];size_t n=strlen(name);GBOIDFormat(tip,hex);
    return b->present && b->length==n+42 && !memcmp(b->bytes,name,n+1) &&
        !memcmp(b->bytes+n+1,hex,40) && b->bytes[n+41]=='\n';
}
static int MSShape(const MSState *s,const MSLimits *l,GPEqual eq,void *ctx) {
    const MSBytes *b;GPMap map;size_t i,total=0,n;int error;
    if(!s || !MSLimitsOK(l) || !eq || !GSValidRef(s->branch) ||
        (!GSValidRef(s->otherRef) && !GSValidTrackingRef(s->otherRef)) ||
        strlen(s->branch)>l->pathBytes || strlen(s->otherRef)>l->pathBytes ||
        s->options&~(MM_ALLOW_UNRELATED|MM_NO_FF|MM_SQUASH) || (s->newline!='\n' && s->newline!='\r') ||
        (s->haveBase!=0 && s->haveBase!=1) || !s->generation || s->revision<s->generation || MSZero(s->binding,32) ||
        MSZero(s->planID,20) || MSZero(s->workspace,20) ||
        memcmp(s->planID,s->choices.planID,20) || s->affectedCount>l->paths ||
        (s->affectedCount && !s->affected))return GB_BAD;
    for(i=0;i<8;++i) {
        b=i<5?s->before+i:i==5?&s->workIndex:i==6?&s->index:&s->mapping;
        if((b->present!=0 && b->present!=1) || (!b->present && b->length) ||
            (b->present && !b->bytes) || b->length>l->bytes-total)return GB_BAD;
        total+=b->length;
    }
    n=strlen(s->branch);
    if(!s->before[0].present || s->before[0].length!=n+6 || memcmp(s->before[0].bytes,"ref: ",5) ||
        memcmp(s->before[0].bytes+5,s->branch,n) || s->before[0].bytes[n+5]!='\n' ||
        !MSRefBytes(s->before+1,s->branch,s->tips) || !MSRefBytes(s->before+4,s->otherRef,s->tips+20) ||
        MSZero(s->trees[1],20) || MSZero(s->trees[2],20) || (!!s->haveBase==MSZero(s->trees[0],20)) ||
        !s->workIndex.present || !s->index.present || !s->mapping.present)return GS_FORMAT;
    error=MSIndexShape(s->before+2,0);
    if(!error)error=MSIndexShape(&s->workIndex,0);
    if(!error)error=MSIndexShape(&s->index,1);
    GPInit(&map);
    if(!error && s->before[3].present)error=GPParse(s->before[3].bytes,s->before[3].length,eq,ctx,&map);
    if(!error)error=GPParse(s->mapping.bytes,s->mapping.length,eq,ctx,&map);
    GPFree(&map);if(error)return error;
    for(i=0;i<s->affectedCount;++i)
        if(!MSPath(s->affected[i],l) || (i && strcmp(s->affected[i-1],s->affected[i])>=0))return GB_BAD;
    return MSChoicesShape(&s->choices,l);
}

typedef struct { unsigned char *bytes;size_t length,capacity,limit;int error; } MSBuffer;
static void MSAppend(MSBuffer *b,const void *p,size_t n) {
    size_t cap;unsigned char *next;
    if(b->error)return;
    if(n>b->limit-b->length){b->error=GB_SPACE;return;}
    if(b->length+n>b->capacity) {
        cap=b->capacity?b->capacity:256;if(cap>b->limit)cap=b->limit;
        while(cap<b->length+n)cap=cap>b->limit/2?b->limit:cap*2;
        next=(unsigned char *)realloc(b->bytes,cap);if(!next){b->error=GB_MEMORY;return;}b->bytes=next;b->capacity=cap;
    }
    if(n)memcpy(b->bytes+b->length,p,n);
    b->length+=n;
}
static void MSWord(MSBuffer *b,GBWord v) { unsigned char p[4];MSPut(p,v);MSAppend(b,p,4); }
static void MSField(MSBuffer *b,const void *p,size_t n) { MSWord(b,(GBWord)n);MSAppend(b,p,n); }
static void MSBytesPut(MSBuffer *out,const MSBytes *b) { MSWord(out,(GBWord)b->present);MSField(out,b->bytes,b->length); }
int MSEncode(const MSState *s,const MSLimits *l,GPEqual eq,void *ctx,unsigned char **bytes,size_t *length) {
    MSBuffer b;GBSHA1 h;unsigned char digest[20];size_t i,j;const MSChoice *c;const MSFile *f;int error;
    if(!bytes || !length)return GB_BAD;
    error=MSShape(s,l,eq,ctx);if(error)return error;
    memset(&b,0,sizeof(b));b.limit=l->bytes;
    MSAppend(&b,"GHMS0002",8);MSWord(&b,s->generation);MSWord(&b,s->revision);MSWord(&b,s->options);MSWord(&b,(unsigned char)s->newline);MSWord(&b,(GBWord)s->haveBase);
    MSField(&b,s->branch,strlen(s->branch));MSField(&b,s->otherRef,strlen(s->otherRef));
    MSAppend(&b,s->tips,40);MSAppend(&b,s->trees,60);MSAppend(&b,s->planID,20);MSAppend(&b,s->workspace,20);
    MSAppend(&b,s->binding,32);
    for(i=0;i<5;++i)MSBytesPut(&b,s->before+i);
    MSBytesPut(&b,&s->workIndex);MSBytesPut(&b,&s->index);MSBytesPut(&b,&s->mapping);
    MSWord(&b,(GBWord)s->affectedCount);
    for(i=0;i<s->affectedCount;++i)MSField(&b,s->affected[i],strlen(s->affected[i]));
    MSWord(&b,(GBWord)s->choices.count);
    for(i=0;i<s->choices.count;++i) {
        c=s->choices.items+i;MSWord(&b,(GBWord)c->node);MSWord(&b,(GBWord)c->count);
        for(j=0;j<c->count;++j) { f=c->files+j;MSField(&b,f->path,strlen(f->path));MSWord(&b,f->mode);MSAppend(&b,f->dataOID,20);MSAppend(&b,f->metadataOID,20); }
    }
    if(!b.error) { GBSHA1Start(&h);GBSHA1Update(&h,b.bytes,b.length);GBSHA1Finish(&h,digest);MSAppend(&b,digest,20); }
    if(b.error){free(b.bytes);return b.error;}*bytes=b.bytes;*length=b.length;return 0;
}
typedef struct { const unsigned char *p,*end;int error; } MSReader;
static GBWord MSWordRead(MSReader *r) {
    GBWord v;if(r->error)return 0;if(r->end-r->p<4){r->error=GS_FORMAT;return 0;}v=MSGet(r->p);r->p+=4;return v;
}
static void MSFixed(MSReader *r,void *out,size_t n) {
    if(r->error)return;
    if(n>(size_t)(r->end-r->p)){r->error=GS_FORMAT;return;}memcpy(out,r->p,n);r->p+=n;
}
static unsigned char *MSFieldRead(MSReader *r,size_t limit,size_t *length,int text) {
    size_t n=MSWordRead(r);unsigned char *p;
    if(r->error)return NULL;
    if(n>limit || n>(size_t)(r->end-r->p) || (text && (!n || memchr(r->p,0,n)))){r->error=GS_FORMAT;return NULL;}
    p=(unsigned char *)malloc(n+(text?1:!n));if(!p){r->error=GB_MEMORY;return NULL;}
    if(n)memcpy(p,r->p,n);
    if(text)p[n]=0;
    r->p+=n;*length=n;return p;
}
static void MSBytesRead(MSReader *r,MSBytes *b,size_t limit) {
    GBWord present=MSWordRead(r);b->present=(int)present;
    b->bytes=MSFieldRead(r,limit,&b->length,0);
    if(!r->error && (present>1 || (!present && b->length)))r->error=GS_FORMAT;
    if(!present){free(b->bytes);b->bytes=NULL;}
}
int MSParse(const void *data,size_t length,const MSLimits *l,GPEqual eq,void *ctx,MSState *out) {
    MSState s;MSReader r;GBSHA1 h;unsigned char digest[20];const unsigned char *p=(const unsigned char *)data;
    size_t i,j,n,total=0;GBWord count;MSChoice *c;MSFile *f;int error;
    if(!out || !MSLimitsOK(l) || !eq || !data || length<28)return GB_BAD;
    if(length>l->bytes)return GB_SPACE;
    if(memcmp(p,"GHMS0001",8) && memcmp(p,"GHMS0002",8))return GS_FORMAT;
    GBSHA1Start(&h);GBSHA1Update(&h,p,length-20);GBSHA1Finish(&h,digest);
    if(memcmp(digest,p+length-20,20))return GB_CHECKSUM;
    MSInit(&s);r.p=p+8;r.end=p+length-20;r.error=0;
    s.generation=MSWordRead(&r);s.revision=p[7]=='2'?MSWordRead(&r):s.generation;
    s.options=MSWordRead(&r);count=MSWordRead(&r);if(count!='\r' && count!='\n')r.error=GS_FORMAT;s.newline=(char)count;
    count=MSWordRead(&r);if(count>1)r.error=GS_FORMAT;s.haveBase=(int)count;
    s.branch=(char *)MSFieldRead(&r,l->pathBytes,&n,1);s.otherRef=(char *)MSFieldRead(&r,l->pathBytes,&n,1);
    MSFixed(&r,s.tips,40);MSFixed(&r,s.trees,60);MSFixed(&r,s.planID,20);MSFixed(&r,s.workspace,20);
    MSFixed(&r,s.binding,32);
    memcpy(s.choices.planID,s.planID,20);
    for(i=0;i<5;++i)MSBytesRead(&r,s.before+i,l->bytes);
    MSBytesRead(&r,&s.workIndex,l->bytes);MSBytesRead(&r,&s.index,l->bytes);MSBytesRead(&r,&s.mapping,l->bytes);
    count=MSWordRead(&r);
    if(!r.error && (count>l->paths || count>(size_t)(r.end-r.p)/5))r.error=GS_FORMAT;
    if(!r.error && count) { s.affected=(char **)calloc(count,sizeof(*s.affected));if(!s.affected)r.error=GB_MEMORY;else s.affectedCount=count; }
    for(i=0;!r.error && i<s.affectedCount;++i)s.affected[i]=(char *)MSFieldRead(&r,l->pathBytes,&n,1);
    count=MSWordRead(&r);
    if(!r.error && (count>l->choices || count>(size_t)(r.end-r.p)/8))r.error=GS_FORMAT;
    if(!r.error && count) { s.choices.items=(MSChoice *)calloc(count,sizeof(*s.choices.items));if(!s.choices.items)r.error=GB_MEMORY;else s.choices.count=count; }
    for(i=0;!r.error && i<s.choices.count;++i) {
        c=s.choices.items+i;c->node=MSWordRead(&r);count=MSWordRead(&r);
        if(!r.error && (count>l->files-total || count>(size_t)(r.end-r.p)/49))r.error=GS_FORMAT;
        if(!r.error && count) { c->files=(MSFile *)calloc(count,sizeof(*c->files));if(!c->files)r.error=GB_MEMORY;else c->count=count; }
        total+=c->count;
        for(j=0;!r.error && j<c->count;++j) {
            f=c->files+j;f->path=(char *)MSFieldRead(&r,l->pathBytes,&n,1);f->mode=MSWordRead(&r);
            MSFixed(&r,f->dataOID,20);MSFixed(&r,f->metadataOID,20);
        }
    }
    error=r.error;if(!error && r.p!=r.end)error=GS_FORMAT;
    if(!error)error=MSShape(&s,l,eq,ctx);
    if(!error) { s.original=(unsigned char *)MSCopy(data,length);if(!s.original)error=GB_MEMORY;else s.originalLength=length; }
    if(!error){MSFree(out);*out=s;MSInit(&s);}MSFree(&s);return error;
}

typedef struct {
    GSRepository *source,objects;
    GOReader bounds;
    const MSState *state;
    char keys[5][64];
    size_t metadataLimit;
    GDProgress progress;void *context;int writable;
} MSIO;
static int MSTick(MSIO *io) { return io->progress?io->progress(io->context):0; }
static int MSRead(void *context,const char *key,unsigned char **bytes,size_t *length) {
    MSIO *io=(MSIO *)context;size_t i;int error;
    *bytes=NULL;*length=0;
    if(!strncmp(key,"objects/",8))return io->objects.read(io->objects.context,key,bytes,length);
    if(!io->state)return GS_FORMAT;
    error=MSTick(io);if(error)return error;
    for(i=0;i<5;++i)if(!strcmp(io->keys[i],key)) {
        if(!io->state->before[i].present)return GS_NOT_FOUND;
        *bytes=(unsigned char *)MSCopy(io->state->before[i].bytes,io->state->before[i].length);
        if(!*bytes)return GB_MEMORY;
        *length=io->state->before[i].length;break;
    }
    if(i==5)error=io->source->read(io->source->context,key,bytes,length);
    if(!error && *length>io->metadataLimit)error=GB_SPACE;
    if(!error)error=MSTick(io);
    if(error){free(*bytes);*bytes=NULL;*length=0;}return error;
}
static int MSReplace(void *context,const char *key,const void *before,size_t bn,const void *after,size_t an) {
    MSIO *io=(MSIO *)context;int error;
    if(!io->writable || strncmp(key,"objects/",8) || before || bn)return GS_FORMAT;
    error=MSTick(io);if(!error)error=io->source->replace(io->source->context,key,NULL,0,after,an);
    if(!error)error=MSTick(io);
    return error;
}
static int MSIOStart(GSRepository *source,const MMLimits *limits,const MSState *state,int writable,
                        GDProgress progress,void *ctx,MSIO *io,GSRepository *repository) {
    int error;
    if(!source || !source->read || (writable && !source->replace) || !limits || !limits->stateBytes)return GB_BAD;
    memset(io,0,sizeof(*io));io->source=source;io->state=state;io->metadataLimit=limits->stateBytes;
    io->progress=progress;io->context=ctx;io->writable=writable;
    error=GOReadStart(source,&limits->tree.read,progress,ctx,&io->bounds,&io->objects);
    if(!error && state) {
        size_t i;
        for(i=0;!error && i<5;++i) {
            const MSBytes *b=state->before+i;
            if((b->present!=0 && b->present!=1) || (!b->present && b->length) || (b->present && !b->bytes))error=GB_BAD;
            else if(b->length>limits->stateBytes)error=GB_SPACE;
        }
        if(error)return error;
        strcpy(io->keys[0],"HEAD");strcpy(io->keys[2],"index");strcpy(io->keys[3],"ghclient-map");
        error=GSRefKey(state->branch,io->keys[1]);if(!error)error=GSRefKey(state->otherRef,io->keys[4]);
        if(!error && !strcmp(io->keys[1],io->keys[4]))error=GS_FORMAT;
    }
    if(!error){repository->context=io;repository->read=MSRead;repository->replace=MSReplace;}return error;
}
static int MSFileOrder(const void *a,const void *b) { return strcmp(((const MSFile *)a)->path,((const MSFile *)b)->path); }
int MSMakeChoices(GSRepository *source,const MMPlan *plan,const TMResolution *input,size_t count,
                     GDProgress progress,void *context,MSChoices *out) {
    MSChoices next;TMDraft draft;MSIO io;GSRepository repository;MSChoice *c;MSFile *f;const GIEntry *e;
    size_t i,j;char key[96];int error;
    if(!out || !plan)return GB_BAD;
    MSChoicesInit(&next);TMDraftInit(&draft);
    error=MSPlanID(plan,next.planID);
    if(!error)error=MSIOStart(source,&plan->limits,NULL,1,progress,context,&io,&repository);
    if(!error)error=TMBuildResolvedIndex(&repository,&plan->files,input,count,progress,context,&draft);
    if(!error && count) { next.items=(MSChoice *)calloc(count,sizeof(*next.items));if(!next.items)error=GB_MEMORY;else next.count=count; }
    for(i=0;!error && i<count;++i) {
        c=next.items+i;c->node=input[i].node;
        if(input[i].count) { c->files=(MSFile *)calloc(input[i].count,sizeof(*c->files));if(!c->files)error=GB_MEMORY;else c->count=input[i].count; }
        for(j=0;!error && j<c->count;++j) {
            error=MSTick(&io);if(error)break;
            f=c->files+j;f->path=MSString(input[i].outputs[j].path);if(!f->path){error=GB_MEMORY;break;}
            e=GIFind(&draft.index,f->path,0);if(!e){error=GS_FORMAT;break;}f->mode=e->stat[6];memcpy(f->dataOID,e->oid,20);
            error=GIMacMetadataPath(f->path,key);if(!error) { e=GIFind(&draft.index,key,0);if(e)memcpy(f->metadataOID,e->oid,20); }
        }
        if(!error && c->count)qsort(c->files,c->count,sizeof(*c->files),MSFileOrder);
    }
    if(!error)error=TMStoreObjects(&repository,&draft,progress,context);
    if(!error)error=MSTick(&io);
    if(!error){MSChoicesFree(out);*out=next;MSChoicesInit(&next);}
    TMDraftFree(&draft);MSChoicesFree(&next);return error;
}
static int MSBlob(GSRepository *r,const unsigned char id[20],unsigned char **bytes,size_t *length) {
    char type[7];int error=GSGetObject(r,id,type,bytes,length);
    if(!error && strcmp(type,"blob")){free(*bytes);*bytes=NULL;*length=0;error=GS_FORMAT;}return error;
}
static int MSRetain(const MMPlan *plan,size_t *retained,size_t n) {
    if(*retained>plan->limits.tree.retainedBytes || n>plan->limits.tree.retainedBytes-*retained)return GB_SPACE;
    *retained+=n;return 0;
}
static int MSChoiceValue(GSRepository *r,const MMPlan *plan,const MSFile *file,TMOutput *out,GRContents *contents,size_t *retained) {
    const unsigned char *resource;unsigned char *encoded=NULL,id[20];char *path=NULL;size_t rn,n;int error=0;
    out->path=MSString(file->path);if(!out->path)return GB_MEMORY;out->file.mode=file->mode;
    if(file->mode==0160000){memcpy(out->file.gitlink,file->dataOID,20);return 0;}
    error=MSBlob(r,file->dataOID,&contents->data,&contents->dataLength);
    if(!error)error=MSRetain(plan,retained,contents->dataLength);
    if(!error && (contents->dataLength>2097152UL || contents->dataLength>plan->limits.tree.file.text.outputBytes))error=GB_SPACE;
    if(!error && !MSZero(file->metadataOID,20)) {
        error=MSBlob(r,file->metadataOID,&contents->metadata,&n);
        if(!error)error=MSRetain(plan,retained,n);
        if(!error)error=GIMacDecode(contents->metadata,n,&path,contents->finderInfo,&resource,&rn);
        if(!error && strcmp(path,file->path))error=GS_FORMAT;
        if(!error && (rn>2097152UL || rn>plan->limits.tree.file.resourceBytes))error=GB_SPACE;
        if(!error)error=GIMacEncode(path,contents->finderInfo,resource,rn,&encoded,&n);
        if(!error)error=GBObjectID("blob",encoded,n,id);
        if(!error && memcmp(id,file->metadataOID,20))error=GS_FORMAT;
        if(!error){contents->hasFinderInfo=1;contents->resource=resource;contents->resourceLength=rn;}
    }
    if(!error) {
        out->file.data=contents->data;out->file.dataLength=contents->dataLength;
        out->file.resource=contents->resource;out->file.resourceLength=contents->resourceLength;
        out->file.hasFinderInfo=contents->hasFinderInfo;memcpy(out->file.finderInfo,contents->finderInfo,32);
    }
    free(path);free(encoded);return error;
}
int MSReadChoices(GSRepository *source,const MMPlan *plan,const MSChoices *choices,GDProgress progress,void *ctx,MSValues *out) {
    MSValues next;MSIO io;GSRepository repository;MSLimits shape;
    unsigned char id[20];size_t i,j,total=0,at=0,retained=0;TMDraft checked;int error;
    if(!plan || !out)return GB_BAD;
    memset(&shape,0,sizeof(shape));shape.choices=65536UL;shape.files=65535UL;shape.pathBytes=plan->limits.tree.pathBytes;
    error=MSChoicesShape(choices,&shape);if(!error)error=MSPlanID(plan,id);
    if(!error && memcmp(id,choices->planID,20))error=GS_CONFLICT;
    if(error)return error;
    for(i=0;i<choices->count;++i) {
        if(choices->items[i].node>=plan->files.count || !plan->files.files[choices->items[i].node].conflicts)return GS_FORMAT;
        total+=choices->items[i].count;
    }
    MSValuesInit(&next);TMDraftInit(&checked);error=MSIOStart(source,&plan->limits,NULL,0,progress,ctx,&io,&repository);
    if(!error && choices->count) { next.items=(TMResolution *)calloc(choices->count,sizeof(*next.items));if(!next.items)error=GB_MEMORY;else next.count=choices->count; }
    if(!error && total) {
        next.files=(TMOutput *)calloc(total,sizeof(*next.files));next.contents=(GRContents *)calloc(total,sizeof(*next.contents));
        if(!next.files || !next.contents)error=GB_MEMORY;else next.fileCount=total;
    }
    for(i=0;!error && i<choices->count;++i) {
        next.items[i].node=choices->items[i].node;next.items[i].count=choices->items[i].count;
        next.items[i].outputs=choices->items[i].count?next.files+at:NULL;
        for(j=0;!error && j<choices->items[i].count;++j,++at) {
            error=MSTick(&io);
            if(!error)error=MSChoiceValue(&repository,plan,choices->items[i].files+j,next.files+at,next.contents+at,&retained);
        }
    }
    if(!error)error=TMBuildResolvedIndex(&repository,&plan->files,next.items,next.count,progress,ctx,&checked);
    if(!error)error=MSTick(&io);
    if(!error){MSValuesFree(out);*out=next;MSValuesInit(&next);}
    TMDraftFree(&checked);MSValuesFree(&next);return error;
}
void MSWorkspaceInit(MSWorkspace *w) { memset(w,0,sizeof(*w)); }
void MSWorkspaceFree(MSWorkspace *w) {
    TMDraftFree(&w->index);TMDraftFree(&w->preview);MSWorkspaceInit(w);
}
static int MSPreviewFile(GSRepository *r,const MMPlan *plan,const GRFile *file,GRContents *c,size_t *retained) {
    const GRSnapshot *s=plan->files.snapshots+1;char *logical=NULL;size_t n;int error;
    if(file->entry>=s->index.count)return GS_FORMAT;
    error=MSBlob(r,s->index.entries[file->entry].oid,&c->data,&c->dataLength);
    if(!error && c->dataLength!=file->dataLength)error=GS_FORMAT;
    if(!error)error=MSRetain(plan,retained,c->dataLength);
    if(!error && file->hasFinderInfo) {
        if(file->metadataEntry>=s->index.count)error=GS_FORMAT;
        else error=MSBlob(r,s->index.entries[file->metadataEntry].oid,&c->metadata,&n);
        if(!error)error=MSRetain(plan,retained,n);
        if(!error)error=GIMacDecode(c->metadata,n,&logical,c->finderInfo,&c->resource,&c->resourceLength);
        if(!error && (strcmp(logical,file->path) || c->resourceLength!=file->resourceLength ||
            memcmp(c->finderInfo,file->finderInfo,32)))error=GS_FORMAT;
        if(!error)c->hasFinderInfo=1;
    }
    free(logical);return error;
}
static void MSPreviewComponents(const TMNode *node,FMVersion *v) {
    const FMResult *p=&node->proposal;
    unsigned structural=TM_DIRECTORY|TM_RENAME_DIVERGENT|TM_RENAME_DELETE|TM_RENAME_AMBIGUOUS|TM_PATH_COLLISION;
    if(node->selected!=-1 || (node->conflicts & structural) || p->present!=1 ||
       (v->mode & 0170000)!=0100000 || (p->mode & 0170000)!=0100000 ||
       (p->conflicts & (FM_KIND|FM_PRESENCE)))return;
    if(!(p->conflicts & FM_MODE))v->mode=p->mode;
    if(!(p->conflicts & FM_DATA) || (!p->data.binary && p->data.count)) {
        v->data=p->data.bytes;v->dataLength=p->data.length;
    }
    if(!(p->conflicts & (FM_METADATA|FM_RESOURCE|FM_FINDER))) {
        v->hasFinderInfo=p->hasFinderInfo;memcpy(v->finderInfo,p->finderInfo,32);
        v->resource=p->resource;v->resourceLength=p->resourceLength;
    } else if(!(p->conflicts & FM_METADATA) && v->hasFinderInfo && p->hasFinderInfo==1) {
        if(!(p->conflicts & FM_RESOURCE)){v->resource=p->resource;v->resourceLength=p->resourceLength;}
        if(!(p->conflicts & FM_FINDER))memcpy(v->finderInfo,p->finderInfo,32);
    }
}
int MSBuildWorkspace(GSRepository *source,const MMPlan *plan,const MSChoices *choices,
                       GDProgress progress,void *ctx,MSWorkspace *out) {
    MSWorkspace next;MSValues values;MSIO io;GSRepository repository;
    TMResolution *all=NULL;TMOutput *fallback=NULL;GRContents *contents=NULL;
    unsigned char *seen=NULL;const TMNode *node;const GRFile *file;FMVersion *v;
    size_t i,ci=0,count=0,at=0,unresolved=0,retained=0;int error;
    if(!plan || !out)return GB_BAD;
    MSWorkspaceInit(&next);MSValuesInit(&values);
    error=MSReadChoices(source,plan,choices,progress,ctx,&values);
    for(i=0;!error && i<values.fileCount;++i) {
        error=MSRetain(plan,&retained,values.contents[i].dataLength);
        if(!error && values.contents[i].metadata)
            error=MSRetain(plan,&retained,12+strlen(values.files[i].path)+82+values.contents[i].resourceLength);
    }
    if(!error)error=MSIOStart(source,&plan->limits,NULL,0,progress,ctx,&io,&repository);
    if(!error)error=TMBuildResolvedIndex(&repository,&plan->files,values.items,values.count,progress,ctx,&next.index);
    if(error)goto done;
    for(i=0;i<plan->files.count;++i)if(plan->files.files[i].conflicts)++count;
    all=(TMResolution *)calloc(count?count:1,sizeof(*all));fallback=(TMOutput *)calloc(count?count:1,sizeof(*fallback));
    contents=(GRContents *)calloc(count?count:1,sizeof(*contents));
    seen=(unsigned char *)calloc(plan->files.snapshots[1].count?plan->files.snapshots[1].count:1,1);
    if(!all || !fallback || !contents || !seen){error=GB_MEMORY;goto done;}
    for(i=0;i<plan->files.count && !error;++i) {
        node=plan->files.files+i;if(!node->conflicts)continue;
        error=MSTick(&io);if(error)break;
        if(ci<values.count && values.items[ci].node==i){all[at++]=values.items[ci++];continue;}
        all[at].node=i;++unresolved;
        if(node->source[1]!=TM_NONE) {
            if(node->source[1]>=plan->files.snapshots[1].count){error=GS_FORMAT;break;}
            if(!seen[node->source[1]]) {
                seen[node->source[1]]=1;file=plan->files.snapshots[1].files+node->source[1];
                fallback[at].path=file->path;v=&fallback[at].file;v->mode=file->mode;
                if(file->mode==0160000)memcpy(v->gitlink,plan->files.snapshots[1].index.entries[file->entry].oid,20);
                else {
                    error=MSPreviewFile(&repository,plan,file,contents+at,&retained);
                    if(error)break;
                    v->data=contents[at].data;v->dataLength=contents[at].dataLength;
                    v->resource=contents[at].resource;v->resourceLength=contents[at].resourceLength;
                    v->hasFinderInfo=contents[at].hasFinderInfo;memcpy(v->finderInfo,contents[at].finderInfo,32);
                    MSPreviewComponents(node,v);
                }
                all[at].outputs=fallback+at;all[at].count=1;
            }
        }
        ++at;
    }
    if(!error)error=TMBuildResolvedIndex(&repository,&plan->files,all,at,progress,ctx,&next.preview);
    if(!error && next.index.unresolved!=unresolved)error=GS_FORMAT;
    if(!error){next.preview.unresolved=unresolved;error=MSTick(&io);}
    if(!error){MSWorkspaceFree(out);*out=next;MSWorkspaceInit(&next);}
done:
    if(contents)for(i=0;i<count;++i)GRContentsFree(contents+i);
    free(all);free(fallback);free(contents);free(seen);MSValuesFree(&values);MSWorkspaceFree(&next);return error;
}
int MSRestorePlan(GSRepository *source,const MSState *state,const MMLimits *limits,GDProgress progress,void *ctx,MMPlan *out) {
    MMPlan next;MSIO io;GSRepository repository;unsigned char id[20];int error;
    if(!state || !out || !limits || !state->branch || !state->otherRef)return GB_BAD;
    MMInit(&next);error=MSIOStart(source,limits,state,0,progress,ctx,&io,&repository);
    if(!error)error=MMPrepare(&repository,state->branch,state->tips,state->otherRef,state->tips+20,state->options,
        state->newline,limits,progress,ctx,&next);
    if(!error)error=MSPlanID(&next,id);
    if(!error && (memcmp(id,state->planID,20) || memcmp(next.trees,state->trees,60) || next.haveBase!=state->haveBase))error=GS_CONFLICT;
    if(!error){MMFree(out);*out=next;MMInit(&next);}MMFree(&next);return error;
}
