#include "GitText.h"
#include "GitPathMap.h"
#include <stdlib.h>
#include <string.h>

void GETextInit(GEText *t) { memset(t, 0, sizeof(*t)); }
void GETextFree(GEText *t) {
    free(t->original); free(t->text); GETextInit(t);
}
static int GEVisible(unsigned c) { return c >= 32 && c != 127; }
int GETextOpen(GEText *out, const void *input, size_t n) {
    const unsigned char *p = (const unsigned char *)input;
    GEText t;
    size_t i = 0;
    unsigned c, next, minimum;
    int trailing, mac, lf = 0, crlf = 0, cr = 0, result = 0;
    if (!out || (!p && n)) return GB_BAD;
    if (n > GE_DISK_LIMIT) return GB_SPACE;
    GETextInit(&t);
    t.original = (unsigned char *)malloc(n ? n : 1);
    t.text = (unsigned char *)malloc(GE_TEXT_LIMIT + 1);
    if (!t.original || !t.text) { GETextFree(&t); return GB_MEMORY; }
    if (n) memcpy(t.original, p, n);
    t.originalLength = n;
    if (n >= 3 && !memcmp(p, "\xef\xbb\xbf", 3)) { t.bom = 1; i = 3; }
    while (i < n) {
        if (t.length == GE_TEXT_LIMIT) { result = GB_SPACE; break; }
        c = p[i++];
        if (c == '\r') {
            if (i < n && p[i] == '\n') { ++i; crlf = 1; } else cr = 1;
        } else if (c == '\n') { lf = 1; c = '\r'; }
        else if (c >= 128) {
            if (c >= 194 && c <= 223) { trailing = 1; minimum = 128; c &= 31; }
            else if (c >= 224 && c <= 239) { trailing = 2; minimum = 2048; c &= 15; }
            else { result = GE_ENCODING; break; }
            while (trailing--) {
                if (i == n || (next = p[i++]) < 128 || next > 191) {
                    result = GE_ENCODING; break;
                }
                c = (c << 6) | (next & 63);
            }
            if (result) break;
            if (c < minimum || (c >= 0xd800 && c <= 0xdfff) ||
                (mac = GPRomanCharacter(c)) < 0) { result = GE_ENCODING; break; }
            c = (unsigned)mac;
        } else if (c != '\t' && !GEVisible(c)) { result = GE_ENCODING; break; }
        t.text[t.length++] = (unsigned char)c;
    }
    if (result) { GETextFree(&t); return result; }
    t.text[t.length] = 0;
    t.endings = cr || (lf && crlf) ? GE_NORMALIZE : crlf ? GE_CRLF : GE_LF;
    t.ready = 1;
    GETextFree(out); *out = t; return 0;
}
int GETextEncode(const GEText *t, const void *input, size_t n, int normalize,
                 unsigned char **out, size_t *length, int *changed) {
    const unsigned char *p = (const unsigned char *)input;
    unsigned char *result;
    size_t i, used = 0;
    unsigned c;
    if (out) *out = NULL;
    if (length) *length = 0;
    if (changed) *changed = 0;
    if (!t || !t->ready || !out || !length || !changed || (!p && n)) return GB_BAD;
    if (n > GE_TEXT_LIMIT) return GB_SPACE;
    if (n == t->length && (!n || !memcmp(p, t->text, n))) {
        result = (unsigned char *)malloc(t->originalLength ? t->originalLength : 1);
        if (!result) return GB_MEMORY;
        if (t->originalLength) memcpy(result, t->original, t->originalLength);
        *out = result; *length = t->originalLength; return 0;
    }
    if (t->endings == GE_NORMALIZE && !normalize) return GE_NEWLINES;
    result = (unsigned char *)malloc(n * 3 + 3);
    if (!result) return GB_MEMORY;
    if (t->bom) { memcpy(result, "\xef\xbb\xbf", 3); used = 3; }
    for (i = 0; i < n; ++i) {
        c = p[i];
        if (c == '\r') {
            if (t->endings == GE_CRLF) result[used++] = '\r';
            result[used++] = '\n';
        } else if (c == '\t' || GEVisible(c)) {
            c = GPRomanUnicode((unsigned char)c);
            if (c < 128) result[used++] = (unsigned char)c;
            else if (c < 2048) {
                result[used++] = (unsigned char)(192 | (c >> 6));
                result[used++] = (unsigned char)(128 | (c & 63));
            } else {
                result[used++] = (unsigned char)(224 | (c >> 12));
                result[used++] = (unsigned char)(128 | ((c >> 6) & 63));
                result[used++] = (unsigned char)(128 | (c & 63));
            }
        } else { free(result); return GE_ENCODING; }
    }
    *out = result; *length = used; *changed = 1; return 0;
}
