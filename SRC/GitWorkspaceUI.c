/* Saved Changes: native list, read-only review, explicit Restore/Drop approval.
   No checkout context or repository lease survives a modal review. */
static GXSavedList *gSavedChoices;
static int SUIRestorable(size_t at) {
    const GXSavedRow *r;
    if(!gSavedChoices || at>=gSavedChoices->list.count)return 0;
    r=gSavedChoices->rows+at;
    return !r->status && r->branch && !strcmp(r->branch,gWork.branch) &&
        r->haveBase==gWork.haveHead && (!r->haveBase || !memcmp(r->base,gWork.tip,20));
}
static const char *SUIUnavailable(int status) {
    if(status==GS_NOT_FOUND)return "Saved contents are missing.";
    if(status==GS_CONFLICT)return "This copy belongs to another local repository.";
    if(status==GI_UNSUPPORTED)return "This saved format requires a newer client.";
    return "Saved contents could not be verified.";
}
static int SUIRow(void *context,size_t at,char label[256],char name[256],char info[256]) {
    const GXSavedList *list=context;const GXSavedRow *r=list->rows+at;char branch[256];
    if(r->status) {
        snprintf(name,256,"Unavailable copy %lu",(unsigned long)(at+1));strcpy(label,name);
        snprintf(info,256,"%s Open Details for its identity.",SUIUnavailable(r->status));
    } else {
        LocalDisplayPath(r->branch+11,branch);
        snprintf(name,256,"%.190s / save %lu",branch,(unsigned long)r->generation);
        snprintf(label,256,"%.176s    %lu path%s",name,(unsigned long)r->pathCount,r->pathCount==1?"":"s");
        snprintf(info,256,"%s",SUIRestorable(at)?"Restore reviews the original staged and working changes.":
            "To restore, return to its original branch and base commit.");
    }
    return 1; /* An unavailable entry still has readable identity Details. */
}
static char *SUIDetails(void *context,size_t at) {
    const GXSavedList *list=context;const GXSavedRow *r=list->rows+at;
    char id[41],base[41],staged[41],working[41],untracked[41],*identity,*text;size_t n;
    GBOIDFormat(list->list.ids[at],id);
    identity=ChoiceIdentityDetails("Original branch",r->branch?r->branch:"(unavailable)");if(!identity)return NULL;
    n=strlen(identity)+1400;text=malloc(n);
    if(text) {
        GBOIDFormat(r->base,base);GBOIDFormat(r->staged,staged);GBOIDFormat(r->working,working);GBOIDFormat(r->untracked,untracked);
        snprintf(text,n,"Saved copy\r%s\r\r%s\rGeneration: %lu\rReviewed paths: %lu\r\r%s\r\rBase: %s\rStaged: %s\rWorking: %s\rUntracked: %s\r\r%s",
            id,identity,(unsigned long)r->generation,(unsigned long)r->pathCount,
            r->status?SUIUnavailable(r->status):"The saved envelope was checked. Restore and Drop verify its complete contents before approval.",
            r->haveBase?base:"(unborn branch)",staged,working,r->haveUntracked?untracked:"(none)",
            "Restore keeps this saved copy. Drop removes its entry from this list; existing files and staging are kept.");
    }
    free(identity);return text;
}
static void SUISync(DialogPtr d) {
    int selected=gSavedChoices && gChoiceSelected<gSavedChoices->list.count;
    gChoiceActionEnabled=selected && SUIRestorable(gChoiceSelected);
    ChoiceEnable(d,1,gChoiceActionEnabled);
    ChoiceEnable(d,3,selected && !gSavedChoices->rows[gChoiceSelected].status);
}
static pascal Boolean SUIFilter(DialogPtr d,EventRecord *event,short *hit) {
    Boolean handled;Point point;Rect bounds;short kind;Handle item;Cell cell;int doubled;
    *hit=0;
    /* Done is the safe Return action. Double-click reviews; it cannot apply. */
    if((event->what==keyDown || event->what==autoKey) && !(event->modifiers&cmdKey) &&
        ((event->message&charCodeMask)==13 || (event->message&charCodeMask)==3)){*hit=2;return true;}
    if(event->what==mouseDown) {
        SetPort((GrafPtr)d);point=event->where;GlobalToLocal(&point);GetDialogItem(d,5,&kind,&item,&bounds);
        if(PtInRect(point,&bounds)) {
            TextFont(gGeneva);TextSize(12);TextFace(0);doubled=LClick(point,event->modifiers,gChoiceList);cell.h=cell.v=0;
            if(LGetSelect(true,&cell,gChoiceList))ChoiceSelect(d,gChoiceFirst+cell.v);
            else if(gSavedChoices->list.count)ChoiceSelect(d,gChoiceSelected);
            SUISync(d);if(doubled){if(gChoiceActionEnabled)*hit=1;else SysBeep(1);}return true;
        }
    }
    handled=ChoiceFilter(d,event,hit);SUISync(d);return handled;
}
static int SUIChoose(GXSavedList *list,size_t *selected) {
    const ChoiceItems items={1,6,5,7,10,11,4};NativeChoices choices;DialogPtr d;ModalFilterUPP filter;
    short hit=0;int answer=0;char repository[256];
    memset(&choices,0,sizeof(choices));choices.context=list;choices.count=list->list.count;choices.row=SUIRow;
    choices.details=SUIDetails;choices.noun="Saved copies";gSavedChoices=list;
    d=GetNewDialog(155,NULL,(WindowPtr)-1);if(!d){gSavedChoices=NULL;return 0;}
    filter=NewModalFilterProc(SUIFilter);
    if(!filter || !PrepareDialogChrome(d,8,9) || !ChoiceCreate(d,&choices,&items,0))goto done;
    memcpy(repository,gWork.folder.name+1,gWork.folder.name[0]);repository[gWork.folder.name[0]]=0;DialogText(d,12,repository);
    PrepareDialog(d,2,2);
    if(list->list.count)ChoiceSelect(d,*selected<list->list.count?*selected:0);
    else ChoiceRefresh(d);
    SUISync(d);DrawDialog(d);
    while(!gDone) {
        hit=0;RunModalDialog(filter,&hit);if(hit==2 || gDone)break;
        if((hit==1 && SUIRestorable(gChoiceSelected)) ||
            (hit==3 && gChoiceSelected<list->list.count && !list->rows[gChoiceSelected].status)) {
            *selected=gChoiceSelected;answer=hit;break;
        }
        if(hit==4)ChoiceDetails();
        if(hit==10 && gChoiceFirst)ChoiceSelect(d,gChoiceFirst-CHOICE_PAGE);
        if(hit==11 && gChoiceFirst+gChoiceRows<list->list.count)ChoiceSelect(d,gChoiceFirst+CHOICE_PAGE);
        SUISync(d);SetPort((GrafPtr)d);InvalRect(&((WindowPtr)d)->portRect);
    }
    ChoiceDispose();
done:
    if(filter)DisposeRoutineDescriptor((UniversalProcPtr)filter);
    DisposeDialog(d);gSavedChoices=NULL;SetPort(gWindow);return gDone?0:answer;
}
static int SUIPathRow(void *context,size_t at,char label[256],char name[256],char info[256]) {
    const WSRecord *record=context;LocalDisplayPath(record->paths[at],name);strcpy(label,name);
    strcpy(info,"Details shows the full original path.");return 1;
}
static char *SUIPathDetails(void *context,size_t at) {
    const WSRecord *record=context;return ChoiceIdentityDetails("Reviewed saved path",record->paths[at]);
}
static void SUIPaths(const WSRecord *record) {
    NativeChoices choices;memset(&choices,0,sizeof(choices));choices.context=(void *)record;choices.count=record->pathCount;
    choices.row=SUIPathRow;choices.details=SUIPathDetails;choices.title="Paths in Saved Copy";
    choices.description="These original paths were captured together. This list does not change files or staging.";
    choices.action="Done";choices.noun="Paths";(void)PickNativeChoice(&choices);
}
static int SUIReview(const unsigned char oid[20],int drop) {
    GXDiscardReview review;WSRecord record;GQError why;OperationPrompt prompt;
    char repository[256],*branch=NULL,state[600],body[500],hex[41];int result,closed,answer=0;
    GXDiscardInit(&review);WSInit(&record);memset(&why,0,sizeof(why));
    result=CheckoutAttach(&gWork.folder);
    if(!result) {
        CheckoutBegin("Verifying the complete saved copy... Escape cancels review.");
        result=GXSavedInspect(&gUICheckout,oid,&record);
        if(!result)result=drop?GXDropPrepare(&gUICheckout,oid,&review):GXRestorePrepare(&gUICheckout,oid,&review,&why);
        gBusy=0;
    }
    closed=CheckoutRelease();if(!result)result=closed;LocalRefresh();if(result || gDone)goto done;
    memcpy(repository,gWork.folder.name+1,gWork.folder.name[0]);repository[gWork.folder.name[0]]=0;
    for(closed=0;closed<(int)record.discard.metadataCount;++closed)if(!strcmp(record.discard.metadata[closed].path,"HEAD"))break;
    /* WSOpen validated the symbolic HEAD; retain the full identity in Details. */
    if(closed==(int)record.discard.metadataCount){result=GS_FORMAT;goto done;}
    {
        const GCMetadata *head=record.discard.metadata+closed;size_t n=head->beforeLength-6;
        branch=malloc(n+1);if(!branch){result=GB_MEMORY;goto done;}memcpy(branch,head->before+5,n);branch[n]=0;
    }
    memset(&prompt,0,sizeof(prompt));GBOIDFormat(oid,hex);
    prompt.title=drop?"Drop Saved Copy":"Restore Saved Changes";prompt.repository=repository;prompt.state=state;
    snprintf(state,sizeof(state),"%lu saved path%s / generation %lu\r%s",(unsigned long)record.pathCount,
        record.pathCount==1?"":"s",(unsigned long)record.discard.generation,
        drop?"Your current files and staging will be kept.":"Restore to the original branch and base commit.");
    prompt.primary=drop?"Drop Copy":"Restore";prompt.primaryText=body;prompt.canPrimary=1;
    if(drop)strcpy(body,"Remove this entry from Saved Changes. You will no longer be able to select it here. Existing object and operation archives are retained.");
    else snprintf(body,sizeof(body),"Recover the original staged and working copies, including their data/resource forks, in one operation. The current branch tip stays unchanged. This plan changes %lu file%s and creates %lu folder%s.",
        (unsigned long)review.plan.transaction.fileCount,review.plan.transaction.fileCount==1?"":"s",
        (unsigned long)review.plan.transaction.createdDirectoryCount,review.plan.transaction.createdDirectoryCount==1?"":"s");
    prompt.secondary="Review Paths";prompt.secondaryText="Inspect the complete list of original paths before deciding.";prompt.canSecondary=record.pathCount!=0;
    prompt.footer=drop?"Drop changes this saved list only. Cancel keeps the saved copy.":
        "The saved copy is kept after Restore. Later changes to these paths cause refusal. Cancel keeps the current files and staging.";
    prompt.labels[0]="Saved copy";prompt.values[0]=hex;prompt.labels[1]="Original branch";prompt.values[1]=branch;
    do {answer=OperationConfirm(&prompt);if(answer==2 && !gDone)SUIPaths(&record);}while(answer==2 && !gDone);
    if(answer!=1 || gDone){SetStatus("Saved-copy review closed. No operation was approved.");goto done;}
    result=CheckoutAttach(&gWork.folder);
    if(!result) {
        CheckoutBegin(drop?"Dropping the saved-list entry... Escape stops at a recoverable checkpoint.":
            "Restoring saved changes... Escape stops at a recoverable checkpoint.");
        result=GXDiscardApply(&gUICheckout,&review);gBusy=0;
    }
    closed=CheckoutRelease();if(!result)result=closed;LocalRefresh();
    if(!result && !gLocalBlocked)SetStatus(drop?"Saved copy dropped. Current files, staging and branch kept.":
        "Saved changes restored. Original staging and working forks recovered; saved copy kept.");
done:
    free(branch);WSFree(&record);GXDiscardFree(&review);
    if(result && !gDone) {
        if(why.reason)Message("Keep Current Changes","Restore would replace later changes or an existing file or folder. Keep or move those changes before restoring this saved copy.");
        else if(!gCheckoutStopped)CheckoutError(drop?"Drop Saved Copy":"Restore Saved Changes",result);
    }
    return result;
}
static void SavedChangesCommand(void) {
    GXSavedList list;size_t selected=0;unsigned char oid[20];int result=0,closed,action;
    if(!gLocal || gLocalBlocked || gDone)return;GXSavedListInit(&list);
    while(!gDone && gLocal && !gLocalBlocked) {
        result=CheckoutAttach(&gWork.folder);gCheckoutStopped=0;
        if(!result){gBusy=1;gUICheckout.checkpoint=CheckoutProgress;
            SetStatus("Reading saved changes... Escape cancels.");result=GXSavedListRead(&gUICheckout,&list);gBusy=0;}
        closed=CheckoutRelease();if(!result)result=closed;if(result)break;
        SetStatus(list.list.count?"Choose a saved copy to inspect, restore or drop.":"No saved changes in this local repository.");
        action=SUIChoose(&list,&selected);if(!action)break;
        memcpy(oid,list.list.ids[selected],20);GXSavedListFree(&list);
        if(SUIReview(oid,action==3))break;
    }
    GXSavedListFree(&list);gBusy=0;
    if(result && !gDone) {
        if(gCheckoutStopped)SetStatus("Reading saved changes cancelled. Saved copies were kept.");
        else CheckoutError("Saved Changes",result);
    }
}

/* Capture every changed file, independently of the visible Changes filter.
   Include only directory witnesses below those paths, so a tracked file can
   replace its observed empty-folder tree. Other empty/ignored folders remain. */
typedef struct {char **paths;size_t count,files,staged,untracked;} DUSelection;
static void DUInit(DUSelection *s) {memset(s,0,sizeof(*s));}
static void DUFree(DUSelection *s) {size_t i;for(i=0;i<s->count;++i)free(s->paths[i]);free(s->paths);DUInit(s);}
static int DUOrder(const void *a,const void *b) {return strcmp(*(const char *const *)a,*(const char *const *)b);}
static int DUValid(const char *path) {
    return path && strlen(path)<=16384 && GIValidPath(path) && strcmp(path,GI_MAC_NAMESPACE) &&
        strncmp(path,GI_MAC_NAMESPACE "/",sizeof(GI_MAC_NAMESPACE));
}
static int DUAppend(DUSelection *s,const char *path) {
    char *copy;size_t n;
    if(s->count==8192)return GB_SPACE;if(!DUValid(path))return GS_FORMAT;
    n=strlen(path)+1;copy=malloc(n);if(!copy)return GB_MEMORY;
    memcpy(copy,path,n);s->paths[s->count++]=copy;return 0;
}
/* Compare an unallocated path prefix against the sorted original file list. */
static int DUHas(const DUSelection *s,size_t count,const char *path,size_t n) {
    size_t lo=0,hi=count,mid,m;int order;
    while(lo<hi) {
        mid=lo+(hi-lo)/2;m=strlen(s->paths[mid]);order=memcmp(s->paths[mid],path,m<n?m:n);
        if(!order)order=m<n?-1:m>n?1:0;if(!order)return 1;
        if(order<0)lo=mid+1;else hi=mid;
    }
    return 0;
}
static int DUBelowFiles(const DUSelection *s,size_t count,const char *path) {
    size_t i;for(i=0;;++i) {
        if((!path[i] || path[i]=='/') && DUHas(s,count,path,i))return 1;
        if(!path[i])return 0;
    }
}
static int DUBuild(const GWWorkspace *w,const GFInventory *inventory,DUSelection *out) {
    DUSelection next;size_t i,original;int result=0;
    if(!w || !inventory || !out || w->count>8192 || inventory->count>8192 ||
        (w->count && !w->files) || (inventory->count && !inventory->items))return GB_BAD;
    DUInit(&next);next.paths=calloc(8192,sizeof(*next.paths));if(!next.paths)return GB_MEMORY;
    for(i=0;!result && i<w->count;++i)if(w->files[i].staged || w->files[i].unstaged) {
        result=DUAppend(&next,w->files[i].path);
        if(!result){++next.files;if(w->files[i].staged)++next.staged;if(w->files[i].untracked)++next.untracked;}
    }
    if(!result && next.count>1)qsort(next.paths,next.count,sizeof(*next.paths),DUOrder);
    for(i=1;!result && i<next.count;++i)if(!strcmp(next.paths[i-1],next.paths[i]))result=GS_FORMAT;
    original=next.count;
    for(i=0;!result && i<inventory->count;++i)if(inventory->items[i].file.present==2) {
        const char *path=inventory->items[i].path;
        if(!DUValid(path))result=GS_FORMAT;
        else if(!DUHas(&next,original,path,strlen(path)) && DUBelowFiles(&next,original,path))result=DUAppend(&next,path);
    }
    if(!result && next.count>1)qsort(next.paths,next.count,sizeof(*next.paths),DUOrder);
    for(i=1;!result && i<next.count;++i)if(!strcmp(next.paths[i-1],next.paths[i]))result=GS_FORMAT;
    if(!result){DUFree(out);*out=next;DUInit(&next);}DUFree(&next);return result;
}
static int DiscardAvailable(void) {
    size_t i;if(!gLocal || gLocalBlocked || gMergePending || gDone)return 0;
    for(i=0;i<gWork.count;++i)if(gWork.files[i].staged || gWork.files[i].unstaged)return 1;
    return 0;
}
static void DUPaths(const DUSelection *selection) {
    WSRecord view;NativeChoices choices;WSInit(&view);view.paths=selection->paths;view.pathCount=selection->count;
    memset(&choices,0,sizeof(choices));choices.context=&view;choices.count=view.pathCount;
    choices.row=SUIPathRow;choices.details=SUIPathDetails;choices.title="Paths to Discard";
    choices.description="All changed files and required folders are included, even when Changes is filtered.";
    choices.action="Done";choices.noun="Paths";(void)PickNativeChoice(&choices);
    /* Borrowed path view; its owner remains alive across this modal. */
}
static void DUDescribe(const DUSelection *selection,const GXDiscardReview *review,
    const char *repository,const char *branch,const char *base,const char *saved,
    OperationPrompt *prompt,char state[600],char body[500]) {
    memset(prompt,0,sizeof(*prompt));prompt->title="Discard All Changes";prompt->repository=repository;prompt->state=state;
    snprintf(state,600,"%lu changed file%s / %lu staged / %lu untracked\r%lu folder%s required by this review",
        (unsigned long)selection->files,selection->files==1?"":"s",(unsigned long)selection->staged,(unsigned long)selection->untracked,
        (unsigned long)review->plan.transaction.directoryCount,review->plan.transaction.directoryCount==1?"":"s");
    snprintf(body,500,"Save a recoverable copy, then reset these changes to %s. Staged and working versions, data/resource forks and required folder metadata are saved together.",
        strcmp(base,"(unborn branch)")?"the current commit":"an empty repository");
    prompt->primary="Discard Changes";prompt->primaryText=body;prompt->canPrimary=selection->files!=0;
    prompt->secondary="Review Paths";prompt->secondaryText="Inspect the complete list before deciding. No files are changed by this review.";prompt->canSecondary=selection->count!=0;
    prompt->footer="Ignored files and unrelated folders are kept. Use Saved Changes to restore on this branch and base commit. Cancel keeps your files and staging.";
    prompt->labels[0]="Current branch";prompt->values[0]=branch;prompt->labels[1]="Base commit";prompt->values[1]=base;
    prompt->labels[2]="Saved copy";prompt->values[2]=saved;
}
static void DiscardChangesCommand(void) {
    DUSelection selected;GFInventory inventory;GPMap map;GXDiscardReview review;GQProtection paths;GQError why;
    OperationPrompt prompt;FSSpec folder;char repository[256],state[600],body[500],base[41],saved[41],*branch=NULL;
    unsigned char tip[20];int haveTip,result=0,closed,answer=0;
    if(!DiscardAvailable())return;LocalRefresh();if(!DiscardAvailable())return;
    DUInit(&selected);GFInit(&inventory);GPInit(&map);GXDiscardInit(&review);memset(&why,0,sizeof(why));gCheckoutStopped=0;
    folder=gWork.folder;haveTip=gWork.haveHead;memcpy(tip,gWork.tip,20);
    branch=malloc(strlen(gWork.branch)+1);if(!branch){result=GB_MEMORY;goto done;}strcpy(branch,gWork.branch);
    result=CheckoutAttach(&folder);
    if(!result) {
        CheckoutBegin("Preparing a recoverable Discard review... Escape cancels.");
        result=GSMacEnter(&gUICheckout.store,0);
        if(!result)result=GTNormalWriteAllowed(&gUICheckout.raw);
        if(!result)result=GPLoad(&gUICheckout.raw,GWMacNameEqual,NULL,&map);
        if(!result)result=GFCollect(&gUICheckout.root,&map,&inventory,&gUICheckout.lastError);
        if(!result)result=DUBuild(&gWork,&inventory,&selected);
        if(gUICheckout.store.leaseHeld){closed=GSMacLeave(&gUICheckout.store);if(!result)result=closed;}
        paths.paths=(const char *const *)selected.paths;paths.count=selected.count;paths.changed=0;
        if(!result && selected.files)result=GXDiscardPrepare(&gUICheckout,branch,haveTip?tip:NULL,&paths,&review,&why);
        gBusy=0;
    }
    closed=CheckoutRelease();if(!result)result=closed;LocalRefresh();if(result || gDone || gLocalBlocked)goto done;
    if(!selected.files){SetStatus("No changes to discard.");goto done;}
    memcpy(repository,folder.name+1,folder.name[0]);repository[folder.name[0]]=0;
    if(haveTip)GBOIDFormat(tip,base);else strcpy(base,"(unborn branch)");GBOIDFormat(review.snapshotOID,saved);
    DUDescribe(&selected,&review,repository,branch,base,saved,&prompt,state,body);
    do {answer=OperationConfirm(&prompt);if(answer==2 && !gDone)DUPaths(&selected);}while(answer==2 && !gDone);
    if(answer!=1 || gDone){SetStatus("Discard canceled. Your files and staging are kept.");goto done;}
    result=CheckoutAttach(&folder);
    if(!result){CheckoutBegin("Saving and discarding changes... Escape stops at a recoverable checkpoint.");result=GXDiscardApply(&gUICheckout,&review);gBusy=0;}
    closed=CheckoutRelease();if(!result)result=closed;LocalRefresh();
    if(!result && !gLocalBlocked)SetStatus("Changes discarded. A recoverable copy is available in Saved Changes; branch tip kept.");
done:
    free(branch);DUFree(&selected);GFFree(&inventory);GPFree(&map);GXDiscardFree(&review);
    if(result && !gDone) {
        if(gCheckoutStopped)SetStatus("Discard stopped. Refresh to check recovery; keep this repository intact.");
        else if(why.reason)Message("Keep Current Changes","This Discard would replace an unreviewed file or folder. Refresh the repository and keep or move the obstructing changes before trying again.");
        else CheckoutError("Discard Changes",result);
    }
}
