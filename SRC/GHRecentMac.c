/* Preferences catalog only. Never opens a repository for writing. */
static short gRecentIORef,gRecentLeaseRef;
static int gRecentHaveIO,gRecentHaveLease;
static OSErr RecentCloseRef(short ref,int lease) {
    OSErr error=FSClose(ref);
    if(error){if(lease){gRecentLeaseRef=ref;gRecentHaveLease=1;}else{gRecentIORef=ref;gRecentHaveIO=1;}}
    return error;
}
static int RecentRetryClose(void) {
    if(gRecentHaveIO){if(FSClose(gRecentIORef))return -1;gRecentHaveIO=0;}
    if(gRecentHaveLease){if(FSClose(gRecentLeaseRef))return -1;gRecentHaveLease=0;}
    return 0;
}
static OSErr RecentSpec(short volume,long directory,ConstStr255Param name,FSSpec *spec) {
    OSErr error=FSMakeFSSpec(volume,directory,name,spec);return error==fnfErr?0:error;
}
static OSErr RecentCatalog(const FSSpec *spec,OSType type,long *length) {
    CInfoPBRec pb;OSErr error;memset(&pb,0,sizeof(pb));pb.hFileInfo.ioNamePtr=(StringPtr)spec->name;
    pb.hFileInfo.ioVRefNum=spec->vRefNum;pb.hFileInfo.ioDirID=spec->parID;error=PBGetCatInfoSync(&pb);if(error)return error;
    if((pb.hFileInfo.ioFlAttrib&16) || (pb.hFileInfo.ioFlFndrInfo.fdFlags&0x8000) ||
       pb.hFileInfo.ioFlFndrInfo.fdCreator!='GHCl' || pb.hFileInfo.ioFlFndrInfo.fdType!=type ||
       pb.hFileInfo.ioFlRLgLen || pb.hFileInfo.ioFlLgLen<0)return paramErr;
    *length=pb.hFileInfo.ioFlLgLen;return 0;
}
static int RecentReadFile(const FSSpec *target,RecentList *list,int *present) {
    unsigned char bytes[RECENT_BYTES];long length,count;short ref;OSErr error,closed;
    error=RecentCatalog(target,'GHRL',&length);if(error==fnfErr){memset(list,0,sizeof(*list));*present=0;return 0;}
    if(error || length<16 || length>RECENT_BYTES)return -1;
    error=FSpOpenDF(target,fsRdPerm,&ref);if(error)return -1;
    count=length;error=FSRead(ref,&count,bytes);closed=RecentCloseRef(ref,0);
    if(error || closed || count!=length || RecentDecode(list,bytes,(size_t)length))return -1;
    *present=1;return 0;
}
static int RecentWriteFile(const FSSpec *target,const RecentList *list,int present) {
    unsigned char bytes[RECENT_BYTES];size_t length;FSSpec temp;Str31 name;char text[32];
    long count;short ref;unsigned i;OSErr error,closed;
    if(RecentEncode(list,bytes,&length))return -1;
    for(i=0;i<4096;++i) {
        sprintf(text,".ghrecent%04x",i);name[0]=(unsigned char)strlen(text);memcpy(name+1,text,name[0]);
        if(RecentSpec(target->vRefNum,target->parID,name,&temp))return -1;
        error=FSpCreate(&temp,'GHCl','GHRL',smSystemScript);if(error==dupFNErr)continue;if(error)return -1;break;
    }
    if(i==4096)return -1;
    error=FSpOpenDF(&temp,fsWrPerm,&ref);
    if(!error){count=(long)length;error=FSWrite(ref,&count,bytes);if(!error && count!=(long)length)error=ioErr;closed=RecentCloseRef(ref,0);if(!error)error=closed;}
    if(!error)error=FlushVol(NULL,target->vRefNum);
    if(error)return -1; /* A failed temporary never replaces the live catalog. */
    error=present?FSpExchangeFiles(&temp,target):FSpRename(&temp,target->name);
    if(error)return -1;
    if(FlushVol(NULL,target->vRefNum))return -1;
    if(present && !FSpDelete(&temp))FlushVol(NULL,target->vRefNum);
    return 0;
}
static int RecentAccess(RecentList *list,const RecentEntry *touch,const RecentEntry *remove) {
    short volume,lease;long directory,length;FSSpec lock,target;OSErr error,closed;int present,result=0;size_t i;
    if(RecentRetryClose())return -1;
    error=FindFolder(kOnSystemDisk,kPreferencesFolderType,true,&volume,&directory);if(error)return -1;
    if(RecentSpec(volume,directory,"\pGitHub Classic Recent",&target) || RecentSpec(volume,directory,"\pGitHub Classic Recent Lock",&lock))return -1;
    error=FSpCreate(&lock,'GHCl','GHRK',smSystemScript);if(error && error!=dupFNErr)return -1;
    error=FSpOpenDF(&lock,fsWrPerm,&lease);if(error)return -1;
    error=RecentCatalog(&lock,'GHRK',&length);if(error || length)result=-1;
    if(!result)result=RecentReadFile(&target,list,&present);
    if(!result && touch)result=RecentTouch(list,touch);
    if(!result && remove)for(i=0;i<list->count;++i)if(RecentSame(list->entries+i,remove)){result=RecentRemove(list,i);break;}
    if(!result && (touch || remove))result=RecentWriteFile(&target,list,present);
    closed=RecentCloseRef(lease,1);if(closed)result=-1;return result;
}
static int RecentForFolder(const FSSpec *folder,RecentEntry *entry) {
    GFCatalog cat;HParamBlockRec pb;Str255 volume;OSErr error;int result;
    result=GFCatalogRead(folder,&cat,&error);if(result || !(cat.attributes&16) || !folder->name[0] || folder->name[0]>31)return -1;
    memset(&pb,0,sizeof(pb));memset(volume,0,sizeof(volume));pb.volumeParam.ioVRefNum=folder->vRefNum;pb.volumeParam.ioNamePtr=volume;
    if(PBHGetVInfoSync(&pb) || volume[0]>31 || !volume[0])return -1;
    memset(entry,0,sizeof(*entry));memcpy(entry->volume,volume,volume[0]+1);memcpy(entry->name,folder->name,folder->name[0]+1);
    entry->volumeCreated=(GBWord)pb.volumeParam.ioVCrDate;entry->signature=(GBWord)(unsigned short)pb.volumeParam.ioVSigWord;
    entry->directory=(GBWord)cat.id;entry->created=cat.created;return 0;
}
static int RecentResolve(const RecentEntry *entry,FSSpec *folder) {
    HParamBlockRec pb;Str255 volume;GFCatalog cat;OSErr error;int i;
    /* Mounted volumes only. A missing disk never produces a mount or network dialog. */
    for(i=1;i<=128;++i) {
        memset(&pb,0,sizeof(pb));memset(volume,0,sizeof(volume));pb.volumeParam.ioVolIndex=(short)i;pb.volumeParam.ioNamePtr=volume;
        if(PBHGetVInfoSync(&pb))break;
        if(volume[0]!=entry->volume[0] || memcmp(volume,entry->volume,volume[0]+1) ||
           (GBWord)pb.volumeParam.ioVCrDate!=entry->volumeCreated || (unsigned short)pb.volumeParam.ioVSigWord!=entry->signature)continue;
        if(GFDirectoryAt(pb.volumeParam.ioVRefNum,(long)entry->directory,&cat,&error) ||
           !(cat.attributes&16) || cat.created!=entry->created)return -1;
        *folder=cat.spec;return 0;
    }
    return -1;
}
static void RecentRemember(const FSSpec *folder) {
    RecentList list;RecentEntry entry;
    if(RecentForFolder(folder,&entry) || RecentAccess(&list,&entry,NULL))
        SetStatus("Repository opened. Its recent-list entry could not be saved; your repository is unaffected.");
}
