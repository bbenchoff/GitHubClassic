#include "GitCheckout.h"
#include <stdio.h>
#include <stdlib.h>
#include <string.h>

static GBWord GCWord(const unsigned char *p) {
  return ((GBWord)p[0] << 24) | ((GBWord)p[1] << 16) | ((GBWord)p[2] << 8) |
         p[3];
}
static void GCPut(unsigned char *p, GBWord n) {
  p[0] = (unsigned char)(n >> 24);
  p[1] = (unsigned char)(n >> 16);
  p[2] = (unsigned char)(n >> 8);
  p[3] = (unsigned char)n;
}
static void GCDigest(const void *p, size_t n, unsigned char oid[20]) {
  GBSHA1 h;
  GBSHA1Start(&h);
  GBSHA1Update(&h, p, n);
  GBSHA1Finish(&h, oid);
}
static char *GCString(const void *p, size_t n) {
  char *s;
  if (n == (size_t)-1)
    return NULL;
  s = (char *)malloc(n + 1);
  if (s) {
    memcpy(s, p, n);
    s[n] = 0;
  }
  return s;
}
void GCInit(GCTransaction *t) { memset(t, 0, sizeof(*t)); }
void GCFree(GCTransaction *t) {
  size_t i;
  if (t->files)
    for (i = 0; i < t->fileCount; ++i) {
      free(t->files[i].oldPath);
      free(t->files[i].newPath);
    }
  if (t->metadata)
    for (i = 0; i < t->metadataCount; ++i) {
      free(t->metadata[i].path);
      free(t->metadata[i].before);
      free(t->metadata[i].after);
    }
  free(t->files);
  free(t->metadata);
  if(t->directories)
    for(i=0;i<t->directoryCount;++i)free(t->directories[i]);
  free(t->directories);
  if(t->createdDirectories)
    for(i=0;i<t->createdDirectoryCount;++i)free(t->createdDirectories[i].path);
  free(t->createdDirectories);
  free(t->original);
  GCInit(t);
}
int GCFileEqual(const GCFile *a, const GCFile *b) {
  return a->present == b->present &&
         (!a->present ||
          (a->present == 1 && !memcmp(a->dataOID, b->dataOID, 20) &&
           !memcmp(a->resourceOID, b->resourceOID, 20) &&
           !memcmp(a->finderInfo, b->finderInfo, 32)));
}
static int GCZero(const void *p, size_t n) {
  const unsigned char *s = (const unsigned char *)p;
  while (n--)
    if (*s++)
      return 0;
  return 1;
}
static int GCNative(const char *p, GCEqual eq, void *ctx) {
  const char *start;
  size_t n;
  char name[32];
  if (!p || !*p)
    return 0;
  for (start = p;; ++p) {
    if (*p && *p != ':') {
      continue;
    }
    n = (size_t)(p - start);
    if (!n || n > 31)
      return 0;
    memcpy(name, start, n);
    name[n] = 0;
    if (eq(ctx, name, ".") || eq(ctx, name, "..") || eq(ctx, name, ".git") ||
        eq(ctx, name, ".ghclient-mac"))
      return 0;
    if (!*p)
      return 1;
    start = p + 1;
  }
}
/* 0 unrelated, 1 equal, 2 first is a proper ancestor of second. */
static int GCRelation(const char *a, const char *b, GCEqual eq, void *ctx) {
  const char *x, *y;
  char u[32], v[32];
  size_t n, m;
  if (!a || !b)
    return 0;
  for (;;) {
    x = strchr(a, ':');
    y = strchr(b, ':');
    n = x ? (size_t)(x - a) : strlen(a);
    m = y ? (size_t)(y - b) : strlen(b);
    if (!n || n > 31 || !m || m > 31)
      return 0;
    memcpy(u, a, n);
    u[n] = 0;
    memcpy(v, b, m);
    v[m] = 0;
    if (!eq(ctx, u, v))
      return 0;
    if (!x)
      return y ? 2 : 1;
    if (!y)
      return 0;
    a = x + 1;
    b = y + 1;
  }
}
static int GCHashedKey(const char *p,const char *prefix) {
  size_t i,n=strlen(prefix);
  if(strncmp(p,prefix,n) || strlen(p)!=n+42 || p[n+2]!='/' || p[n+15]!='/')return 0;
  for(i=n;i<n+42;++i)
    if(i!=n+2 && i!=n+15 && !((p[i]>='0' && p[i]<='9') || (p[i]>='a' && p[i]<='f')))return 0;
  return 1;
}
static int GCKey(const char *p) {
  size_t i, n;
  if (!p)
    return 0;
  if (!strcmp(p, "HEAD") || !strcmp(p, "index") || !strcmp(p, "ghclient-map") || !strcmp(p, "ghclient-merge") || !strcmp(p,"ghclient-rebase"))
    return 1;
  if(!strcmp(p,"ghclient-origin") || !strcmp(p,"ghclient-push") || !strcmp(p,"ghclient-saved-work") || !strcmp(p,"ghclient-stash-log") ||
     GCHashedKey(p,"ghclient-upstreams/") || GCHashedKey(p,"ghclient-branch-log/"))return 1;
  n = strlen(p);
  if (n != 47 || memcmp(p, "refs/", 5) || p[7] != '/' || p[20] != '/')
    return 0;
  for (i = 5; i < n; ++i)
    if (i != 7 && i != 20 &&
        !((p[i] >= '0' && p[i] <= '9') || (p[i] >= 'a' && p[i] <= 'f')))
      return 0;
  return 1;
}
static int GCValidFile(const GCFile *f) {
  return (f->present == 1) ||
         (!f->present && GCZero(f->dataOID, 20) && GCZero(f->resourceOID, 20) &&
          GCZero(f->finderInfo, 32));
}
static int GCValidate(const GCTransaction *t, GCEqual eq, void *ctx) {
  size_t i, j;
  int head = 0, index = 0, map = 0, r;
  const GCOperation *o, *p;
  const GCMetadata *m;
  if (!t || !eq || !t->generation || t->phase < GC_PREPARE ||
      t->phase > GC_ROLLED_BACK || (t->fileCount && !t->files) ||
      (t->directoryCount && !t->directories) ||
      (t->createdDirectoryCount && !t->createdDirectories) ||
      !t->metadataCount || !t->metadata)
    return GB_BAD;
  if (t->phase >= GC_ROLLBACK_META) {
    if (t->rollbackFrom < GC_PREPARE || t->rollbackFrom > GC_METADATA)
      return GS_FORMAT;
  } else if (t->rollbackFrom)
    return GS_FORMAT;
  for (i = 0; i < t->fileCount; ++i) {
    o = t->files + i;
    if (!GCValidFile(&o->oldFile) || !GCValidFile(&o->newFile) ||
        (!o->oldFile.present && !o->newFile.present) ||
        (!!o->oldPath != !!o->oldFile.present) ||
        (!!o->newPath != !!o->newFile.present) ||
        (o->oldPath && !GCNative(o->oldPath, eq, ctx)) ||
        (o->newPath && !GCNative(o->newPath, eq, ctx)) ||
        (o->newFile.present && o->mode != 0100644 && o->mode != 0100755 &&
         o->mode != 0120000) ||
        (!o->newFile.present && (o->mode || !GCZero(o->metadataOID, 20))))
      return GS_FORMAT;
    for (j = 0; j < i; ++j) {
      p = t->files + j;
      if (o->oldPath && p->oldPath) {
        r = GCRelation(o->oldPath, p->oldPath, eq, ctx);
        if (r || GCRelation(p->oldPath, o->oldPath, eq, ctx))
          return GS_CONFLICT;
      }
      if (o->newPath && p->newPath) {
        r = GCRelation(o->newPath, p->newPath, eq, ctx);
        if (r || GCRelation(p->newPath, o->newPath, eq, ctx))
          return GS_CONFLICT;
      }
    }
  }
  for(i=0;i<t->directoryCount;++i) {
    int displaced=0;
    if(!GCNative(t->directories[i],eq,ctx))return GS_FORMAT;
    for(j=0;j<i;++j)
      if(GCRelation(t->directories[i],t->directories[j],eq,ctx)==1)return GS_CONFLICT;
    for(j=0;j<t->fileCount;++j) {
      const GCOperation *f=t->files+j;
      if(f->oldPath && GCRelation(f->oldPath,t->directories[i],eq,ctx))return GS_CONFLICT;
      if(f->newPath && GCRelation(f->newPath,t->directories[i],eq,ctx))displaced=1;
    }
    if(!displaced)return GS_FORMAT;
  }
  for(i=0;i<t->createdDirectoryCount;++i) {
    const GCDirectory *d=t->createdDirectories+i;
    if(!GCNative(d->path,eq,ctx) || !(d->attributes&16))return GS_FORMAT;
    for(j=0;j<i;++j)
      if(GCRelation(d->path,t->createdDirectories[j].path,eq,ctx)==1)return GS_CONFLICT;
    for(j=0;j<t->fileCount;++j)
      if(t->files[j].newPath && GCRelation(t->files[j].newPath,d->path,eq,ctx))return GS_CONFLICT;
  }
  for (i = 0; i < t->metadataCount; ++i) {
    m = t->metadata + i;
    if (!GCKey(m->path) || (m->beforePresent != 0 && m->beforePresent != 1) ||
        (m->afterPresent != 0 && m->afterPresent != 1) ||
        (!m->beforePresent && m->beforeLength) ||
        (!m->afterPresent && m->afterLength) ||
        (!m->before && m->beforeLength) || (!m->after && m->afterLength))
      return GS_FORMAT;
    /* Branch operations capture these settings only as read guards. A
       checkout journal must not rewrite origin or a pending upload record. */
    if((!strcmp(m->path,"ghclient-origin") || !strcmp(m->path,"ghclient-push")) &&
       (m->beforePresent!=m->afterPresent || m->beforeLength!=m->afterLength ||
        (m->beforeLength && memcmp(m->before,m->after,m->beforeLength))))return GS_FORMAT;
    for (j = 0; j < i; ++j)
      if (!strcmp(m->path, t->metadata[j].path))
        return GS_CONFLICT;
    if (!strcmp(m->path, "HEAD"))
      head = m->afterPresent;
    if (!strcmp(m->path, "index"))
      index = 1;
    if (!strcmp(m->path, "ghclient-map"))
      map = 1;
  }
  return head && index && map ? 0 : GS_FORMAT;
}
static void GCFilePut(unsigned char *p, const GCFile *f) {
  memcpy(p, f->dataOID, 20);
  memcpy(p + 20, f->resourceOID, 20);
  memcpy(p + 40, f->finderInfo, 32);
}
static void GCFileGet(const unsigned char *p, GCFile *f, int present) {
  f->present = present;
  memcpy(f->dataOID, p, 20);
  memcpy(f->resourceOID, p + 20, 20);
  memcpy(f->finderInfo, p + 40, 32);
}
int GCEncode(const GCTransaction *t, GCEqual eq, void *ctx,
             unsigned char **bytes, size_t *length) {
  unsigned char *out, *p, digest[20];
  size_t i, n = 48, a, b, c;
  int result;
  if (!bytes || !length)
    return GB_BAD;
  *bytes = NULL;
  *length = 0;
  result = GCValidate(t, eq, ctx);
  if (result)
    return result;
  if (t->fileCount > 0xffffffffUL || t->metadataCount > 0xffffffffUL ||
      t->directoryCount > 0xffffffffUL || t->createdDirectoryCount>0xffffffffUL)
    return GB_SPACE;
  if(t->directoryCount || t->createdDirectoryCount) {
    n+=4;
    for(i=0;i<t->directoryCount;++i) {
      a=strlen(t->directories[i]);
      if(a>0xffffffffUL || a>(size_t)-1-4 || n>(size_t)-1-4-a)return GB_SPACE;
      n+=4+a;
    }
  }
  if(t->createdDirectoryCount) {
    if(n>(size_t)-1-4)return GB_SPACE;
    n+=4;
    for(i=0;i<t->createdDirectoryCount;++i) {
      a=strlen(t->createdDirectories[i].path);
      if(a>0xffffffffUL || a>(size_t)-1-52 || n>(size_t)-1-52-a)return GB_SPACE;
      n+=52+a;
    }
  }
  for (i = 0; i < t->fileCount; ++i) {
    a = t->files[i].oldPath ? strlen(t->files[i].oldPath) : 0;
    b = t->files[i].newPath ? strlen(t->files[i].newPath) : 0;
    if (a > 0xffffffffUL || b > 0xffffffffUL || a > (size_t)-1 - 180 ||
        b > (size_t)-1 - 180 - a || n > (size_t)-1 - 180 - a - b)
      return GB_SPACE;
    n += 180 + a + b;
  }
  for (i = 0; i < t->metadataCount; ++i) {
    a = strlen(t->metadata[i].path);
    b = t->metadata[i].beforeLength;
    c = t->metadata[i].afterLength;
    if (a > 0xffffffffUL || b > 0xffffffffUL || c > 0xffffffffUL ||
        a > (size_t)-1 - 16 || b > (size_t)-1 - 16 - a ||
        c > (size_t)-1 - 16 - a - b || n > (size_t)-1 - 16 - a - b - c)
      return GB_SPACE;
    n += 16 + a + b + c;
  }
  out = (unsigned char *)malloc(n);
  if (!out)
    return GB_MEMORY;
  memcpy(out,t->createdDirectoryCount?"GHCO0003":t->directoryCount?"GHCO0002":"GHCO0001",8);
  GCPut(out + 8, t->generation);
  GCPut(out + 12, t->phase);
  GCPut(out + 16, t->rollbackFrom);
  GCPut(out + 20, (GBWord)t->fileCount);
  GCPut(out + 24, (GBWord)t->metadataCount);
  p = out + 28;
  if(t->directoryCount || t->createdDirectoryCount){GCPut(p,(GBWord)t->directoryCount);p+=4;}
  if(t->createdDirectoryCount){GCPut(p,(GBWord)t->createdDirectoryCount);p+=4;}
  for (i = 0; i < t->fileCount; ++i) {
    const GCOperation *o = t->files + i;
    a = o->oldPath ? strlen(o->oldPath) : 0;
    b = o->newPath ? strlen(o->newPath) : 0;
    GCPut(p, (GBWord)(o->oldFile.present | (o->newFile.present << 1)));
    GCPut(p + 4, (GBWord)a);
    GCPut(p + 8, (GBWord)b);
    GCPut(p + 12, o->mode);
    GCFilePut(p + 16, &o->oldFile);
    GCFilePut(p + 88, &o->newFile);
    memcpy(p + 160, o->metadataOID, 20);
    p += 180;
    if (a)
      memcpy(p, o->oldPath, a);
    p += a;
    if (b)
      memcpy(p, o->newPath, b);
    p += b;
  }
  for (i = 0; i < t->metadataCount; ++i) {
    const GCMetadata *m = t->metadata + i;
    a = strlen(m->path);
    b = m->beforeLength;
    c = m->afterLength;
    GCPut(p, (GBWord)(m->beforePresent | (m->afterPresent << 1)));
    GCPut(p + 4, (GBWord)a);
    GCPut(p + 8, (GBWord)b);
    GCPut(p + 12, (GBWord)c);
    p += 16;
    memcpy(p, m->path, a);
    p += a;
    if (b)
      memcpy(p, m->before, b);
    p += b;
    if (c)
      memcpy(p, m->after, c);
    p += c;
  }
  for(i=0;i<t->directoryCount;++i) {
    a=strlen(t->directories[i]);GCPut(p,(GBWord)a);p+=4;
    memcpy(p,t->directories[i],a);p+=a;
  }
  for(i=0;i<t->createdDirectoryCount;++i) {
    const GCDirectory *d=t->createdDirectories+i;
    a=strlen(d->path);GCPut(p,(GBWord)a);GCPut(p+4,d->attributes);
    GCPut(p+8,d->created);GCPut(p+12,d->modified);GCPut(p+16,d->backup);
    memcpy(p+20,d->finderInfo,32);p+=52;memcpy(p,d->path,a);p+=a;
  }
  GCDigest(out, n - 20, digest);
  memcpy(p, digest, 20);
  *bytes = out;
  *length = n;
  return 0;
}
int GCParse(const void *bytes, size_t length, GCEqual eq, void *ctx,
            GCTransaction *out) {
  const unsigned char *p = (const unsigned char *)bytes, *end;
  unsigned char digest[20];
  char hex[41];
  GCTransaction t;
  size_t i, a, b, c;
  GBWord flags;
  int result = GS_FORMAT, version;
  if (!bytes || !out || !eq)
    return GB_BAD;
  if (length < 48 || (memcmp(p, "GHCO0001", 8) && memcmp(p,"GHCO0002",8) && memcmp(p,"GHCO0003",8)))
    return GS_FORMAT;
  version=!memcmp(p,"GHCO0003",8)?3:!memcmp(p,"GHCO0002",8)?2:1;
  if(length<48+(version-1)*4UL)return GS_FORMAT;
  GCDigest(p, length - 20, digest);
  if (memcmp(digest, p + length - 20, 20))
    return GB_CHECKSUM;
  GCInit(&t);
  t.generation = GCWord(p + 8);
  t.phase = GCWord(p + 12);
  t.rollbackFrom = GCWord(p + 16);
  t.fileCount = GCWord(p + 20);
  t.metadataCount = GCWord(p + 24);
  if(version>=2)t.directoryCount=GCWord(p+28);
  if(version>=3)t.createdDirectoryCount=GCWord(p+32);
  if (t.fileCount > (length - 48) / 181 ||
      t.metadataCount > (length - 48) / 17 ||
      t.fileCount > (size_t)-1 / sizeof(*t.files) ||
      t.metadataCount > (size_t)-1 / sizeof(*t.metadata) ||
      t.directoryCount > (length-48)/5 ||
      t.directoryCount > (size_t)-1 / sizeof(*t.directories) ||
      (version==2 && !t.directoryCount) ||
      t.createdDirectoryCount>(length-48)/53 ||
      t.createdDirectoryCount>(size_t)-1/sizeof(*t.createdDirectories) ||
      (version==3 && !t.createdDirectoryCount))
    return GS_FORMAT;
  t.files =
      (GCOperation *)calloc(t.fileCount ? t.fileCount : 1, sizeof(*t.files));
  t.metadata = (GCMetadata *)calloc(t.metadataCount ? t.metadataCount : 1,
                                    sizeof(*t.metadata));
  if (!t.files || !t.metadata) {
    result = GB_MEMORY;
    goto fail;
  }
  if(t.directoryCount) {
    t.directories=(char **)calloc(t.directoryCount,sizeof(*t.directories));
    if(!t.directories){result=GB_MEMORY;goto fail;}
  }
  if(t.createdDirectoryCount) {
    t.createdDirectories=(GCDirectory *)calloc(t.createdDirectoryCount,sizeof(*t.createdDirectories));
    if(!t.createdDirectories){result=GB_MEMORY;goto fail;}
  }
  end = p + length - 20;
  p += 28+(version-1)*4;
  for (i = 0; i < t.fileCount; ++i) {
    GCOperation *o = t.files + i;
    if ((size_t)(end - p) < 180)
      goto fail;
    flags = GCWord(p);
    a = GCWord(p + 4);
    b = GCWord(p + 8);
    o->mode = GCWord(p + 12);
    if (flags & ~3U)
      goto fail;
    GCFileGet(p + 16, &o->oldFile, (int)(flags & 1));
    GCFileGet(p + 88, &o->newFile, (int)((flags >> 1) & 1));
    memcpy(o->metadataOID, p + 160, 20);
    p += 180;
    if (a > (size_t)(end - p) || b > (size_t)(end - p) - a ||
        memchr(p, 0, a + b))
      goto fail;
    if (a) {
      o->oldPath = GCString(p, a);
      if (!o->oldPath) {
        result = GB_MEMORY;
        goto fail;
      }
    }
    p += a;
    if (b) {
      o->newPath = GCString(p, b);
      if (!o->newPath) {
        result = GB_MEMORY;
        goto fail;
      }
    }
    p += b;
  }
  for (i = 0; i < t.metadataCount; ++i) {
    GCMetadata *m = t.metadata + i;
    if ((size_t)(end - p) < 16)
      goto fail;
    flags = GCWord(p);
    a = GCWord(p + 4);
    b = GCWord(p + 8);
    c = GCWord(p + 12);
    p += 16;
    if ((flags & ~3U) || !a || a > (size_t)(end - p) ||
        b > (size_t)(end - p) - a || c > (size_t)(end - p) - a - b ||
        memchr(p, 0, a))
      goto fail;
    m->beforePresent = (int)(flags & 1);
    m->afterPresent = (int)((flags >> 1) & 1);
    m->path = GCString(p, a);
    p += a;
    m->before = (unsigned char *)GCString(p, b);
    p += b;
    m->after = (unsigned char *)GCString(p, c);
    p += c;
    m->beforeLength = b;
    m->afterLength = c;
    if (!m->path || !m->before || !m->after) {
      result = GB_MEMORY;
      goto fail;
    }
  }
  for(i=0;i<t.directoryCount;++i) {
    if((size_t)(end-p)<4)goto fail;
    a=GCWord(p);p+=4;
    if(!a || a>(size_t)(end-p) || memchr(p,0,a))goto fail;
    t.directories[i]=GCString(p,a);
    if(!t.directories[i]){result=GB_MEMORY;goto fail;}
    p+=a;
  }
  for(i=0;i<t.createdDirectoryCount;++i) {
    GCDirectory *d=t.createdDirectories+i;
    if((size_t)(end-p)<52)goto fail;
    a=GCWord(p);flags=GCWord(p+4);
    if(!a || a>(size_t)(end-p)-52 || flags>255 || memchr(p+52,0,a))goto fail;
    d->attributes=(unsigned char)flags;d->created=GCWord(p+8);d->modified=GCWord(p+12);d->backup=GCWord(p+16);
    memcpy(d->finderInfo,p+20,32);d->path=GCString(p+52,a);
    if(!d->path){result=GB_MEMORY;goto fail;}p+=52+a;
  }
  if (p != end)
    goto fail;
  result = GCValidate(&t, eq, ctx);
  if (result)
    goto fail;
  GCDigest((const unsigned char *)bytes + 20, length - 40, digest);
  GBOIDFormat(digest, hex);
  sprintf(t.token, "%08lx-%.20s", (unsigned long)t.generation, hex);
  t.original = (unsigned char *)malloc(length);
  if (!t.original) {
    result = GB_MEMORY;
    goto fail;
  }
  memcpy(t.original, bytes, length);
  t.originalLength = length;
  GCFree(out);
  *out = t;
  return 0;
fail:
  GCFree(&t);
  return result;
}
static int GCBackendValid(const GCBackend *b) {
  return b && b->lock && b->unlock && b->begin && b->inspect && b->prepare &&
         b->move && b->erase && b->finish;
}
static int GCReadMetadata(GSRepository *r, const GCMetadata *m, int after,
                          int *matches) {
  unsigned char *p = NULL;
  size_t n = 0;
  int result, present = after ? m->afterPresent : m->beforePresent;
  const unsigned char *want = after ? m->after : m->before;
  size_t length = after ? m->afterLength : m->beforeLength;
  *matches = 0;
  result = r->read(r->context, m->path, &p, &n);
  if (result == GS_NOT_FOUND) {
    *matches = !present;
    return 0;
  }
  if (result)
    return result;
  *matches = present && n == length && (!n || !memcmp(p, want, n));
  free(p);
  return 0;
}
static int GCCheckMetadata(GSRepository *r, const GCTransaction *t, int which) {
  size_t i;
  int result, before, after;
  for (i = 0; i < t->metadataCount; ++i) {
    result = GCReadMetadata(r, t->metadata + i, 0, &before);
    if (result)
      return result;
    if (which == 0) {
      if (!before)
        return GS_CONFLICT;
      continue;
    }
    result = GCReadMetadata(r, t->metadata + i, 1, &after);
    if (result)
      return result;
    if (which == 1 ? !after : (!before && !after))
      return GS_CONFLICT;
  }
  return 0;
}
static int GCMetadataApply(GSRepository *r, GCBackend *b,
                           const GCTransaction *t, int rollback) {
  size_t pos, i;
  const GCMetadata *m;
  int result, before, after, present, expectedPresent;
  const unsigned char *expected, *next;
  size_t en, nn;
  for (pos = 0; pos < t->metadataCount; ++pos) {
    result = GCCheckMetadata(r, t, 2);
    if (result)
      return result;
    i = rollback ? t->metadataCount - pos - 1 : pos;
    m = t->metadata + i;
    result = GCReadMetadata(r, m, 0, &before);
    if (result)
      return result;
    result = GCReadMetadata(r, m, 1, &after);
    if (result)
      return result;
    if (rollback ? before : after)
      continue;
    if (rollback ? !after : !before)
      return GS_CONFLICT;
    expectedPresent = rollback ? m->afterPresent : m->beforePresent;
    expected = rollback ? m->after : m->before;
    en = rollback ? m->afterLength : m->beforeLength;
    present = rollback ? m->beforePresent : m->afterPresent;
    next = rollback ? m->before : m->after;
    nn = rollback ? m->beforeLength : m->afterLength;
    if (present)
      result = r->replace(r->context, m->path,
                          expectedPresent ? expected : NULL, en, next, nn);
    else
      result = b->erase(b->context, m->path, expected, en);
    if (result)
      return result;
  }
  return GCCheckMetadata(r, t, rollback ? 0 : 1);
}
static int GCInspect(GCBackend *b, const GCTransaction *t, int area, size_t i,
                     const char *path, GCFile *f) {
  int result;
  memset(f, 0, sizeof(*f));
  result = b->inspect(b->context, t, area, i, path, f);
  if (!result && f->present != 0 && f->present != 1 && f->present != 2)
    return GS_FORMAT;
  return result;
}
static const GCFile *GCExpected(const GCTransaction *t, const char *path,
                                int old, GCEqual eq, void *ctx,
                                int *directory) {
  size_t i;
  const char *other;
  int relation;
  *directory = 0;
  for (i = 0; i < t->fileCount; ++i) {
    other = old ? t->files[i].oldPath : t->files[i].newPath;
    if (!other)
      continue;
    relation = GCRelation(path, other, eq, ctx);
    if (relation == 1)
      return old ? &t->files[i].oldFile : &t->files[i].newFile;
    if (relation == 2)
      *directory = 1;
  }
  if(old)
    for(i=0;i<t->directoryCount;++i)
      if(GCRelation(path,t->directories[i],eq,ctx))*directory=1;
  if(!old)
    for(i=0;i<t->createdDirectoryCount;++i)
      if(GCRelation(path,t->createdDirectories[i].path,eq,ctx))*directory=1;
  return NULL;
}
static int GCCheckFiles(GCBackend *b, const GCTransaction *t, int old,
                        GCEqual eq, void *ctx) {
  GCFile have;
  const GCFile *want;
  const char *path;
  size_t i;
  int side, result, directory;
  for (i = 0; i < t->fileCount+t->directoryCount+t->createdDirectoryCount; ++i)
    for (side = 0; side < 2; ++side) {
      path = i<t->fileCount ? (side ? t->files[i].newPath : t->files[i].oldPath) :
             (side?NULL:i<t->fileCount+t->directoryCount?t->directories[i-t->fileCount]:
                 t->createdDirectories[i-t->fileCount-t->directoryCount].path);
      if (!path)
        continue;
      want = GCExpected(t, path, old, eq, ctx, &directory);
      result = GCInspect(b, t, GC_LIVE, i<t->fileCount?i:0, path, &have);
      if (result)
        return result;
      /* A new directory cannot take over an existing directory's identity. */
      if(old && i>=t->fileCount+t->directoryCount && have.present==2)return GS_CONFLICT;
      if (want) {
        if (!GCFileEqual(&have, want))
          return GS_CONFLICT;
      } else if (directory) {
        if (have.present != 2)
          return GS_CONFLICT;
      } else if (have.present)
        return GS_CONFLICT;
    }
  return 0;
}
static int GCState(GSRepository *r, GCTransaction *t, GCEqual eq, void *ctx,
                   GBWord phase) {
  unsigned char *bytes;
  size_t n;
  GBWord old = t->phase;
  int result;
  t->phase = phase;
  result = GCEncode(t, eq, ctx, &bytes, &n);
  if (result) {
    t->phase = old;
    return result;
  }
  result = r->replace(r->context, "checkout-journal", t->original,
                      t->originalLength, bytes, n);
  if (result) {
    free(bytes);
    t->phase = old;
    return result;
  }
  free(t->original);
  t->original = bytes;
  t->originalLength = n;
  return 0;
}
static int GCIdleRead(GSRepository *r, unsigned char **bytes, size_t *n,
                      GBWord *generation) {
  unsigned char hash[20];
  int result;
  *bytes = NULL;
  *n = 0;
  *generation = 0;
  result = r->read(r->context, "checkout-journal", bytes, n);
  if (result == GS_NOT_FOUND)
    return 0;
  if (result)
    return result;
  if (*n != 32 || memcmp(*bytes, "GHCI0001", 8))
    return GC_RECOVERY;
  GCDigest(*bytes, 12, hash);
  if (memcmp(hash, *bytes + 12, 20))
    return GB_CHECKSUM;
  *generation = GCWord(*bytes + 8);
  return 0;
}
int GCWriteAllowed(GSRepository *r) {
  unsigned char *bytes = NULL;
  size_t n = 0;
  GBWord generation;
  int result;
  if (!r || !r->read)
    return GB_BAD;
  result = GCIdleRead(r, &bytes, &n, &generation);
  free(bytes);
  return result;
}
static int GCIdleSave(GSRepository *r, const GCTransaction *t) {
  unsigned char idle[32];
  memcpy(idle, "GHCI0001", 8);
  GCPut(idle + 8, t->generation);
  GCDigest(idle, 12, idle + 12);
  return r->replace(r->context, "checkout-journal", t->original,
                    t->originalLength, idle, 32);
}
static int GCPrepareFiles(GSRepository *r, GCBackend *b, const GCTransaction *t,
                          GCEqual eq, void *ctx) {
  size_t i;
  GCFile f;
  int result;
  result = GCCheckMetadata(r, t, 0);
  if (!result)
    result = GCCheckFiles(b, t, 1, eq, ctx);
  if (result)
    return result;
  for (i = 0; i < t->fileCount; ++i) {
    result = GCInspect(b, t, GC_BACKUP, i, NULL, &f);
    if (result)
      return result;
    if (f.present)
      return GS_CONFLICT;
    if (!t->files[i].newFile.present)
      continue;
    result = GCInspect(b, t, GC_READY, i, NULL, &f);
    if (result)
      return result;
    if (!f.present) {
      result = b->prepare(b->context, t, i);
      if (result)
        return result;
      result = GCInspect(b, t, GC_READY, i, NULL, &f);
      if (result)
        return result;
    }
    if (!GCFileEqual(&f, &t->files[i].newFile))
      return GS_CONFLICT;
  }
  return 0;
}
static int GCBackupFiles(GSRepository *r, GCBackend *b,
                         const GCTransaction *t) {
  size_t i;
  GCFile backup, live;
  int result;
  result = GCCheckMetadata(r, t, 0);
  if (result)
    return result;
  for (i = 0; i < t->fileCount; ++i) {
    const GCOperation *o = t->files + i;
    if (!o->oldFile.present)
      continue;
    result = GCInspect(b, t, GC_BACKUP, i, NULL, &backup);
    if (result)
      return result;
    result = GCInspect(b, t, GC_LIVE, i, o->oldPath, &live);
    if (result)
      return result;
    if (backup.present) {
      if (!GCFileEqual(&backup, &o->oldFile) || live.present)
        return GS_CONFLICT;
    } else {
      if (!GCFileEqual(&live, &o->oldFile))
        return GS_CONFLICT;
      result = b->move(b->context, t, i, GC_LIVE, o->oldPath, GC_BACKUP, NULL,
                       &o->oldFile);
      if (result)
        return result;
    }
  }
  return 0;
}
static int GCInstallFiles(GCBackend *b, const GCTransaction *t, GCEqual eq,
                          void *ctx) {
  size_t i;
  GCFile ready, live;
  int result, directory;
  const GCFile *old;
  for (i = 0; i < t->fileCount; ++i) {
    const GCOperation *o = t->files + i;
    if (!o->newFile.present)
      continue;
    result = GCInspect(b, t, GC_READY, i, NULL, &ready);
    if (result)
      return result;
    result = GCInspect(b, t, GC_LIVE, i, o->newPath, &live);
    if (result)
      return result;
    if (!ready.present) {
      if (!GCFileEqual(&live, &o->newFile))
        return GS_CONFLICT;
      continue;
    }
    if (!GCFileEqual(&ready, &o->newFile))
      return GS_CONFLICT;
    old = GCExpected(t, o->newPath, 1, eq, ctx, &directory);
    (void)old;
    if (live.present && !(live.present == 2 && directory))
      return GS_CONFLICT;
    result = b->move(b->context, t, i, GC_READY, NULL, GC_LIVE, o->newPath,
                     &o->newFile);
    if (result)
      return result;
  }
  return GCCheckFiles(b, t, 0, eq, ctx);
}
static int GCUninstallFiles(GCBackend *b, const GCTransaction *t) {
  size_t i;
  GCFile ready, live;
  int result;
  if (t->rollbackFrom < GC_INSTALLING)
    return 0;
  for (i = 0; i < t->fileCount; ++i) {
    const GCOperation *o = t->files + i;
    if (!o->newFile.present)
      continue;
    result = GCInspect(b, t, GC_READY, i, NULL, &ready);
    if (result)
      return result;
    result = GCInspect(b, t, GC_LIVE, i, o->newPath, &live);
    if (result)
      return result;
    if (ready.present) {
      if (!GCFileEqual(&ready, &o->newFile) || live.present == 1)
        return GS_CONFLICT;
    } else {
      if (!GCFileEqual(&live, &o->newFile))
        return GS_CONFLICT;
      result = b->move(b->context, t, i, GC_LIVE, o->newPath, GC_READY, NULL,
                       &o->newFile);
      if (result)
        return result;
    }
  }
  return 0;
}
static int GCRestoreFiles(GCBackend *b, const GCTransaction *t, GCEqual eq,
                          void *ctx) {
  size_t i;
  GCFile backup, live;
  int result, directory;
  const GCFile *newFile;
  for (i = 0; i < t->fileCount; ++i) {
    const GCOperation *o = t->files + i;
    if (!o->oldFile.present)
      continue;
    result = GCInspect(b, t, GC_BACKUP, i, NULL, &backup);
    if (result)
      return result;
    result = GCInspect(b, t, GC_LIVE, i, o->oldPath, &live);
    if (result)
      return result;
    if (!backup.present) {
      if (!GCFileEqual(&live, &o->oldFile))
        return GS_CONFLICT;
      continue;
    }
    if (!GCFileEqual(&backup, &o->oldFile))
      return GS_CONFLICT;
    newFile = GCExpected(t, o->oldPath, 0, eq, ctx, &directory);
    (void)newFile;
    if (live.present && !(live.present == 2 && directory))
      return GS_CONFLICT;
    result = b->move(b->context, t, i, GC_BACKUP, NULL, GC_LIVE, o->oldPath,
                     &o->oldFile);
    if (result)
      return result;
  }
  return GCCheckFiles(b, t, 1, eq, ctx);
}
static int GCRun(GSRepository *r, GCBackend *b, GCEqual eq, void *ctx,
                 GCTransaction *t, int rollback) {
  int result;
  GBWord oldFrom;
  if((t->directoryCount && !b->directories) || (t->createdDirectoryCount && !b->createdDirectories))return GB_BAD;
  result = b->begin(b->context, t);
  if (result)
    return result;
  if (rollback && t->phase < GC_COMMITTED) {
    oldFrom = t->rollbackFrom;
    t->rollbackFrom = t->phase;
    result = GCState(r, t, eq, ctx, GC_ROLLBACK_META);
    if (result) {
      t->rollbackFrom = oldFrom;
      return result;
    }
  }
  for (;;) {
    switch (t->phase) {
    case GC_PREPARE:
      result = GCPrepareFiles(r, b, t, eq, ctx);
      if (result)
        return result;
      result = GCState(r, t, eq, ctx, GC_BACKING_UP);
      break;
    case GC_BACKING_UP:
      result = GCBackupFiles(r, b, t);
      if(!result && t->directoryCount)result=b->directories(b->context,t,0);
      if (result)
        return result;
      result = GCState(r, t, eq, ctx, GC_INSTALLING);
      break;
    case GC_INSTALLING:
      result = GCCheckMetadata(r, t, 0);
      if(!result && t->createdDirectoryCount)result=b->createdDirectories(b->context,t,GC_DIR_INSTALL);
      if (!result)
        result = GCInstallFiles(b, t, eq, ctx);
      if(!result && t->createdDirectoryCount)result=b->createdDirectories(b->context,t,GC_DIR_VERIFY);
      if (result)
        return result;
      result = GCState(r, t, eq, ctx, GC_METADATA);
      break;
    case GC_METADATA:
      result = GCCheckFiles(b, t, 0, eq, ctx);
      if(!result && t->createdDirectoryCount)result=b->createdDirectories(b->context,t,GC_DIR_VERIFY);
      if (!result)
        result = GCMetadataApply(r, b, t, 0);
      if (!result)
        result = GCCheckFiles(b, t, 0, eq, ctx);
      if (result)
        return result;
      result = GCState(r, t, eq, ctx, GC_COMMITTED);
      break;
    case GC_ROLLBACK_META:
      result = GCMetadataApply(r, b, t, 1);
      if (result)
        return result;
      result = GCState(r, t, eq, ctx, GC_UNINSTALLING);
      break;
    case GC_UNINSTALLING:
      result = GCCheckMetadata(r, t, 0);
      if (!result)
        result = GCUninstallFiles(b, t);
      if(!result && t->createdDirectoryCount)result=b->createdDirectories(b->context,t,GC_DIR_UNINSTALL);
      if (result)
        return result;
      result = GCState(r, t, eq, ctx, GC_RESTORING);
      break;
    case GC_RESTORING:
      result = GCCheckMetadata(r, t, 0);
      if(!result && t->directoryCount)result=b->directories(b->context,t,1);
      if (!result)
        result = GCRestoreFiles(b, t, eq, ctx);
      if (result)
        return result;
      result = GCState(r, t, eq, ctx, GC_ROLLED_BACK);
      break;
    case GC_COMMITTED:
    case GC_ROLLED_BACK:
      /* The decision was recorded only after verification. Later user edits
         are ordinary post-transaction changes, not failed installation. Never
         rewrite them or keep the repository gated on their old identities. */
      result = b->finish(b->context, t, t->phase == GC_COMMITTED);
      return result ? result : GCIdleSave(r, t);
    default:
      return GS_FORMAT;
    }
    if (result)
      return result;
  }
}
int GCStart(GSRepository *r, GCBackend *b, GCEqual eq, void *ctx,
            const GCTransaction *plan) {
  GCTransaction t, candidate;
  unsigned char *old = NULL, *bytes = NULL;
  size_t oldLength = 0, n;
  GBWord generation;
  int result;
  if (!r || !r->read || !r->replace || !GCBackendValid(b) || !plan || !eq)
    return GB_BAD;
  GCInit(&t);
  result = b->lock(b->context);
  if (result)
    return result;
  result = GCIdleRead(r, &old, &oldLength, &generation);
  if (result)
    goto done;
  if (generation == 0xffffffffU) {
    result = GB_SPACE;
    goto done;
  }
  candidate = *plan;
  candidate.generation = generation + 1;
  candidate.phase = GC_PREPARE;
  candidate.rollbackFrom = 0;
  candidate.original = NULL;
  candidate.originalLength = 0;
  result = GCEncode(&candidate, eq, ctx, &bytes, &n);
  if (result)
    goto done;
  result = GCParse(bytes, n, eq, ctx, &t);
  if(!result && t.directoryCount && !b->directories)result=GB_BAD;
  if(!result && t.createdDirectoryCount && !b->createdDirectories)result=GB_BAD;
  if (result)
    goto done;
  result = GCCheckMetadata(r, &t, 0);
  if (!result)
    result = GCCheckFiles(b, &t, 1, eq, ctx);
  if (result)
    goto done;
  result = r->replace(r->context, "checkout-journal", old, oldLength, bytes, n);
  if (result)
    goto done;
  result = GCRun(r, b, eq, ctx, &t, 0);
done:
  free(old);
  free(bytes);
  GCFree(&t);
  b->unlock(b->context);
  return result;
}
int GCResume(GSRepository *r, GCBackend *b, GCEqual eq, void *ctx,
             int rollback) {
  unsigned char *bytes = NULL, *idle = NULL;
  size_t n = 0, idleLength = 0;
  GBWord generation;
  GCTransaction t;
  int result;
  if (!r || !r->read || !r->replace || !GCBackendValid(b) || !eq)
    return GB_BAD;
  GCInit(&t);
  result = b->lock(b->context);
  if (result)
    return result;
  result = GCIdleRead(r, &idle, &idleLength, &generation);
  if (!result)
    goto done;
  if (result != GC_RECOVERY)
    goto done;
  result = r->read(r->context, "checkout-journal", &bytes, &n);
  if (result)
    goto done;
  result = GCParse(bytes, n, eq, ctx, &t);
  if (!result)
    result = GCRun(r, b, eq, ctx, &t, rollback);
done:
  free(idle);
  free(bytes);
  GCFree(&t);
  b->unlock(b->context);
  return result;
}
