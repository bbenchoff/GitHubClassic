#include "GHCore.h"
#include <string.h>
#include <stdlib.h>
#include <limits.h>

typedef struct { size_t start, end; int next, count; char type; } Token;
typedef struct { const char *s; size_t length, pos; Token *tokens;
    int used; } Parser;
static void White(Parser *p) {
    while(p->pos < p->length && (p->s[p->pos]==' ' || p->s[p->pos]=='\r' ||
          p->s[p->pos]=='\n' || p->s[p->pos]=='\t')) ++p->pos;
}
static int Hex(int c) {
    if(c>='0' && c<='9') return c-'0';
    if(c>='a' && c<='f') return c-'a'+10;
    if(c>='A' && c<='F') return c-'A'+10;
    return -1;
}
static int Value(Parser *p, int depth) {
    int n, child, i; char c, close; size_t begin;
    White(p);
    if(depth>32 || p->used>=GH_JSON_TOKENS || p->pos>=p->length) return -1;
    n=p->used++; p->tokens[n].start=p->pos; p->tokens[n].count=0;
    c=p->s[p->pos++]; p->tokens[n].type=c;
    if(c=='{' || c=='[') {
        close=c=='{' ? '}' : ']'; White(p);
        if(p->pos<p->length && p->s[p->pos]==close) ++p->pos;
        else for(;;) {
            if(c=='{' && (p->pos>=p->length || p->s[p->pos]!='"')) return -1;
            child=Value(p,depth+1); if(child<0) return -1;
            ++p->tokens[n].count; White(p);
            if(c=='{') {
                if(p->pos>=p->length || p->s[p->pos++]!=':') return -1;
                if(Value(p,depth+1)<0) return -1;
                ++p->tokens[n].count; White(p);
            }
            if(p->pos>=p->length) return -1;
            if(p->s[p->pos]==close) { ++p->pos; break; }
            if(p->s[p->pos++]!=',') return -1;
            White(p);
        }
    } else if(c=='"') {
        for(;;) {
            if(p->pos>=p->length) return -1;
            c=p->s[p->pos++]; if(c=='"') break;
            if((unsigned char)c<32) return -1;
            if(c=='\\') {
                if(p->pos>=p->length) return -1;
                c=p->s[p->pos++];
                if(c=='u') {
                    for(i=0;i<4;++i) {
                        if(p->pos>=p->length || Hex(p->s[p->pos++])<0) return -1;
                    }
                } else if(!strchr("\"\\/bfnrt",c)) return -1;
            }
        }
    } else {
        begin=p->pos-1;
        if(c=='t' || c=='f' || c=='n') {
            const char *literal=c=='t' ? "true" : c=='f' ? "false" : "null";
            size_t len=strlen(literal);
            if(p->length-begin<len || memcmp(p->s+begin,literal,len)) return -1;
            p->pos=begin+len;
        } else {
            p->pos=begin;
            if(p->s[p->pos]=='-') ++p->pos;
            if(p->pos>=p->length) return -1;
            if(p->s[p->pos]=='0') ++p->pos;
            else {
                if(p->s[p->pos]<'1' || p->s[p->pos]>'9') return -1;
                while(p->pos<p->length && p->s[p->pos]>='0' && p->s[p->pos]<='9') ++p->pos;
            }
            if(p->pos<p->length && p->s[p->pos]=='.') {
                ++p->pos; begin=p->pos;
                while(p->pos<p->length && p->s[p->pos]>='0' && p->s[p->pos]<='9') ++p->pos;
                if(begin==p->pos) return -1;
            }
            if(p->pos<p->length && (p->s[p->pos]=='e' || p->s[p->pos]=='E')) {
                ++p->pos;
                if(p->pos<p->length && (p->s[p->pos]=='+' || p->s[p->pos]=='-')) ++p->pos;
                begin=p->pos;
                while(p->pos<p->length && p->s[p->pos]>='0' && p->s[p->pos]<='9') ++p->pos;
                if(begin==p->pos) return -1;
            }
        }
    }
    p->tokens[n].end=p->pos; p->tokens[n].next=p->used; return n;
}
static int Equal(Parser *p, int n, const char *s) {
    return n>=0 && p->tokens[n].type=='"' &&
        p->tokens[n].end-p->tokens[n].start==strlen(s)+2 &&
        !memcmp(p->s+p->tokens[n].start+1,s,strlen(s));
}
static int Field(Parser *p, int n, const char *name) {
    int key, val;
    if(n<0 || p->tokens[n].type!='{') return -1;
    key=n+1;
    while(key<p->tokens[n].next) {
        val=key+1; if(Equal(p,key,name)) return val;
        key=p->tokens[val].next;
    }
    return -1;
}
/* Unicode mapping matches the Macintosh Roman character set. */
static unsigned short roman[128]={
  0xc4,0xc5,0xc7,0xc9,0xd1,0xd6,0xdc,0xe1,0xe0,0xe2,0xe4,0xe3,0xe5,0xe7,0xe9,0xe8,
  0xea,0xeb,0xed,0xec,0xee,0xef,0xf1,0xf3,0xf2,0xf4,0xf6,0xf5,0xfa,0xf9,0xfb,0xfc,
  0x2020,0xb0,0xa2,0xa3,0xa7,0x2022,0xb6,0xdf,0xae,0xa9,0x2122,0xb4,0xa8,0x2260,0xc6,0xd8,
  0x221e,0xb1,0x2264,0x2265,0xa5,0xb5,0x2202,0x2211,0x220f,0x3c0,0x222b,0xaa,0xba,0x3a9,0xe6,0xf8,
  0xbf,0xa1,0xac,0x221a,0x192,0x2248,0x2206,0xab,0xbb,0x2026,0xa0,0xc0,0xc3,0xd5,0x152,0x153,
  0x2013,0x2014,0x201c,0x201d,0x2018,0x2019,0xf7,0x25ca,0xff,0x178,0x2044,0x20ac,0x2039,0x203a,0xfb01,0xfb02,
  0x2021,0xb7,0x201a,0x201e,0x2030,0xc2,0xca,0xc1,0xcb,0xc8,0xcd,0xce,0xcf,0xcc,0xd3,0xd4,
  0xf8ff,0xd2,0xda,0xdb,0xd9,0x131,0x2c6,0x2dc,0xaf,0x2d8,0x2d9,0x2da,0xb8,0x2dd,0x2db,0x2c7};
static unsigned char MacChar(unsigned long c) {
    int i;
    if(c<128) return c=='\n' ? '\r' : (unsigned char)c;
    for(i=0;i<128;++i) if(roman[i]==c) return (unsigned char)(128+i);
    return '?';
}
static int String(Parser *p, int n, char *out, size_t cap, int mac) {
    size_t i, end, used=0; unsigned long c; int j, count;
    if(!cap) return -1;
    out[0]=0;
    if(n<0 || p->tokens[n].type!='"') return -1;
    i=p->tokens[n].start+1; end=p->tokens[n].end-1;
    while(i<end && used+1<cap) {
        c=(unsigned char)p->s[i++];
        if(c=='\\') {
            c=(unsigned char)p->s[i++];
            if(c=='u') {
                c=0; for(j=0;j<4;++j) c=c*16+Hex(p->s[i++]);
                if(c>=0xd800 && c<=0xdbff && end-i>=6 && p->s[i]=='\\' && p->s[i+1]=='u') {
                    unsigned long low=0; i+=2;
                    for(j=0;j<4;++j) low=low*16+Hex(p->s[i++]);
                    c=low>=0xdc00 && low<=0xdfff ? 0x10000+(c-0xd800)*1024+low-0xdc00 : 0xfffd;
                }
            } else if(c=='n') c='\n'; else if(c=='r') c='\r';
            else if(c=='t') c='\t'; else if(c=='b' || c=='f') c=' ';
        } else if(mac && c>=0xc0) {
            count=c>=0xf0 ? 3 : c>=0xe0 ? 2 : 1;
            c &= count==3 ? 7 : count==2 ? 15 : 31;
            for(j=0;j<count;++j) {
                if(i>=end || ((unsigned char)p->s[i]&0xc0)!=0x80) { c=0xfffd; break; }
                c=c*64+((unsigned char)p->s[i++]&63);
            }
        }
        /* URLs are ASCII and are restricted again before use. */
        out[used++]=mac ? MacChar(c) : c<128 && c>=32 ? (char)c : '?';
    }
    out[used]=0;
    return i<end ? 1 : 0;
}
static int CaseEqual(const unsigned char *a, size_t len, const char *b) {
    size_t i; int c;
    if(len!=strlen(b)) return 0;
    for(i=0;i<len;++i) { c=a[i]; if(c>='A' && c<='Z') c+=32;
        if(c!=b[i]) return 0; }
    return 1;
}
static size_t LineEnd(const unsigned char *d, size_t n, size_t start) {
    size_t i; for(i=start;i+1<n;++i) if(d[i]=='\r' && d[i+1]=='\n') return i;
    return n;
}
int GHHTTPContentType(const unsigned char *d, size_t n, const char *expected) {
    size_t at, end, colon, value, stop;
    int found = 0;
    if (!d || !expected) return -1;
    at = LineEnd(d, n, 0);
    if (at == n) return 1;
    if (at < 12 || (memcmp(d, "HTTP/1.1 ", 9) && memcmp(d, "HTTP/1.0 ", 9))) return -1;
    at += 2;
    for (;;) {
        end = LineEnd(d, n, at);
        if (end == n) return 1;
        if (at == end) return found ? 0 : -1;
        colon = at;
        while (colon < end && d[colon] != ':') ++colon;
        if (colon == end) return -1;
        if (CaseEqual(d + at, colon - at, "content-type")) {
            if (found) return -1;
            value = colon + 1;
            while (value < end && (d[value] == ' ' || d[value] == '\t')) ++value;
            stop = value;
            while (stop < end && d[stop] != ';') ++stop;
            while (stop > value && (d[stop - 1] == ' ' || d[stop - 1] == '\t')) --stop;
            if (!CaseEqual(d + value, stop - value, expected)) return -1;
            found = 1;
        }
        at = end + 2;
    }
}
int DecodeHTTP(unsigned char *d, size_t n, int eof, size_t *body, int *status) {
    size_t line, pos, end, colon, v, i, length=0, input, output, chunk;
    int haveLength=0, chunked=0, digit;
    if(!d || !body || !status) return -1;
    line=LineEnd(d,n,0); if(line==n) return eof ? -1 : 1;
    if(line<12 || (memcmp(d,"HTTP/1.1 ",9) && memcmp(d,"HTTP/1.0 ",9))) return -1;
    for(i=9;i<12;++i) if(d[i]<'0' || d[i]>'9') return -1;
    *status=(d[9]-'0')*100+(d[10]-'0')*10+d[11]-'0'; pos=line+2;
    for(;;) {
        end=LineEnd(d,n,pos); if(end==n) return eof ? -1 : 1;
        if(end==pos) { pos+=2; break; }
        colon=pos; while(colon<end && d[colon]!=':') ++colon;
        if(colon==end) return -1;
        v=colon+1; while(v<end && (d[v]==' ' || d[v]=='\t')) ++v;
        if(CaseEqual(d+pos,colon-pos,"content-length")) {
            if(haveLength || v==end) return -1;
            haveLength=1;
            for(i=v;i<end;++i) {
                digit=d[i]-'0'; if(digit<0 || digit>9 || length>(4194304UL-(size_t)digit)/10) return -1;
                length=length*10+digit;
            }
        } else if(CaseEqual(d+pos,colon-pos,"transfer-encoding")) {
            if(chunked || !CaseEqual(d+v,end-v,"chunked")) return -1;
            chunked=1;
        } else if(CaseEqual(d+pos,colon-pos,"content-encoding") && !CaseEqual(d+v,end-v,"identity")) return -1;
        pos=end+2;
    }
    if(chunked && haveLength) return -1;
    if(!chunked) {
        if(haveLength) { if(n-pos<length) return eof ? -1 : 1; }
        else { if(!eof) return 1; length=n-pos; }
        memmove(d,d+pos,length); *body=length; return 0;
    }
    /* Validate the complete chunk stream before changing the input. */
    input=pos;
    for(;;) {
        end=LineEnd(d,n,input); if(end==n) return eof ? -1 : 1;
        chunk=0; i=input;
        while(i<end && d[i]!=';') {
            digit=Hex(d[i++]); if(digit<0 || chunk>(4194304UL-(size_t)digit)/16) return -1;
            chunk=chunk*16+digit;
        }
        if(i==input) return -1;
        input=end+2;
        if(!chunk) {
            for(;;) { end=LineEnd(d,n,input); if(end==n) return eof ? -1 : 1;
                if(end==input) break;
                input=end+2; }
            break;
        }
        if(n-input<chunk+2) return eof ? -1 : 1;
        input+=chunk; if(d[input]!='\r' || d[input+1]!='\n') return -1; input+=2;
    }
    input=pos; output=0;
    for(;;) {
        end=LineEnd(d,n,input); chunk=0;
        for(i=input;i<end && d[i]!=';';++i) chunk=chunk*16+Hex(d[i]);
        input=end+2; if(!chunk) break;
        memmove(d+output,d+input,chunk); output+=chunk; input+=chunk+2;
    }
    *body=output; return 0;
}

static int GHHTTPTokenByte(unsigned char c) {
    if(c<=32 || c>=127)return 0;
    return (c>='A' && c<='Z') || (c>='a' && c<='z') || (c>='0' && c<='9') ||
        strchr("!#$%&'*+-.^_`|~",c)!=NULL;
}
static int GHHTTPParts(const unsigned char *d,size_t first,size_t end,size_t *colon,size_t *value,size_t *stop) {
    size_t i=first;
    while(i<end && GHHTTPTokenByte(d[i]))++i;
    if(i==first || i==end || d[i]!=':')return 0;
    *colon=i;*value=i+1;
    while(*value<end && (d[*value]==' ' || d[*value]=='\t'))++*value;
    *stop=end;while(*stop>*value && (d[*stop-1]==' ' || d[*stop-1]=='\t'))--*stop;
    for(i=*value;i<*stop;++i)if((d[i]<32 && d[i]!='\t') || d[i]==127)return 0;
    return 1;
}
static int GHHTTPConnection(const unsigned char *d,size_t first,size_t end) {
    size_t at=first,start;int found=0;
    while(at<end) {
        while(at<end && (d[at]==' ' || d[at]=='\t' || d[at]==','))++at;
        start=at;while(at<end && GHHTTPTokenByte(d[at]))++at;
        if(at==start)break;
        if(CaseEqual(d+start,at-start,"close") || CaseEqual(d+start,at-start,"upgrade"))return 0;
        found=1;while(at<end && (d[at]==' ' || d[at]=='\t'))++at;
        if(at<end && d[at]!=',')return 0;
    }
    return found && at==end;
}
int GHHTTPReusable(const unsigned char *d,size_t n) {
    size_t at,end,colon,value,stop,i,length=0,chunk,total=0;int haveLength=0,chunked=0,digit;
    if(!d || n<14 || memcmp(d,"HTTP/1.1 200 ",13))return 0;
    end=LineEnd(d,n,0);if(end==n)return 0;
    for(i=13;i<end;++i)if((d[i]<32 && d[i]!='\t') || d[i]==127)return 0;
    at=end+2;
    for(;;) {
        end=LineEnd(d,n,at);if(end==n)return 0;
        if(end==at){at+=2;break;}
        if(!GHHTTPParts(d,at,end,&colon,&value,&stop))return 0;
        if(CaseEqual(d+at,colon-at,"content-length")) {
            if(haveLength || value==stop || stop!=end)return 0;
            haveLength=1;
            for(i=value;i<stop;++i) {
                digit=d[i]-'0';if(digit<0 || digit>9 || length>(4194304UL-(size_t)digit)/10)return 0;
                length=length*10+digit;
            }
        } else if(CaseEqual(d+at,colon-at,"transfer-encoding")) {
            if(chunked || stop!=end || !CaseEqual(d+value,stop-value,"chunked"))return 0;
            chunked=1;
        } else if(CaseEqual(d+at,colon-at,"connection")) {
            if(!GHHTTPConnection(d,value,stop))return 0;
        } else if(CaseEqual(d+at,colon-at,"upgrade") || CaseEqual(d+at,colon-at,"proxy-connection"))return 0;
        else if(CaseEqual(d+at,colon-at,"content-encoding") &&
            (stop!=end || !CaseEqual(d+value,stop-value,"identity")))return 0;
        at=end+2;
    }
    if(haveLength && chunked)return 0;
    if(haveLength)return n-at==length;
    if(!chunked)return 0; /* Close-delimited replies remain supported, but close. */
    for(;;) {
        end=LineEnd(d,n,at);if(end==n)return 0;
        chunk=0;i=at;
        while(i<end && d[i]!=';') {
            digit=Hex(d[i++]);if(digit<0 || chunk>(4194304UL-(size_t)digit)/16)return 0;
            chunk=chunk*16+digit;
        }
        if(i==at || (i<end && i+1==end))return 0;
        for(;i<end;++i)if((d[i]<32 && d[i]!='\t') || d[i]==127)return 0;
        at=end+2;
        if(!chunk) {
            for(;;) {
                end=LineEnd(d,n,at);if(end==n)return 0;
                if(end==at)return end+2==n;
                if(!GHHTTPParts(d,at,end,&colon,&value,&stop))return 0;
                if(CaseEqual(d+at,colon-at,"content-length") || CaseEqual(d+at,colon-at,"transfer-encoding") ||
                    CaseEqual(d+at,colon-at,"connection") || CaseEqual(d+at,colon-at,"upgrade") ||
                    CaseEqual(d+at,colon-at,"content-encoding"))return 0;
                at=end+2;
            }
        }
        if(total>4194304UL-chunk || chunk>n-at || n-at-chunk<2)return 0;
        total+=chunk;at+=chunk;
        if(d[at]!='\r' || d[at+1]!='\n')return 0;
        at+=2;
    }
}

int GHField(const char *json,size_t length,const char *field,char *out,size_t cap) {
    Parser p; int root,n,error=-1;
    if(!json || !out || !cap || length>1048576UL) return -1;
    p.tokens=(Token*)calloc(GH_JSON_TOKENS,sizeof(Token)); if(!p.tokens) return -1;
    p.s=json;p.length=length;p.pos=0;p.used=0;
    root=Value(&p,0); White(&p);
    if(root>=0 && p.pos==length && p.tokens[root].type=='{') {
        n=Field(&p,root,field);
        if(n>=0 && p.tokens[n].type=='"') error=String(&p,n,out,cap,1);
    }
    free(p.tokens);return error;
}

static int Document(Parser *p,const char *json,size_t length,char type) {
    int root;
    memset(p,0,sizeof(*p));
    if(!json || length>1048576UL) return -1;
    p->tokens=(Token*)calloc(GH_JSON_TOKENS,sizeof(Token));if(!p->tokens)return -1;
    p->s=json;p->length=length;root=Value(p,0);White(p);
    if(root<0 || p->pos!=length || p->tokens[root].type!=type) {
        free(p->tokens);p->tokens=NULL;return -1;
    }
    return root;
}
static int JSONGetString(Parser *p,int object,const char *field,char *out,size_t cap,int optional) {
    int n = Field(p, object, field);
    out[0] = 0;
    if (optional && (n < 0 || p->tokens[n].type == 'n'))
        return 0;
    return String(p, n, out, cap, 1);
}
static int ProtocolString(Parser *p, int n, char *out, size_t cap) {
    size_t i, end, used = 0;
    unsigned long c;
    int j;
    if (n < 0 || p->tokens[n].type != '"' || !out || !cap)
        return -1;
    i = p->tokens[n].start + 1;
    end = p->tokens[n].end - 1;
    while (i < end) {
        c = (unsigned char)p->s[i++];
        if (c == '\\') {
            c = (unsigned char)p->s[i++];
            if (c == 'u') {
                c = 0;
                for (j = 0; j < 4; ++j)
                    c = c * 16 + Hex(p->s[i++]);
            } else if (c != '"' && c != '\\' && c != '/')
                return -1;
        }
        if (c < 32 || c > 126 || used + 1 >= cap)
            return -1;
        out[used++] = (char)c;
    }
    out[used] = 0;
    return 0;
}
static void ClearProtocolMembers(GHJSONMember *fields, size_t count) {
    size_t i;
    for (i = 0; i < count; ++i) {
        fields[i].present = 0;
        if (fields[i].text && fields[i].capacity)
            memset(fields[i].text, 0, fields[i].capacity);
        if (fields[i].number)
            *fields[i].number = 0;
    }
}
int GHJSONMembers(const char *json, size_t length, GHJSONMember *fields, size_t count) {
    Parser p;
    int root, key, value, error = -1;
    size_t i, j, start, end, n;
    unsigned long number;
    char name[128];
    GHJSONMember *f;
    if (!fields || count > 64)
        return -1;
    ClearProtocolMembers(fields, count);
    root = Document(&p, json, length, '{');
    if (root < 0)
        return -1;
    key = root + 1;
    while (key < p.tokens[root].next) {
        if (ProtocolString(&p, key, name, sizeof(name)))
            goto done;
        value = key + 1;
        for (i = 0; i < count; ++i)
            if (!strcmp(name, fields[i].name)) {
                f = fields + i;
                if (f->present)
                    goto done;
                f->present = 1;
                if (f->kind == 1) {
                    if (ProtocolString(&p, value, f->text, f->capacity))
                        goto done;
                } else if (f->kind == 2 || f->kind == 3) {
                    start = p.tokens[value].start;
                    end = p.tokens[value].end;
                    n = end - start;
                    if (!n || (n > 1 && p.s[start] == '0'))
                        goto done;
                    number = 0;
                    for (j = start; j < end; ++j) {
                        if (p.s[j] < '0' || p.s[j] > '9')
                            goto done;
                        if (f->kind == 2) {
                            if (number > (0xffffffffUL - (unsigned long)(p.s[j] - '0')) / 10)
                                goto done;
                            number = number * 10 + (unsigned long)(p.s[j] - '0');
                        }
                    }
                    if (f->kind == 2) {
                        if (!f->number)
                            goto done;
                        *f->number = number;
                    } else {
                        if (!f->text || n >= f->capacity)
                            goto done;
                        memcpy(f->text, p.s + start, n);
                        f->text[n] = 0;
                    }
                } else
                    goto done;
                break;
            }
        key = p.tokens[value].next;
    }
    for (i = 0; i < count; ++i)
        if (fields[i].required && !fields[i].present)
            goto done;
    error = 0;
done:
    free(p.tokens);
    if (error)
        ClearProtocolMembers(fields, count);
    return error;
}
int GHValidRepository(const char *name) {
    size_t i, start = 0;
    int slashes = 0;
    unsigned char c;
    if (!name || !*name || strlen(name) > 254)
        return 0;
    for (i = 0;; ++i) {
        c = (unsigned char)name[i];
        if (!c || c == '/') {
            if (i == start || (i - start == 1 && name[start] == '.') ||
                (i - start == 2 && name[start] == '.' && name[start + 1] == '.'))
                return 0;
            if(!c)return slashes==1;
            if(++slashes>1)return 0;
            start=i+1;
        } else if (!((c >= 'a' && c <= 'z') || (c >= 'A' && c <= 'Z') || (c >= '0' && c <= '9') ||
                     c == '_' || c == '-' || c == '.'))
            return 0;
    }
}
int GHURLEncode(const char *in,char *out,size_t cap) {
    const char *hex="0123456789ABCDEF";size_t used=0;unsigned char c;int safe;
    if(!in || !out || !cap)return -1;
    while((c=(unsigned char)*in++)!=0) {
        safe=(c>='a' && c<='z') || (c>='A' && c<='Z') || (c>='0' && c<='9') || strchr("-._~",c)!=NULL;
        if(used+(safe?1:3)>=cap){out[0]=0;return -1;}
        if(safe)out[used++]=(char)c;
        else {out[used++]='%';out[used++]=hex[c>>4];out[used++]=hex[c&15];}
    }
    out[used]=0;return 0;
}
int GHReadRepositories(const char *json,size_t length,GHRepository *out,int cap,int *count) {
    Parser p;int n,total=0,error=0,field,overflow=0;GHRepository *r;
    if(!out || cap<0 || !count)return -1;
    *count=0;if(!json || length>1048576UL)return -1;
    memset(&p,0,sizeof(p));p.s=json;p.length=length;White(&p);
    if(p.pos>=length || p.s[p.pos++]!='[')return -1;
    p.tokens=(Token*)calloc(GH_JSON_TOKENS,sizeof(Token));if(!p.tokens)return -1;
    White(&p);
    if(p.pos<length && p.s[p.pos]==']')++p.pos;
    else for(;;) {
        /* Reuse the bounded token arena for each object. GitHub's 50-row
           pages exceed the arena even though every individual record fits. */
        p.used=0;n=Value(&p,0);
        if(n<0 || p.tokens[n].type!='{'){error=-1;break;}
        if(total>=cap)overflow=1;
        else {
            r=out+total;memset(r,0,sizeof(*r));
            if(JSONGetString(&p,n,"full_name",r->fullName,sizeof(r->fullName),0) ||
               JSONGetString(&p,n,"name",r->name,sizeof(r->name),0) ||
               JSONGetString(&p,n,"default_branch",r->branch,sizeof(r->branch),0) ||
               JSONGetString(&p,n,"description",r->description,sizeof(r->description),1)<0 ||
               !GHValidRepository(r->fullName)) {error=-1;break;}
            field=Field(&p,n,"private");
            if(field<0 || (p.tokens[field].type!='t' && p.tokens[field].type!='f')){error=-1;break;}
            r->isPrivate=p.tokens[field].type=='t';++total;
        }
        White(&p);if(p.pos>=length){error=-1;break;}
        if(p.s[p.pos]==']'){++p.pos;break;}
        if(p.s[p.pos++]!=','){error=-1;break;}
    }
    White(&p);if(p.pos!=length)error=-1;
    if(!error && overflow)error=-2;
    free(p.tokens);*count=total;return error;
}
static int ValidSHA(const char *s) {
    int i;if(strlen(s)!=40)return 0;
    for(i=0;i<40;++i)if(Hex((unsigned char)s[i])<0)return 0;
    return 1;
}
int GHReadRevisions(const char *json,size_t length,GHRevision *out,int cap,int *count) {
    Parser p;int root,n,total=0,error=0,commit,author;char *cr;GHRevision *r;
    if(!out || cap<0 || !count)return -1;
    *count=0;root=Document(&p,json,length,'[');if(root<0)return -1;
    for(n=root+1;n<p.tokens[root].next;n=p.tokens[n].next) {
        if(total>=cap){error=-2;break;}
        r=out+total;memset(r,0,sizeof(*r));commit=Field(&p,n,"commit");author=Field(&p,commit,"author");
        if(JSONGetString(&p,n,"sha",r->sha,sizeof(r->sha),0) || !ValidSHA(r->sha) ||
           JSONGetString(&p,author,"name",r->author,sizeof(r->author),1)<0 ||
           JSONGetString(&p,author,"date",r->date,sizeof(r->date),1)) {error=-1;break;}
        /* Commit bodies can be arbitrarily long; only the subject is shown here. */
        if(JSONGetString(&p,commit,"message",r->summary,sizeof(r->summary),0)<0){error=-1;break;}
        cr=strchr(r->summary,'\r');if(cr)*cr=0;++total;
    }
    free(p.tokens);*count=total;return error;
}
static int Files(Parser *p,int root) {
    int n=Field(p,root,"files");return n>=0 && p->tokens[n].type=='[' ? n : -1;
}
int GHReadChanges(const char *json,size_t length,GHChange *out,int cap,int *count) {
    Parser p;int root,files,n,total=0,error=0;
    if(!out || cap<0 || !count)return -1;
    *count=0;root=Document(&p,json,length,'{');if(root<0)return -1;
    files=Files(&p,root);if(files<0){free(p.tokens);return -1;}
    for(n=files+1;n<p.tokens[files].next;n=p.tokens[n].next) {
        if(total>=cap){error=-2;break;}
        if(JSONGetString(&p,n,"filename",out[total].filename,sizeof(out[total].filename),0) ||
           JSONGetString(&p,n,"status",out[total].status,sizeof(out[total].status),0)) {error=-1;break;}
        ++total;
    }
    free(p.tokens);*count=total;return error;
}
int GHReadPatch(const char *json,size_t length,int index,char *out,size_t cap) {
    Parser p;int root,files,n,i=0,error=-1;
    if(!out || !cap || index<0)return -1;
    out[0]=0;root=Document(&p,json,length,'{');if(root<0)return -1;
    files=Files(&p,root);
    if(files>=0)for(n=files+1;n<p.tokens[files].next;n=p.tokens[n].next) {
        if(i++==index){error=JSONGetString(&p,n,"patch",out,cap,1);break;}
    }
    free(p.tokens);return error;
}
