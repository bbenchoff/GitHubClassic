/* Native local Changes/Commit controls. Included after the Toolbox helpers. */
static void LocalError(const char *operation, int result) {
    char message[256];
    snprintf(message, sizeof(message), "%s: error %d. Working files were not overwritten.",
             operation, result);
    SetStatus(message);
}
static void LocalEditState(void) {
    HiliteControl(gFetch, gLocal && !gLocalBlocked && !gBusy ? 0 : 255);
    HiliteControl(gCommit,
                  gLocal && !gLocalBlocked && !gTab && gLocalStaged && (*gSummaryEdit)->teLength > 0 ? 0 : 255);
}
static void LocalClose(void) {
    if (SettingsRelease()) {
        SetStatus("The ignore editor could not close its files. Try Refresh, or quit Classic Github.");
        return;
    }
    if (gCommitField)
        TEDeactivate(gCommitField == 1 ? gSummaryEdit : gDescriptionEdit);
    gCommitField = 0;
    EditReset();
    gLocal = 0;
    gLocalBlocked = 0;
    gMergePending = 0;
    gRebasePending = 0;
    LocalHistoryReset();
    GWClose(&gWork);
    free(gLocalRows);
    gLocalRows = NULL;
    gLocalRowCount = gLocalStaged = 0;
    HiliteControl(gCommit, 255);
    HiliteControl(gFetch, 255);
    gOriginName[0] = gOriginBranch[0] = 0;
    if (gUser[0])
        ShowControl(gBrowse);
    else
        ShowControl(gSignIn);
    HideDiffControls();
    gPatch[0] = 0;
}
static void LocalEditMenu(short item) {
    TEHandle edit = gCommitField == 1 ? gSummaryEdit : gDescriptionEdit;
    if (item == 3) {
        if (CopyTextSelection(edit)) TEDelete(edit);
    }
    if (item == 4) {
        CopyTextSelection(edit);
    }
    if (item == 5) {
        if (!TEFromScrap() && (*edit)->teLength - ((*edit)->selEnd - (*edit)->selStart) +
            GetHandleSize(TEScrapHandle()) < 8000)
            TEPaste(edit);
        else SysBeep(1);
    }
    if (item == 6)
        TESetSelect(0, 32767, edit);
    LocalEditState();
}
static void LocalRows(void) {
    size_t i;
    char message[256];
    LocalHistoryReset();
    free(gLocalRows);
    gLocalRows = NULL;
    gLocalRowCount = gLocalStaged = 0;
    gLocalSelection = -1;
    gLocalPage = 0;
    if (gWork.count)
        gLocalRows = (size_t *)malloc(gWork.count * sizeof(*gLocalRows));
    if (gWork.count && !gLocalRows) {
        LocalError("Read changes", GB_MEMORY);
        return;
    }
    for (i = 0; i < gWork.count; ++i)
        if (gWork.files[i].staged || gWork.files[i].unstaged) {
            if (gWork.files[i].staged)
                ++gLocalStaged;
            if (LocalMatches(gWork.files[i].path))
                gLocalRows[gLocalRowCount++] = i;
        }
    if (gLocalRowCount)
        LocalSelect(0);
    else {
        strcpy(gPatch,
               LocalFiltered() ? "No changes match the filter.\r" : "No uncommitted changes.\r");
        gDiffLines = 1;
        gDiffTop = 0;
        FindReset(); DiffScroll();
    }
    snprintf(message, sizeof(message),
             "%lu %s; %lu staged; %lu ignored entries hidden. Both forks are preserved.",
             (unsigned long)gLocalRowCount, LocalFiltered() ? "matching files" : "changed files",
             (unsigned long)gLocalStaged, (unsigned long)gWork.ignored);
    SetStatus(message);
    LocalEditState();
}
static void LocalRefresh(void) {
    int result;
    if (!gLocal)
        return;
    gMergePending = 0;
    gRebasePending = 0;
    SetStatus("Reading local changes...");
    LocalHistoryReset();
    result = CheckoutRelease();
    if (!result)
        result = GWRefresh(&gWork);
    if (result == GC_RECOVERY) {
        gLocalBlocked = 1;
        gLocalRowCount = gLocalStaged = 0;
        gLocalSelection = -1;
        gLocalHistoryCount = 0;
        strcpy(gPatch, "This repository needs checkout recovery.\rChoose Repository > Refresh to finish or restore.\r");
        gDiffTop = 0; gDiffLines = 2; FindReset(); DiffScroll();
        LocalEditState();
        if (!CheckoutRecovery(&gWork.folder))
            return;
        result = GWRefresh(&gWork);
    }
    if (result == GT_MERGE_ACTIVE) {
        gMergePending=1;gLocalBlocked=1;
        if(!MergeManage(&gWork.folder)){MergePaused();return;}
        gMergePending=0;result=GWRefresh(&gWork);
    }
    if(result==GT_REBASE_ACTIVE) {
        gRebasePending=gLocalBlocked=1;
        if(!RebaseManage(&gWork.folder)){RebasePaused();return;}
        gRebasePending=0;result=GWRefresh(&gWork);
    }
    if (result) {
        gLocalBlocked = 1;
        gLocalRowCount = gLocalStaged = 0;
        gLocalHistoryCount = 0;
        gLocalSelection = -1;
        strcpy(gPatch, "The repository could not be refreshed.\rChoose Repository > Refresh before continuing.\r");
        gDiffTop = 0; gDiffLines = 2; FindReset(); DiffScroll();
        LocalEditState();
        LocalError("Refresh", result);
        return;
    }
    gLocalBlocked = 0;
    ShowDiffControls();
    if (gTab)
        LocalHistoryLoad();
    else
        LocalRows();
    LocalEditState();
}
static void LocalOpenSpec(const FSSpec *folder, int create) {
    int result;
    unsigned char *identity;
    size_t n;
    result = CheckoutRelease();
    if (result) {
        SetStatus("The previous checkout could not be closed. Refresh or try opening again.");
        Message("Open Repository", "The previous checkout could not be closed. Keep its repository folder intact and try again.");
        return;
    }
    LocalHistoryReset();
    result = GWOpen(&gWork, folder, create);
    if (result == GC_RECOVERY) {
        if (gLocal && folder->vRefNum == gWork.folder.vRefNum &&
            folder->parID == gWork.folder.parID &&
            !RelString(folder->name, gWork.folder.name, false, true)) {
            gLocalBlocked = 1;
            gLocalRowCount = gLocalStaged = 0;
            gLocalHistoryCount = 0;
            gLocalSelection = -1;
            strcpy(gPatch, "This repository needs checkout recovery.\rChoose Repository > Refresh to finish or restore.\r");
            gDiffTop = 0; gDiffLines = 2; FindReset(); DiffScroll();
            LocalEditState();
        }
        if (!CheckoutRecovery(folder))
            return;
        result = GWOpen(&gWork, folder, create);
    }
    if(result==GT_MERGE_ACTIVE || result==GT_REBASE_ACTIVE) {
        int replay=result==GT_REBASE_ACTIVE;
        int same=gLocal && folder->vRefNum==gWork.folder.vRefNum && folder->parID==gWork.folder.parID &&
            !RelString(folder->name,gWork.folder.name,false,true);
        if(!(replay?RebaseManage(folder):MergeManage(folder))) {
            if(same){if(replay)RebasePaused();else MergePaused();}
            else if(gLocal && !gMergePending && !gRebasePending)LocalRefresh();
            else SetStatus(replay?"The selected repository's rebase remains saved. Open its folder to resume.":"The selected repository's merge remains saved. Open its folder to resume.");
            return;
        }
        result=GWOpen(&gWork,folder,create);
    }
    if (result) {
        LocalError("Open repository", result);
        Message("Open Repository",
                result == GS_NOT_FOUND
                    ? "No repository was found in this folder. Choose a repository, or use File > "
                      "New Repository to create one."
                    : "This repository could not be opened. Its format may be unsupported or the "
                      "disk may be unavailable. Your files were not changed.");
        return;
    }
    if (gCommitField)
        TEDeactivate(gCommitField == 1 ? gSummaryEdit : gDescriptionEdit);
    ClearRemote();
    gLocal = 1;
    gLocalBlocked = 0;
    gMergePending = 0;
    gRebasePending = 0;
    gTab = 0;
    gCommitField = 0;
    HideControl(gSignIn);
    HideControl(gBrowse);
    ShowDiffControls();
    TESetText("", 0, gSummaryEdit);
    TESetText("", 0, gDescriptionEdit);
    EditReset();
    LocalFilterReset();
    gLocalIdentity[0] = 0;
    result = gWork.repository.read(gWork.repository.context, "identity", &identity, &n);
    if (!result) {
        if (n < sizeof(gLocalIdentity) && !memchr(identity, 0, n)) {
            memcpy(gLocalIdentity, identity, n);
            gLocalIdentity[n] = 0;
        }
        free(identity);
    }
    NetworkHeader();
    LocalRows();
    SetPort(gWindow);
    InvalRect(&gWindow->portRect);
    RecentRemember(folder);
}
static void LocalOpenMode(int mode) {
    FSSpec folder;
    if (ChooseLocalFolder(mode > 0, &folder))
        LocalOpenSpec(&folder, mode > 0);
}
static void LocalOpen(void) { LocalOpenMode(0); }
static int LocalAllStaged(void) {
    size_t i;
    if (!gLocalRowCount) return 0;
    for (i = 0; i < gLocalRowCount; ++i)
        if (!gWork.files[gLocalRows[i]].staged || gWork.files[gLocalRows[i]].unstaged) return 0;
    return 1;
}
static int LocalStageProgress(void *unused) {
    EventRecord e;
    (void)unused;
    while (GetNextEvent(everyEvent, &e)) {
        if (e.what == updateEvt && (WindowPtr)e.message == gWindow) {
            BeginUpdate(gWindow); Draw(); EndUpdate(gWindow);
        } else if (e.what == kHighLevelEvent) AEProcessAppleEvent(&e);
        else if (e.what == keyDown && (e.message & charCodeMask) == 27) return GS_IO;
    }
    return gDone ? GS_IO : 0;
}
static void LocalToggleAll(void) {
    int result, stage;
    if (gBusy || gLocalBlocked || !gLocalRowCount) return;
    stage = !LocalAllStaged(); gBusy = 1;
    SetStatus(stage ? "Staging the displayed files... Escape cancels before saving the index."
                    : "Unstaging the displayed files... Escape cancels before saving the index.");
    result = GWStageSet(&gWork, gLocalRows, gLocalRowCount, stage, LocalStageProgress, NULL);
    gBusy = 0;
    if (result) { LocalRefresh(); LocalError("Stage displayed files", result); }
    else LocalRows();
    InvalRect(&gWindow->portRect);
}

static void LocalToggle(void) {
    int result;
    size_t index;
    if (gLocalBlocked || gLocalSelection < 0 || (size_t)gLocalSelection >= gLocalRowCount)
        return;
    index = gLocalRows[gLocalSelection];
    result = gWork.files[index].staged ? GWUnstage(&gWork, index) : GWStage(&gWork, index);
    if (result == GC_RECOVERY) { LocalRefresh(); return; }
    if (result) {
        LocalError("Stage change", result);
        return;
    }
    LocalRows();
}
static void LocalAppend(const char *text) {
    size_t have = strlen(gPatch), n = strlen(text);
    if (n >= sizeof(gPatch) - have) {
        n = sizeof(gPatch) - have - 1;
        gPatchTruncated = 1;
    }
    memcpy(gPatch + have, text, n);
    gPatch[have + n] = 0;
}
static void LocalDisplayPath(const char *text, char output[256]) {
    const unsigned char *p = (const unsigned char *)text;
    size_t n = 0, i;
    unsigned u;
    while (*p && n < 255) {
        u = *p++;
        if (u >= 194 && u < 224 && p[0] && (p[0] & 192) == 128) {
            u = ((u & 31) << 6) | (p[0] & 63);
            ++p;
        } else if (u >= 224 && u < 240 && p[0] && p[1] && (p[0] & 192) == 128 &&
                   (p[1] & 192) == 128) {
            u = ((u & 15) << 12) | ((p[0] & 63) << 6) | (p[1] & 63);
            p += 2;
        } else if (u >= 128)
            u = '?';
        if (u < 128)
            output[n++] = (char)u;
        else {
            i = (size_t)GPRomanCharacter(u);
            output[n++] = i < 256 ? (char)i : '?';
        }
    }
    output[n] = 0;
}
static int LocalPreviewProgress(void *context) {
    (void)context; return Pump(NULL) ? -99 : 0;
}
static void LocalSelect(int row) {
    GWFile *file;
    GDFile before, after;
    GDResult diff;
    unsigned char *workingResource = NULL;
    int result = 0;
    char message[256];
    if (gLocalBlocked || row < 0 || (size_t)row >= gLocalRowCount) return;
    file = gWork.files + gLocalRows[row];
    if (gLocalSelection != row) gLocalDiffMode = file->unstaged ? 1 : 0;
    gLocalSelection = row; FindReset();
    GDFileInit(&before); GDFileInit(&after);
    gPatch[0] = 0; gPatchTruncated = 0; gDiffTop = 0;
    gBusy = 1; gCancel = 0;
    result = GDReadFile(&gWork.repository, gLocalDiffMode ? &gWork.index : &gWork.head,
                        file->path, &before);
    if (!result && !gLocalDiffMode)
        result = GDReadFile(&gWork.repository, &gWork.index, file->path, &after);
    else if (!result && file->exists) {
        after.exists = 1;
        result = GWReadFileLimit(&file->file, &after.data, &after.dataLength, after.finderInfo,
                                 &workingResource, &after.resourceLength, 2UL * 1024UL * 1024UL);
        after.resource = workingResource;
        if (!result) result = GPWorkPolicy(GPFind(&gWork.mapping, file->path),
                              GIFind(&gWork.index, file->path, 0), after.finderInfo,
                              after.resourceLength, &after.mode, &after.hasFinderInfo);
    }
    if (!result) result = GDPreview(&before, &after, '\r', gPatch, sizeof(gPatch),
                                    LocalPreviewProgress, NULL, &diff);
    GDFileFree(&before); GDFileFree(&after); free(workingResource);
    gBusy = 0;
    if (result) {
        strcpy(gPatch, result == -99 ? "Diff preview cancelled.\rSelect the file again to retry.\r"
                                   : "This comparison could not be displayed.\rFiles and staged content were not changed.\r");
        if (result == GB_SPACE)
            LocalAppend("Preview limit: 2 MB and 8192 lines per data fork.\r");
        LocalError("Preview", result);
    } else {
        gPatchTruncated = diff.truncated;
        snprintf(message, sizeof(message), "%s: +%lu -%lu lines%s. Preview does not change the index or working files.",
                 gLocalDiffMode ? "Unstaged (index to working)" : "Staged (HEAD to index)",
                 (unsigned long)diff.added, (unsigned long)diff.removed,
                 diff.coarse ? "; coarse replacement" : "");
        SetStatus(message);
    }
    DiffScroll(); InvalRect(&gWindow->portRect);
}
static pascal Boolean LocalAuthorFilter(DialogPtr d,EventRecord *event,short *hit) {
    Handle item,button;short kind,enabledKind;Rect r;Str255 p;char identity[256];int valid;
    GetDialogItem(d,4,&kind,&item,&r);GetDialogItemText(item,p);
    memcpy(identity,p+1,p[0]);identity[p[0]]=0;valid=GSValidIdentity(identity);
    GetDialogItem(d,1,&kind,&button,&r);
    enabledKind=(short)((kind&127)|(valid?0:128));
    if(enabledKind!=kind)SetDialogItem(d,1,enabledKind,button,&r);
    if((**(ControlHandle)button).contrlHilite!=(valid?0:255))HiliteControl((ControlHandle)button,valid?0:255);
    if(event && (event->what==keyDown || event->what==autoKey) &&
       !(event->modifiers&cmdKey) &&
       ((event->message&charCodeMask)==13 || (event->message&charCodeMask)==3) && !valid) {
        *hit=0;SysBeep(1);return true;
    }
    return event?NativeDialogFilter(d,event,hit):false;
}
static int LocalAuthor(int editing) {
    DialogPtr dialog;
    Handle item;
    short hit = 0, kind;
    Rect r;
    Str255 text;
    char nextIdentity[256];
    unsigned char *old = NULL;
    size_t n = 0;
    int result;
    ModalFilterUPP filter;
    if (gLocalIdentity[0] && !editing)
        return 1;
    dialog = GetNewDialog(133, NULL, (WindowPtr)-1);
    if (!dialog)
        return 0;
    filter=NewModalFilterProc(LocalAuthorFilter);
    if(!filter){DisposeDialog(dialog);SetPort(gWindow);return 0;}
    PrepareDialogChrome(dialog,7,8);
    GetDialogItem(dialog, 4, &kind, &item, &r);
    Pascal(gLocalIdentity, text);
    SetDialogItemText(item, text);
    SelectDialogItemText(dialog, 4, 0, 32767);
    LocalAuthorFilter(dialog,NULL,NULL);
    PrepareDialog(dialog, 1, 2);
    while (hit != 1 && hit != 2)
        RunModalDialog(filter, &hit);
    GetDialogItemText(item, text);
    DisposeDialog(dialog);
    DisposeRoutineDescriptor((UniversalProcPtr)filter);SetPort(gWindow);
    if (hit == 2 || !text[0])
        return 0;
    memcpy(nextIdentity, text + 1, text[0]);
    nextIdentity[text[0]] = 0;
    if (!GSValidIdentity(nextIdentity)) {
        SetStatus("Enter an author as Name <email>.");
        return 0;
    }
    result = gWork.repository.read(gWork.repository.context, "identity", &old, &n);
    if (result && result != GS_NOT_FOUND) {
        LocalError("Save author", result);
        return 0;
    }
    result = gWork.repository.replace(gWork.repository.context, "identity", old, n, nextIdentity,
                                      strlen(nextIdentity));
    free(old);
    if (result) {
        LocalError("Save author", result);
        return 0;
    }
    strcpy(gLocalIdentity, nextIdentity);
    return 1;
}
static void LocalCommit(void) {
    char *message, seconds[32], status[256], hex[41];
    size_t summary, description, i, n;
    unsigned long macTime;
    long delta;
    MachineLocation location;
    unsigned char oid[20];
    int result;
    if (!gLocal || gLocalBlocked || !gLocalStaged || !(summary = (size_t)(*gSummaryEdit)->teLength))
        return;
    if (!LocalAuthor(0))
        return;
    description = (size_t)(*gDescriptionEdit)->teLength;
    n = summary + description + 3;
    message = (char *)malloc(n);
    if (!message) {
        LocalError("Commit", GB_MEMORY);
        return;
    }
    memcpy(message, *(*gSummaryEdit)->hText, summary);
    n = summary;
    if (description) {
        message[n++] = '\n';
        message[n++] = '\n';
        memcpy(message + n, *(*gDescriptionEdit)->hText, description);
        n += description;
    }
    message[n] = 0;
    for (i = 0; i < n; ++i)
        if (message[i] == '\r')
            message[i] = '\n';
    GetDateTime(&macTime);
    ReadLocation(&location);
    delta = location.u.gmtDelta & 0x00ffffffL;
    if (delta & 0x00800000L)
        delta |= 0xff000000L;
    snprintf(seconds, sizeof(seconds), "%lu", macTime - delta - 2082844800UL);
    result = GWCommit(&gWork, gLocalIdentity, gLocalIdentity, seconds, "+0000", message, oid);
    free(message);
    if (result == GC_RECOVERY) { LocalRefresh(); return; }
    if (result) {
        LocalError("Commit", result);
        return;
    }
    TESetText("", 0, gSummaryEdit);
    TESetText("", 0, gDescriptionEdit);
    EditReset();
    LocalRows();
    GBOIDFormat(oid, hex);
    snprintf(status, sizeof(status),
             "Committed %.7s on %s. Working files and both forks preserved.", hex,
             gWork.branch + 11);
    SetStatus(status);
}
static void LocalDraw(void) {
    Rect rect;
    size_t i, row;
    short y;
    char name[64], detail[256], displayPath[256];
    GWFile *file;
    SetPort(gWindow);
    Box(0, 0, gUI.width, gUI.height, 221, 221, 221);
    Bevel(5, 5, 237, 57, 0);
    Bevel(241, 5, RightEdge(577), 57, 0);
    Bevel(RightEdge(581), 5, RightEdge(795), 57, 0);
    Icon(256, 18, 27);
    Icon(257, 252, 27);
    Icon(260, RightEdge(588), 20);
    memcpy(name, gWork.folder.name + 1, gWork.folder.name[0]);
    name[gWork.folder.name[0]] = 0;
    Text(44, 22, "Current Repository:", gGeneva, 9, 64, 64, 64);
    FitText(44, 43, name, gChicago, 12, 182, 0, 0, 0);
    Text(278, 22, "Current Branch:", gGeneva, 9, 64, 64, 64);
    if (gWork.branch && strlen(gWork.branch) > 11)
        LocalDisplayPath(gWork.branch + 11, displayPath);
    else
        strcpy(displayPath, "Unknown branch");
    FitText(278, 43, gBusy ? "Working..." : gRebasePending ? "Rebase paused" : gMergePending ? "Review paused" : gLocalBlocked ? "Refresh needed" : displayPath, gChicago, 12, RightEdge(280), 0, 0, 0);
    FitText(RightEdge(620), 52, gOriginName[0] ? gOriginName : "No origin configured", gGeneva, 9, 170, 96, 96, 96);
    Bevel(8, 65, 119, 94, gTab ? 0 : 1);
    Bevel(122, 65, 232, 94, gTab ? 1 : 0);
    Icon(265, 16, 72);
    Icon(264, 132, 72);
    Text(38, 84, "Changes", gChicago, 12, 0, 0, 0);
    Text(154, 84, "History", gChicago, 12, 0, 0, 0);
    Box(8, 98, 232, gUI.listBottom, 255, 255, 255);
    Bevel(7, 97, 233, gUI.listBottom+1, 1);
    Box(10, 100, 230, 125, 238, 238, 238);
    if(gTab && BCUIActive())BCUIDrawToolbar();else {
    if (gTab) Text(17, 117, "Local History", gChicago, 12, 0, 0, 0);
    else {
        SetRect(&rect, 16, 106, 27, 117); Color(0, 0, 0); FrameRect(&rect);
        if (LocalAllStaged()) Text(17, 116, "x", gGeneva, 9, 0, 0, 0);
        Text(34, 117, "Changed Files", gChicago, 12, 0, 0, 0);
    }
    if (!gTab || gLocalHistoryPage > 1 || gLocalHistoryOffset > 0) {
        Bevel(190, 101, 209, 123, 0); Text(196, 116, "<", gGeneva, 9, 0, 0, 0);
    }
    if (!gTab || LocalHistoryHasNext()) {
        Bevel(211, 101, 230, 123, 0); Text(217, 116, ">", gGeneva, 9, 0, 0, 0);
    }
    }
    if (gTab) {
        if(BCUIActive())BCUIDrawRows();else LocalHistoryRows();
    }
    else
        for (i = 0; i < gUI.rows; ++i) {
            row = (size_t)gLocalPage * gUI.rows + i;
            if (row >= gLocalRowCount)
                break;
            file = gWork.files + gLocalRows[row];
            y = (short)(148 + i * 28);
            if ((int)row == gLocalSelection)
                Box(10, y - 14, 230, y + 13, 225, 217, 240);
            if(gMonochrome) {
                SetRect(&rect,16,y-10,27,y+1);Color(0,0,0);FrameRect(&rect);
            }else Bevel(16, y - 10, 27, y + 1, 1);
            if (file->staged)
                Text(17, y, "x", gGeneva, 9, 0, 0, 0);
            LocalDisplayPath(file->path, displayPath);
            FitText(34, y, displayPath, gGeneva, 9, 192, 0, 0, 0);
            snprintf(detail, sizeof(detail), "%s%s",
                     file->untracked ? "New file"
                     : file->deleted ? "Deleted"
                     : file->staged  ? "Staged"
                                     : "Modified",
                     file->staged && file->unstaged ? " + unstaged edits" : "");
            Text(34, y + 11, detail, gGeneva, 9, 96, 96, 96);
        }
    if (!gTab && !gLocalRowCount)
        Text(18, 151, gLocalBlocked ? "Refresh required" : LocalFiltered() ? "No matching changes" : "No changes", gGeneva, 9, 96, 96,
             96);
    FitText(16, gUI.authorY, gLocalIdentity[0] ? gLocalIdentity : "Set an author for new commits",
            gGeneva, 9, 208, 64, 64, 64);
    Text(16, gUI.summaryLabel, "Summary:", gGeneva, 9, 0, 0, 0);
    Box(16, gUI.summaryTop, 223, gUI.summaryTop+22, 255, 255, 255);
    Bevel(14, gUI.summaryTop-2, 225, gUI.summaryTop+24, 1);
    Text(16, gUI.descriptionLabel, "Description:", gGeneva, 9, 0, 0, 0);
    Box(16, gUI.descriptionTop, 223, gUI.descriptionTop+22, 255, 255, 255);
    Bevel(14, gUI.descriptionTop-2, 225, gUI.descriptionTop+24, 1);
    Color(0, 0, 0);
    SetRect(&rect, 20, gUI.summaryTop+3, 220, gUI.summaryTop+20);
    TEUpdate(&rect, gSummaryEdit);
    SetRect(&rect, 20, gUI.descriptionTop+3, 220, gUI.descriptionTop+20);
    TEUpdate(&rect, gDescriptionEdit);
    Box(243, 67, RightEdge(792), BottomEdge(470), 255, 255, 255);
    Bevel(241, 65, RightEdge(794), BottomEdge(472), 1);
    Box(245, 69, RightEdge(790), 94, 82, 45, 128);
    if (gTab) {if(BCUIActive())BCUIDrawHeader();else LocalHistoryHeader();}
    else Text(255, 86, gLocalDiffMode ? "Unstaged Changes" : "Staged Changes", gChicago, 12, 255, 255, 255);
    if (!gTab && gLocalSelection >= 0 && (size_t)gLocalSelection < gLocalRowCount) {
        file = gWork.files + gLocalRows[gLocalSelection];
        LocalDisplayPath(file->path, displayPath);
        FitText(255, 113, displayPath, gChicago, 12, RightEdge(525), 0, 0, 0);
        Box(255, 119, 405, 144, gLocalDiffMode ? 238 : 39, gLocalDiffMode ? 238 : 97, gLocalDiffMode ? 238 : 169);
        Box(415, 119, 575, 144, gLocalDiffMode ? 39 : 238, gLocalDiffMode ? 97 : 238, gLocalDiffMode ? 169 : 238);
        Bevel(255, 119, 405, 144, !gLocalDiffMode);
        Bevel(415, 119, 575, 144, gLocalDiffMode);
        Text(265, 136, "Staged changes", gChicago, 12, gLocalDiffMode ? 48 : 255, gLocalDiffMode ? 48 : 255, gLocalDiffMode ? 48 : 255);
        Text(425, 136, "Unstaged changes", gChicago, 12, gLocalDiffMode ? 255 : 48, gLocalDiffMode ? 255 : 48, gLocalDiffMode ? 255 : 48);
    }
    DrawDiff();
    if (gPatchTruncated)
        Text(255, BottomEdge(464), "Preview truncated at 32 KB.", gGeneva, 9, 128, 0, 0);
    Bevel(5, BottomEdge(479), RightEdge(779), BottomEdge(498), 1);
    FitText(10, BottomEdge(492), gStatus, gGeneva, 9, gUI.width-36, 0, 0, 0);
    Color(0, 0, 0);
    DrawControls(gWindow);WindowChrome();
}
