/* Included by GitRebaseLifecycle.c. Uses the same guarded checkout values as
   merge sessions, with separate replay identity and original HEAD semantics. */
#include "GitRebaseTransitions.h"
typedef struct {
    GSRepository *source;const RKState *state;MSBytes ref;char key[64];
} RLView;
static int RLViewRead(void *context,const char *key,unsigned char **p,size_t *n) {
    RLView *v=context;const MSBytes *b=NULL;
    if(!strcmp(key,v->key))b=&v->ref;
    else if(!strcmp(key,"HEAD"))b=v->state->replay.before;
    else if(!strcmp(key,"index"))b=&v->state->workIndex;
    else if(!strcmp(key,"ghclient-map"))b=&v->state->mapping;
    if(!b)return v->source->read(v->source->context,key,p,n);
    *p=NULL;*n=0;if(!b->present)return GS_NOT_FOUND;
    *p=WXCopy(b->bytes,b->length);if(!*p)return GB_MEMORY;*n=b->length;return 0;
}
static int RLViewReplace(void *context,const char *key,const void *a,size_t an,const void *b,size_t bn) {
    RLView *v=context;
    if(strncmp(key,"objects/",8) || a || an)return GS_FORMAT;
    return v->source->replace(v->source->context,key,NULL,0,b,bn);
}
static int RLViewStart(GSRepository *source,const RKState *s,RLView *v,GSRepository *r) {
    char hex[41];int result;memset(v,0,sizeof(*v));v->source=source;v->state=s;
    result=GSRefKey(s->replay.branch,v->key);
    if(!result)result=WXBytesSet(&v->ref,s->replay.before[1].bytes,s->replay.before[1].length,1);
    if(!result) {
        GBOIDFormat(s->workspace,hex);memcpy(v->ref.bytes+strlen(s->replay.branch)+1,hex,40);
        r->context=v;r->read=RLViewRead;r->replace=RLViewReplace;
    }
    return result;
}
static int RLBinding(GPEqual eq,void *ctx,const GPMap *map,const char *native,const char *path,GQError *why) {
    char *logical=NULL;size_t n;int result=GPResolve(map,native,eq,ctx,&logical);
    if(!result && strcmp(logical,path))result=GS_CONFLICT;
    free(logical);
    if(result && why) {
        why->reason=GQ_INVENTORY;n=strlen(path);if(n>=sizeof(why->path))n=sizeof(why->path)-1;
        memcpy(why->path,path,n);why->path[n]=0;
    }
    return result;
}
static int RLAbortBindings(const GQPlan *p,const GPMap *original,const GQWork *work,size_t count,GPEqual eq,void *ctx,GQError *why) {
    size_t i,j;const GCOperation *op;const GPEntry *entry;int result=0;
    for(i=0;!result && i<count;++i) {
        if(work[i].file.present!=1)continue;
        for(j=0;j<p->transaction.fileCount;++j)if(p->transaction.files[j].oldPath && !strcmp(work[i].native,p->transaction.files[j].oldPath))break;
        if(j==p->transaction.fileCount)result=RLBinding(eq,ctx,original,work[i].native,work[i].path,why);
    }
    for(i=0;!result && i<p->transaction.fileCount;++i) {
        op=p->transaction.files+i;if(!op->newFile.present)continue;
        entry=NULL;
        for(j=0;j<p->mapping.count;++j)if(!strcmp(p->mapping.entries[j].native,op->newPath)){entry=p->mapping.entries+j;break;}
        if(!entry)result=GS_FORMAT;
        else result=RLBinding(eq,ctx,original,op->newPath,entry->path,why);
    }
    return result;
}
int RLAbort(GSRepository *source,const void *expected,size_t length,const RLLimits *limits,const unsigned char binding[32],
    const GQWork *work,size_t count,GPEqual eq,void *eqCtx,GDProgress fn,void *ctx,RLPlan *out,GQError *why) {
    RLSession *old;RLPlan *next;RLIO io;RLView view;GSRepository r,virtualRepo;MSBytes incoming;GIIndex original;GPMap mapping;
    GQProtection protection;unsigned char *bytes=NULL;size_t n=0;GBWord generation=0;char incomingKey[64],branchKey[64];int result;
    if(!expected || !length || !limits || !binding || !out || !eq || (count && !work))return GB_BAD;
    if(why)memset(why,0,sizeof(*why));old=(RLSession *)calloc(1,sizeof(*old));next=(RLPlan *)calloc(1,sizeof(*next));
    if(!old || !next){free(old);free(next);return GB_MEMORY;}memset(&view,0,sizeof(view));memset(&incoming,0,sizeof(incoming));GIInit(&original);GPInit(&mapping);
    result=RLIOStart(source,limits,fn,ctx,&io,&r);if(!result)result=RLOpen(&r,limits,binding,eq,eqCtx,fn,ctx,old);
    if(!result && (length!=old->state.originalLength || memcmp(expected,old->state.original,length)))result=GS_CONFLICT;
    if(!result)result=RLLive(&r,&old->state,&generation);
    if(!result)result=GSRefKey(old->state.replay.ontoRef,incomingKey);
    if(!result)result=WXTake(&r,incomingKey,&incoming);
    if(!result)result=WXRefShape(&incoming,old->state.replay.ontoRef);
    if(!result)result=GIParse(old->state.replay.before[2].bytes,old->state.replay.before[2].length,&original);
    if(!result && old->state.replay.before[3].present)result=GPParse(old->state.replay.before[3].bytes,old->state.replay.before[3].length,eq,eqCtx,&mapping);
    protection.paths=(const char *const *)old->state.affected;protection.count=old->state.affectedCount;protection.changed=0;
    if(!result)result=RLViewStart(&r,&old->state,&view,&virtualRepo);
    if(!result)result=GQToCommitRestored(&virtualRepo,old->state.replay.branch,old->state.workspace,old->state.replay.head,
        work,count,&protection,&mapping,eq,eqCtx,&next->checkout,why);
    if(!result && !WXIndexSame(&next->checkout.index,&original))result=GS_CONFLICT;
    if(!result)result=RLAbortBindings(&next->checkout,&mapping,work,count,eq,eqCtx,why);
    if(!result)result=GSRefKey(old->state.replay.branch,branchKey);
    if(!result)result=WXMetaSet(&next->checkout.transaction,"HEAD",old->state.replay.before[0].bytes,old->state.replay.before[0].length,1,
        old->state.replay.before[0].bytes,old->state.replay.before[0].length,1);
    if(!result)result=WXMetaSet(&next->checkout.transaction,branchKey,old->state.replay.before[1].bytes,old->state.replay.before[1].length,1,
        old->state.replay.before[1].bytes,old->state.replay.before[1].length,1);
    if(!result)result=WXMetaSet(&next->checkout.transaction,"index",old->state.index.bytes,old->state.index.length,1,
        old->state.replay.before[2].bytes,old->state.replay.before[2].length,old->state.replay.before[2].present);
    if(!result)result=WXMetaSet(&next->checkout.transaction,"ghclient-map",old->state.mapping.bytes,old->state.mapping.length,1,
        old->state.replay.before[3].bytes,old->state.replay.before[3].length,old->state.replay.before[3].present);
    if(!result)result=WXMetaSet(&next->checkout.transaction,incomingKey,incoming.bytes,incoming.length,incoming.present,incoming.bytes,incoming.length,incoming.present);
    if(!result)result=WXMetaSet(&next->checkout.transaction,"ghclient-rebase",old->state.original,old->state.originalLength,1,NULL,0,0);
    next->checkout.transaction.generation=generation;next->exitAction=2;
    if(!result)result=GCEncode(&next->checkout.transaction,eq,eqCtx,&bytes,&n);if(!result && n>limits->journalBytes)result=GB_SPACE;
    if(!result)result=RLLive(&r,&old->state,&generation);if(!result)result=WXMatch(&r,incomingKey,&incoming);if(!result)result=RLTick(&io);
    if(!result){memcpy(next->tree,old->replay.original.tree,20);next->state=old->state;RKInit(&old->state);RLFree(out);*out=*next;RLInit(next);}
    free(bytes);free(view.ref.bytes);free(incoming.bytes);GIFree(&original);GPFree(&mapping);RLSessionFree(old);RLFree(next);free(old);free(next);return result;
}
int RLAbortStart(GSRepository *r,GCBackend *b,GTControl *c,const unsigned char binding[32],GPEqual eq,void *ctx,const RLPlan *p) {
    const GCMetadata *m;
    if(!p || !binding || memcmp(binding,p->state.replay.binding,32) || !p->state.original || !p->state.replay.revision ||
        p->state.replay.revision>=p->checkout.transaction.generation || p->unresolved || p->exitAction!=2)return GS_CONFLICT;
    m=WXMeta(&p->checkout.transaction,"ghclient-rebase");
    if(!m || !m->beforePresent || m->afterPresent || m->beforeLength!=p->state.originalLength || memcmp(m->before,p->state.original,m->beforeLength))return GS_CONFLICT;
    return GTStartAtGeneration(r,b,c,binding,eq,ctx,p->checkout.transaction.generation,&p->checkout.transaction);
}
