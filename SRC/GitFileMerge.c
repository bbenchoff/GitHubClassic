#include "GitFileMerge.h"
#include <stdlib.h>
#include <string.h>

void FMInit(FMResult *r) { memset(r, 0, sizeof(*r)); }
void FMFree(FMResult *r) { GMTextFree(&r->data); free(r->resource); FMInit(r); }
static int FMKind(GBWord mode) { return (int)(mode & 0170000); }
static int FMEqualBytes(const void *a, size_t an, const void *b, size_t bn) {
    return an == bn && (!an || !memcmp(a, b, an));
}
static int FMValid(const FMVersion *v) {
    size_t i;
    if (!v) return 1;
    if ((v->mode != 0100644 && v->mode != 0100755 && v->mode != 0120000 && v->mode != 0160000) ||
        v->dataLength > 2UL * 1024 * 1024 || v->resourceLength > 2UL * 1024 * 1024 ||
        (!v->data && v->dataLength) || (!v->resource && v->resourceLength) ||
        (v->hasFinderInfo != 0 && v->hasFinderInfo != 1) ||
        (!v->hasFinderInfo && v->resourceLength) ||
        (FMKind(v->mode) != 0100000 && v->hasFinderInfo)) return 0;
    if (v->mode == 0160000) {
        if (v->dataLength) return 0;
        for (i = 0; i < 20 && !v->gitlink[i]; ++i) { }
        if (i == 20) return 0;
    }
    return 1;
}
static int FMMetaEqual(const FMVersion *a, const FMVersion *b) {
    int ah = a && a->hasFinderInfo, bh = b && b->hasFinderInfo;
    if (ah != bh) return 0;
    return !ah || (!memcmp(a->finderInfo, b->finderInfo, 32) &&
        FMEqualBytes(a->resource, a->resourceLength, b->resource, b->resourceLength));
}
static int FMEqual(const FMVersion *a, const FMVersion *b) {
    if (!a || !b) return !a && !b;
    if (a->mode != b->mode || !FMMetaEqual(a, b)) return 0;
    return a->mode == 0160000 ? !memcmp(a->gitlink, b->gitlink, 20) :
        FMEqualBytes(a->data, a->dataLength, b->data, b->dataLength);
}
static int FMCopyResource(FMResult *r, const FMVersion *v, const FMLimits *limits) {
    if (!v || !v->resourceLength) return 0;
    if (v->resourceLength > limits->resourceBytes) return GB_SPACE;
    r->resource = (unsigned char *)malloc(v->resourceLength);
    if (!r->resource) return GB_MEMORY;
    memcpy(r->resource, v->resource, v->resourceLength); r->resourceLength = v->resourceLength;
    return 0;
}
static int FMCopyMeta(FMResult *r, const FMVersion *v, const FMLimits *limits) {
    if (!v || !v->hasFinderInfo) return 0;
    r->hasFinderInfo = 1; memcpy(r->finderInfo, v->finderInfo, 32);
    return FMCopyResource(r, v, limits);
}
static int FMCopyData(FMResult *r, const FMVersion *v, char newline,
                         const FMLimits *limits, GDProgress progress, void *context) {
    return GMTextMerge(NULL, 0, v->data, v->dataLength, NULL, 0, newline,
                         &limits->text, progress, context, &r->data);
}
static int FMCopy(FMResult *r, const FMVersion *v, char newline,
                     const FMLimits *limits, GDProgress progress, void *context) {
    int error;
    if (!v) return 0;
    r->present = 1; r->mode = v->mode;
    if (v->mode == 0160000) { memcpy(r->gitlink, v->gitlink, 20); return 0; }
    error = FMCopyData(r, v, newline, limits, progress, context);
    if (!error) error = FMCopyMeta(r, v, limits);
    return error;
}
static int FMMergeMeta(FMResult *r, const FMVersion *b, const FMVersion *c,
                          const FMVersion *o, const FMLimits *limits) {
    const FMVersion *selected;
    const void *br = b ? b->resource : NULL;
    size_t bn = b ? b->resourceLength : 0;
    if (FMMetaEqual(c, o) || FMMetaEqual(b, o)) return FMCopyMeta(r, c, limits);
    if (FMMetaEqual(b, c)) return FMCopyMeta(r, o, limits);
    if (!c->hasFinderInfo || !o->hasFinderInfo) {
        r->conflicts |= FM_METADATA; r->hasFinderInfo = -1; return 0;
    }
    r->hasFinderInfo = 1;
    if (!memcmp(c->finderInfo, o->finderInfo, 32) ||
        (b && b->hasFinderInfo && !memcmp(b->finderInfo, o->finderInfo, 32)))
        memcpy(r->finderInfo, c->finderInfo, 32);
    else if (b && b->hasFinderInfo && !memcmp(b->finderInfo, c->finderInfo, 32))
        memcpy(r->finderInfo, o->finderInfo, 32);
    else r->conflicts |= FM_FINDER;
    if (FMEqualBytes(c->resource, c->resourceLength, o->resource, o->resourceLength) ||
        FMEqualBytes(br, bn, o->resource, o->resourceLength)) selected = c;
    else if (FMEqualBytes(br, bn, c->resource, c->resourceLength)) selected = o;
    else { r->conflicts |= FM_RESOURCE; return 0; }
    return FMCopyResource(r, selected, limits);
}
int FMFileMerge(const FMVersion *b, const FMVersion *c, const FMVersion *o,
                  char newline, const FMLimits *limits, GDProgress progress,
                  void *context, FMResult *destination) {
    FMResult next;
    const FMVersion *baseline;
    int error = 0;
    if (!destination || !limits || !FMValid(b) || !FMValid(c) || !FMValid(o) ||
        limits->resourceBytes > 2UL * 1024 * 1024 || limits->text.outputBytes > 16UL * 1024 * 1024 ||
        limits->text.conflicts > 8192 || (newline != '\r' && newline != '\n')) return GB_BAD;
    FMInit(&next);
    if (progress) { error = progress(context); if (error) goto done; }
    if (FMEqual(c, o) || FMEqual(b, o)) error = FMCopy(&next, c, newline, limits, progress, context);
    else if (FMEqual(b, c)) error = FMCopy(&next, o, newline, limits, progress, context);
    else if (!c || !o) { next.present = -1; next.conflicts = FM_PRESENCE; }
    else if (FMKind(c->mode) != FMKind(o->mode)) { next.present = 1; next.conflicts = FM_KIND; }
    else {
        next.present = 1;
        baseline = b && FMKind(b->mode) == FMKind(c->mode) ? b : NULL;
        if (c->mode == o->mode || (baseline && baseline->mode == o->mode)) next.mode = c->mode;
        else if (baseline && baseline->mode == c->mode) next.mode = o->mode;
        else next.conflicts |= FM_MODE;
        if (c->mode == 0160000) {
            if (!memcmp(c->gitlink, o->gitlink, 20) || (baseline && !memcmp(baseline->gitlink, o->gitlink, 20)))
                memcpy(next.gitlink, c->gitlink, 20);
            else if (baseline && !memcmp(baseline->gitlink, c->gitlink, 20)) memcpy(next.gitlink, o->gitlink, 20);
            else next.conflicts |= FM_GITLINK;
        } else if (c->mode == 0120000) {
            if (FMEqualBytes(c->data, c->dataLength, o->data, o->dataLength) ||
                (baseline && FMEqualBytes(baseline->data, baseline->dataLength, o->data, o->dataLength)))
                error = FMCopyData(&next, c, newline, limits, progress, context);
            else if (baseline && FMEqualBytes(baseline->data, baseline->dataLength, c->data, c->dataLength))
                error = FMCopyData(&next, o, newline, limits, progress, context);
            else next.conflicts |= FM_DATA;
        } else {
            error = GMTextMerge(baseline ? baseline->data : NULL, baseline ? baseline->dataLength : 0,
                c->data, c->dataLength, o->data, o->dataLength, newline, &limits->text, progress, context, &next.data);
            if (!error && next.data.count) next.conflicts |= FM_DATA;
            if (!error) error = FMMergeMeta(&next, baseline, c, o, limits);
        }
    }
    if (!error && progress) error = progress(context);
    if (!error) { FMFree(destination); *destination = next; FMInit(&next); }
done:
    FMFree(&next); return error;
}
