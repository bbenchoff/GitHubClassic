#include "GitUpstream.h"
#include "GHCore.h"
#include <stdlib.h>
#include <string.h>

static void GUSWord(unsigned char *p, GBWord n) {
    p[0]=(unsigned char)(n>>24);p[1]=(unsigned char)(n>>16);
    p[2]=(unsigned char)(n>>8);p[3]=(unsigned char)n;
}
static GBWord GUSGet(const unsigned char *p) {
    return ((GBWord)p[0]<<24)|((GBWord)p[1]<<16)|((GBWord)p[2]<<8)|p[3];
}
static void GUSHash(const void *p,size_t n,unsigned char out[20]) {
    GBSHA1 h;GBSHA1Start(&h);GBSHA1Update(&h,p,n);GBSHA1Finish(&h,out);
}
void GUUpstreamInit(GUUpstream *u) {memset(u,0,sizeof(*u));}
static int GUSValid(const GUUpstream *u) {
    if(!u || !memchr(u->repository,0,sizeof(u->repository)) ||
       !memchr(u->localBranch,0,sizeof(u->localBranch)) ||
       !memchr(u->remoteBranch,0,sizeof(u->remoteBranch)))return 0;
    return GHValidRepository(u->repository) && GSValidRef(u->localBranch) &&
        (u->tracked==0 ? !u->remoteBranch[0] : u->tracked==1 && GSValidRef(u->remoteBranch));
}
int GUUpstreamKey(const char *local,char key[80]) {
    unsigned char hash[20];char hex[41];size_t at;
    if(!local || !key || strlen(local)>1024 || !GSValidRef(local))return GB_BAD;
    GUSHash(local,strlen(local),hash);GBOIDFormat(hash,hex);
    strcpy(key,"ghclient-upstreams/");at=strlen(key);
    memcpy(key+at,hex,2);at+=2;key[at++]='/';
    memcpy(key+at,hex+2,12);at+=12;key[at++]='/';strcpy(key+at,hex+14);return 0;
}
int GUUpstreamEncode(const GUUpstream *u,unsigned char **out,size_t *length) {
    size_t rn,ln,bn,n;unsigned char *p;
    if(!out || !length)return GB_BAD;
    *out=NULL;*length=0;
    if(!GUSValid(u))return GB_BAD;
    rn=strlen(u->repository);ln=strlen(u->localBranch);bn=strlen(u->remoteBranch);
    n=44+rn+ln+bn;p=(unsigned char *)malloc(n);if(!p)return GB_MEMORY;
    memcpy(p,"GHUPST01",8);GUSWord(p+8,(GBWord)rn);GUSWord(p+12,(GBWord)ln);
    GUSWord(p+16,(GBWord)bn);GUSWord(p+20,(GBWord)u->tracked);
    memcpy(p+24,u->repository,rn);memcpy(p+24+rn,u->localBranch,ln);
    if(bn)memcpy(p+24+rn+ln,u->remoteBranch,bn);
    GUSHash(p,n-20,p+n-20);*out=p;*length=n;return 0;
}
int GUUpstreamParse(const void *input,size_t n,GUUpstream *out) {
    const unsigned char *p=(const unsigned char *)input;size_t rn,ln,bn;
    GUUpstream u;unsigned char hash[20];
    if(!input || !out)return GB_BAD;
    if(n<44 || n>2346 || memcmp(p,"GHUPST01",8))return GS_FORMAT;
    rn=GUSGet(p+8);ln=GUSGet(p+12);bn=GUSGet(p+16);
    if(!rn || rn>254 || !ln || ln>1024 || bn>1024 || GUSGet(p+20)>1 ||
       n!=44+rn+ln+bn || memchr(p+24,0,rn+ln+bn))return GS_FORMAT;
    GUSHash(p,n-20,hash);if(memcmp(hash,p+n-20,20))return GB_CHECKSUM;
    GUUpstreamInit(&u);u.tracked=(int)GUSGet(p+20);
    memcpy(u.repository,p+24,rn);memcpy(u.localBranch,p+24+rn,ln);
    if(bn)memcpy(u.remoteBranch,p+24+rn+ln,bn);
    if(!GUSValid(&u))return GS_FORMAT;
    *out=u;return 0;
}
int GUUpstreamRead(GSRepository *r,const char *repository,const char *local,GUUpstream *out,int *exists) {
    char key[80];unsigned char *bytes=NULL;size_t n=0;GUUpstream u;int error;
    if(!exists)return GB_BAD;
    *exists=0;
    if(!r || !r->read || !r->replace || !out || !repository || strlen(repository)>254 || !GHValidRepository(repository))return GB_BAD;
    error=GUUpstreamKey(local,key);if(error)return error;
    error=r->read(r->context,key,&bytes,&n);
    if(error==GS_NOT_FOUND){free(bytes);return 0;}
    if(!error)error=GUUpstreamParse(bytes,n,&u);
    free(bytes);
    if(!error && (strcmp(u.repository,repository) || strcmp(u.localBranch,local)))error=GS_CONFLICT;
    if(!error){*out=u;*exists=1;}return error;
}
int GUUpstreamSet(GSRepository *r,const GUUpstream *expected,const GUUpstream *next) {
    unsigned char *before=NULL,*after=NULL,*current=NULL;size_t bn=0,an=0,cn=0;
    char key[80];GUUpstream parsed;int error,missing=0;
    if(!r || !r->read || !r->replace || !GUSValid(next))return GB_BAD;
    error=GUUpstreamKey(next->localBranch,key);if(error)return error;
    if(expected){
        if(!GUSValid(expected) || strcmp(expected->localBranch,next->localBranch))return GB_BAD;
        error=GUUpstreamEncode(expected,&before,&bn);
    }
    if(!error)error=GUUpstreamEncode(next,&after,&an);
    if(!error){error=r->read(r->context,key,&current,&cn);if(error==GS_NOT_FOUND){missing=1;error=0;}}
    if(!error && !missing)error=GUUpstreamParse(current,cn,&parsed);
    if(!error && (missing ? expected!=NULL : !expected || bn!=cn || memcmp(before,current,cn)))error=GS_CONFLICT;
    if(!error)error=r->replace(r->context,key,before,bn,after,an);
    free(before);free(after);free(current);return error;
}
int GUUpstreamResolve(GSRepository *r,const char *repository,const char *local,const char *legacy,GUUpstream *out,int *source) {
    GUUpstream u;int error,exists;
    if(!source)return GB_BAD;
    *source=GU_UPSTREAM_NONE;
    if(!out || !legacy || strlen(legacy)>1024 || !GSValidRef(legacy))return GB_BAD;
    error=GUUpstreamRead(r,repository,local,&u,&exists);if(error)return error;
    if(exists){*source=GU_UPSTREAM_EXPLICIT;*out=u;return 0;}
    GUUpstreamInit(&u);strcpy(u.repository,repository);strcpy(u.localBranch,local);
    if(!strcmp(local,legacy)){u.tracked=1;strcpy(u.remoteBranch,legacy);*source=GU_UPSTREAM_LEGACY;}
    *out=u;return 0;
}
