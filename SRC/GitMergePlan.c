#include "GitMergePlan.h"
#include "GitCheckoutSession.h"
#include "GitHistory.h"
#include <stdlib.h>
#include <string.h>

typedef struct {
    GSRepository *source;
    GOReader reader;
    GSRepository objects;
    GDProgress progress;
    void *context;
    size_t stateLimit;
} MMIO;
void MMInit(MMPlan *p) { memset(p,0,sizeof(*p)); }
void MMFree(MMPlan *p) {
    size_t i;
    free(p->branch);free(p->otherRef);
    for(i=0;i<5;++i)free(p->guards[i].bytes);
    BCFree(&p->graph);TMFree(&p->files);GRFree(&p->target);MMInit(p);
}
void MMCheckoutInit(MMCheckout *p) { memset(p,0,sizeof(*p)); }
void MMCheckoutFree(MMCheckout *p) { GQFree(&p->checkout);MMCheckoutInit(p); }
static int MMProgress(MMIO *io) { return io->progress?io->progress(io->context):0; }
static int MMRead(void *ctx,const char *key,unsigned char **bytes,size_t *n) {
    MMIO *io=(MMIO *)ctx;
    int error;
    *bytes=NULL;*n=0;
    if(!strncmp(key,"objects/",8))return io->objects.read(io->objects.context,key,bytes,n);
    error=MMProgress(io);
    if(!error)error=io->source->read(io->source->context,key,bytes,n);
    if(!error && *n>io->stateLimit)error=GB_SPACE;
    if(!error)error=MMProgress(io);
    if(error){free(*bytes);*bytes=NULL;*n=0;}return error;
}
static int MMReplace(void *ctx,const char *key,const void *before,size_t bn,const void *after,size_t an) {
    MMIO *io=(MMIO *)ctx;
    int error;
    if(strncmp(key,"objects/",8) || before || bn)return GS_FORMAT;
    error=MMProgress(io);
    if(!error)error=io->source->replace(io->source->context,key,NULL,0,after,an);
    if(!error)error=MMProgress(io);
    return error;
}
static int MMStart(GSRepository *r,const MMLimits *limits,GDProgress progress,void *ctx,
                    MMIO *io,GSRepository *wrapper) {
    int error;
    if(!r || !r->read || !r->replace || !limits || !limits->stateBytes)return GB_BAD;
    memset(io,0,sizeof(*io));io->source=r;io->progress=progress;io->context=ctx;
    io->stateLimit=limits->stateBytes;
    error=GOReadStart(r,&limits->tree.read,progress,ctx,&io->reader,&io->objects);
    if(error)return error;
    wrapper->context=io;wrapper->read=MMRead;wrapper->replace=MMReplace;return 0;
}
static char *MMString(const char *s) {
    size_t n=strlen(s)+1;
    char *p=(char *)malloc(n);
    if(p)memcpy(p,s,n);
    return p;
}
static int MMCapture(GSRepository *r,const char *key,MMGuard *g) {
    int error;
    if(strlen(key)>=sizeof(g->key))return GB_BAD;
    strcpy(g->key,key);
    error=r->read(r->context,key,&g->bytes,&g->length);
    if(error==GS_NOT_FOUND)return 0;
    if(error)return error;
    g->present=1;return 0;
}
static int MMRef(const MMGuard *g,const char *name,const unsigned char tip[20]) {
    char hex[41];
    size_t n=strlen(name);
    GBOIDFormat(tip,hex);
    return g->present && g->length==n+42 && !memcmp(g->bytes,name,n+1) &&
        !memcmp(g->bytes+n+1,hex,40) && g->bytes[n+41]=='\n';
}
static int MMHead(const MMGuard *g,const char *branch) {
    size_t n=strlen(branch);
    return g->present && g->length==n+6 && !memcmp(g->bytes,"ref: ",5) &&
        !memcmp(g->bytes+5,branch,n) && g->bytes[n+5]=='\n';
}
static int MMRecheck(GSRepository *r,const MMPlan *p) {
    unsigned char *bytes=NULL;
    size_t i,n;
    int error,present;
    error=GTWriteAllowed(r);
    for(i=0;!error && i<5;++i) {
        error=r->read(r->context,p->guards[i].key,&bytes,&n);
        present=!error;
        if(error==GS_NOT_FOUND)error=0;
        if(!error && (present!=p->guards[i].present ||
            (present && (n!=p->guards[i].length || memcmp(bytes,p->guards[i].bytes,n)))))error=GS_CONFLICT;
        free(bytes);bytes=NULL;
    }
    return error;
}
static int MMTree(GSRepository *r,const unsigned char oid[20],unsigned char tree[20]) {
    GHCommitInfo info;
    unsigned char *body=NULL;
    size_t n;
    char type[7];
    int error=GSGetObject(r,oid,type,&body,&n);
    if(!error)error=strcmp(type,"commit")?GS_FORMAT:GHCommitParse(body,n,&info);
    if(!error)memcpy(tree,info.tree,20);
    free(body);return error;
}
static int MMNonzero(const unsigned char oid[20]) {
    size_t i;for(i=0;i<20;++i)if(oid[i])return 1;return 0;
}
int MMPrepare(GSRepository *r,const char *branch,const unsigned char current[20],const char *other,
                const unsigned char incoming[20],unsigned options,char newline,const MMLimits *limits,
                GDProgress progress,void *ctx,MMPlan *destination) {
    MMPlan next;
    MMIO io;
    GSRepository repository;
    GIReadLimits traversal;
    const BCNode *base;
    char key[64];
    size_t i,n;
    int error;
    if(!GSValidRef(branch) || (!GSValidRef(other) && !GSValidTrackingRef(other)) || !current ||
        !incoming || !destination || !limits || (options & ~(MM_ALLOW_UNRELATED|MM_NO_FF|MM_SQUASH)) ||
        (newline!='\r' && newline!='\n'))return GB_BAD;
    error=MMStart(r,limits,progress,ctx,&io,&repository);
    if(error)return error;
    n=strlen(branch);
    if(n>limits->stateBytes || strlen(other)>limits->stateBytes)return GB_SPACE;
    MMInit(&next);next.limits=*limits;next.options=options;next.newline=newline;
    next.branch=MMString(branch);next.otherRef=MMString(other);
    if(!next.branch || !next.otherRef){error=GB_MEMORY;goto done;}
    memcpy(next.tips,current,20);memcpy(next.tips+20,incoming,20);
    error=GTWriteAllowed(&repository);
    if(!error)error=MMCapture(&repository,"HEAD",next.guards);
    if(!error)error=GSRefKey(branch,key);
    if(!error)error=MMCapture(&repository,key,next.guards+1);
    if(!error)error=MMCapture(&repository,"index",next.guards+2);
    if(!error)error=MMCapture(&repository,"ghclient-map",next.guards+3);
    if(!error)error=GSRefKey(other,key);
    if(!error)error=MMCapture(&repository,key,next.guards+4);
    if(!error && (!MMHead(next.guards,branch) || !MMRef(next.guards+1,branch,current) ||
        !MMRef(next.guards+4,other,incoming)))error=GS_CONFLICT;
    for(i=0;!error && i<5;++i) {
        if(next.guards[i].length>limits->stateBytes-next.stateBytes)error=GB_SPACE;
        else next.stateBytes+=next.guards[i].length;
    }
    if(!error)error=BCBuild(r,current,incoming,&limits->graph,progress,ctx,&next.graph);
    if(error)goto done;
    if(!next.graph.onlyRight)next.kind=MM_UPTODATE;
    else if(next.graph.bases>1)next.kind=MM_MULTIPLE_BASES;
    else if(!next.graph.bases && !(options & MM_ALLOW_UNRELATED))next.kind=MM_UNRELATED;
    else {
        error=MMTree(&repository,current,next.trees[1]);
        if(!error)error=MMTree(&repository,incoming,next.trees[2]);
        if(!error && !next.graph.onlyLeft) {
            memset(&traversal,0,sizeof(traversal));
            traversal.entries=limits->tree.entries;traversal.depth=limits->tree.depth;
            traversal.pathBytes=limits->tree.pathBytes;traversal.progress=progress;traversal.context=ctx;
            error=GRFromTreeBounded(&repository,next.trees[2],&next.target,&traversal);
            for(i=0;!error && i<next.target.count;++i)
                if(next.target.files[i].mode==0160000 &&
                    !MMNonzero(next.target.index.entries[next.target.files[i].entry].oid))error=GS_FORMAT;
            if(!error) {
                next.directTree=1;next.haveBase=1;memcpy(next.trees[0],next.trees[1],20);
                next.kind=(options & (MM_NO_FF|MM_SQUASH))?MM_MERGE:MM_FAST_FORWARD;
            }
        } else if(!error) {
            base=BCBaseAt(&next.graph,0);
            if(base) {
                error=MMTree(&repository,base->oid,next.trees[0]);next.haveBase=!error;
            }
            if(!error)error=TMFromTrees(&repository,next.haveBase?next.trees[0]:NULL,next.trees[1],
                next.trees[2],newline,&limits->tree,progress,ctx,&next.files);
            if(!error)next.kind=next.files.conflicts?MM_CONFLICT:MM_MERGE;
        }
    }
    if(!error)error=MMRecheck(&repository,&next);
    if(!error) {
        next.encodedReadBytes=io.reader.bytes;next.expandedReadBytes=io.reader.expanded;
        next.readCount=io.reader.reads;MMFree(destination);*destination=next;MMInit(&next);
    }
done:MMFree(&next);return error;
}
static int MMBefore(const GCMetadata *m,const MMGuard *g) {
    return m->beforePresent==g->present && m->beforeLength==g->length &&
        (!g->present || !memcmp(m->before,g->bytes,g->length));
}
static int MMAddGuard(GCTransaction *t,const MMGuard *g) {
    GCMetadata *items,*m;
    if(t->metadataCount>=(size_t)-1/sizeof(*items))return GB_SPACE;
    items=(GCMetadata *)realloc(t->metadata,(t->metadataCount+1)*sizeof(*items));
    if(!items)return GB_MEMORY;
    t->metadata=items;m=items+t->metadataCount++;memset(m,0,sizeof(*m));
    m->path=MMString(g->key);m->beforePresent=m->afterPresent=g->present;
    m->beforeLength=m->afterLength=g->length;
    if(g->present) {
        m->before=(unsigned char *)malloc(g->length?g->length:1);
        m->after=(unsigned char *)malloc(g->length?g->length:1);
        if(!m->before || !m->after)return GB_MEMORY;
        memcpy(m->before,g->bytes,g->length);memcpy(m->after,g->bytes,g->length);
    }
    return m->path?0:GB_MEMORY;
}
static int MMSeal(const MMPlan *p,GCTransaction *t,const unsigned char candidate[20]) {
    size_t i,j;
    MMGuard after;
    int error;
    for(i=0;i<5;++i) {
        for(j=0;j<t->metadataCount;++j)if(!strcmp(p->guards[i].key,t->metadata[j].path))break;
        if(j==t->metadataCount) {
            if(i!=4)return GS_FORMAT;
            error=MMAddGuard(t,p->guards+i);if(error)return error;
        }
        if(!MMBefore(t->metadata+j,p->guards+i))return GS_CONFLICT;
        after=p->guards[i];after.present=t->metadata[j].afterPresent;
        after.bytes=t->metadata[j].after;after.length=t->metadata[j].afterLength;
        if(i==0 && !MMHead(&after,p->branch))return GS_CONFLICT;
        if(i==1 && !MMRef(&after,p->branch,candidate))return GS_CONFLICT;
        if(i==4 && (after.present!=p->guards[i].present || after.length!=p->guards[i].length ||
            (after.present && memcmp(after.bytes,p->guards[i].bytes,after.length))))return GS_CONFLICT;
    }
    return 0;
}
int MMBuildCheckout(GSRepository *r,const MMPlan *p,const GQWork *work,size_t count,GPEqual eq,void *eqCtx,
                      const char *author,const char *committer,const char *seconds,const char *zone,
                      const char *message,GDProgress progress,void *ctx,MMCheckout *destination,GQError *why) {
    MMCheckout next;
    TMDraft draft;
    MMIO io;
    GSRepository repository;
    unsigned char *encoded=NULL;
    size_t n;
    int error;
    if(!r || !r->read || !r->replace || !p || !destination || !eq || (count && !work) ||
        p->kind<MM_UPTODATE || p->kind>MM_UNRELATED)return GB_BAD;
    if(why)memset(why,0,sizeof(*why));
    if(p->kind==MM_UPTODATE)return MM_NO_CHANGE;
    if(p->kind==MM_CONFLICT)return GI_UNMERGED;
    if(p->kind==MM_MULTIPLE_BASES || p->kind==MM_UNRELATED)return MM_POLICY;
    error=MMStart(r,&p->limits,progress,ctx,&io,&repository);if(error)return error;
    MMCheckoutInit(&next);TMDraftInit(&draft);next.kind=p->kind;
    error=MMRecheck(&repository,p);
    if(!error && p->kind==MM_FAST_FORWARD) {
        memcpy(next.commit,p->tips+20,20);memcpy(next.tree,p->trees[2],20);
    } else if(!error) {
        if(p->directTree)memcpy(next.tree,p->trees[2],20);
        else {
            error=TMBuildIndex(&repository,&p->files,progress,ctx,&draft);
            if(!error)error=TMStoreObjects(&repository,&draft,progress,ctx);
            if(!error)error=GIWriteTree(&repository,&draft.index,next.tree);
        }
        if(!error && (p->options & MM_SQUASH) && !memcmp(next.tree,p->trees[1],20)) {
            /* Do not invent an empty squash commit. Refuse stale state even
               when this proposal needs no mutable publication. */
            error=MMRecheck(&repository,p);if(!error)error=MM_NO_CHANGE;
        } else if(!error)error=GSWriteCommitObject(&repository,next.tree,p->tips,(p->options & MM_SQUASH)?1:2,
            author,committer,seconds,zone,message,next.commit);
    }
    if(!error)error=GQToCommit(&repository,p->branch,p->tips,next.commit,work,count,eq,eqCtx,&next.checkout,why);
    if(!error)error=MMSeal(p,&next.checkout.transaction,next.commit);
    if(!error)error=GCEncode(&next.checkout.transaction,eq,eqCtx,&encoded,&n);
    if(!error)error=MMRecheck(&repository,p);
    if(!error) {
        next.encodedReadBytes=io.reader.bytes;next.expandedReadBytes=io.reader.expanded;next.readCount=io.reader.reads;
        MMCheckoutFree(destination);*destination=next;MMCheckoutInit(&next);
    }
    free(encoded);TMDraftFree(&draft);MMCheckoutFree(&next);return error;
}
