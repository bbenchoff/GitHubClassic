#include "GitPreview.h"
#include <stdlib.h>
#include <string.h>
#include <stdio.h>


typedef struct {
    char *text;
    size_t used, size;
    char newline;
    int truncated;
} GDPOutput;
static void GDPText(GDPOutput *out, const char *text) {
    size_t n = strlen(text), left = out->size - out->used - 1;
    if (n > left) { n = left; out->truncated = 1; }
    if (n) memcpy(out->text + out->used, text, n);
    out->used += n; out->text[out->used] = 0;
}
static void GDPEnd(GDPOutput *out) {
    char text[2]; text[0] = out->newline; text[1] = 0; GDPText(out, text);
}

void GDFileInit(GDFile *f) { memset(f, 0, sizeof(*f)); }
void GDFileFree(GDFile *f) { free(f->data); free(f->metadata); GDFileInit(f); }
static void GDFinder(unsigned char *info) {
    info[8] &= (unsigned char)~1U;
    memset(info + 10, 0, 6); memset(info + 28, 0, 4);
}
static int GDBlob(GSRepository *r, const GIEntry *entry, unsigned char **body, size_t *n) {
    char type[7];
    int error = GSGetObjectLimit(r, entry->oid, type, body, n, 2UL * 1024UL * 1024UL);
    if (!error && strcmp(type, "blob")) error = GS_FORMAT;
    if (error) { free(*body); *body = NULL; *n = 0; }
    return error;
}
int GDReadFile(GSRepository *r, const GIIndex *index, const char *path, GDFile *destination) {
    GDFile next;
    const GIEntry *entry, *metadata;
    char key[96], *logical = NULL;
    size_t length;
    int error;
    if (!r || !index || !path || !destination || !GIValidPath(path) ||
        (!strncmp(path, GI_MAC_NAMESPACE, strlen(GI_MAC_NAMESPACE)) &&
         (!path[strlen(GI_MAC_NAMESPACE)] || path[strlen(GI_MAC_NAMESPACE)] == '/'))) return GB_BAD;
    GDFileInit(&next);
    error = GIMacMetadataPath(path, key);
    if (error) return error;
    entry = GIFind(index, path, 0); metadata = GIFind(index, key, 0);
    if (metadata && !entry) return GS_FORMAT;
    if (entry) {
        next.exists = 1; next.mode = entry->stat[6];
        if (next.mode != 0100644 && next.mode != 0100755 && next.mode != 0120000) error = GI_UNSUPPORTED;
        else error = GDBlob(r, entry, &next.data, &next.dataLength);
    }
    if (!error && metadata) {
        error = GIValidateMacNamespace(r, index);
        if (!error && (metadata->stat[6] != 0100644 || next.mode == 0120000)) error = GS_FORMAT;
        if (!error) error = GDBlob(r, metadata, &next.metadata, &length);
        if (!error) error = GIMacDecode(next.metadata, length, &logical, next.finderInfo,
                                       &next.resource, &next.resourceLength);
        if (!error && strcmp(logical, path)) error = GS_FORMAT;
        if (!error) { next.hasFinderInfo = 1; GDFinder(next.finderInfo); }
    }
    free(logical);
    if (error) GDFileFree(&next);
    else { GDFileFree(destination); *destination = next; }
    return error;
}
static void GDEndings(int flags, char output[48]) {
    output[0] = 0;
    if (flags & GD_CR) strcat(output, "CR ");
    if (flags & GD_LF) strcat(output, "LF ");
    if (flags & GD_CRLF) strcat(output, "CRLF ");
    if (flags & GD_UNTERMINATED) strcat(output, "no-final-newline ");
    if (!flags) strcpy(output, "empty ");
    output[strlen(output) - 1] = 0;
}
int GDPreview(const GDFile *before, const GDFile *after, char newline,
              char *output, size_t capacity, GDProgress progress, void *context, GDResult *result) {
    GDResult diff;
    GDPOutput out;
    char *patch, line[180], oldEndings[48], newEndings[48];
    unsigned char oldInfo[32], newInfo[32];
    size_t oldResource, newResource;
    int error, sameResource;
    if (output && capacity) output[0] = 0;
    if (result) memset(result, 0, sizeof(*result));
    if (!before || !after || !output || !capacity || !result ||
        (!before->exists && (before->dataLength || before->hasFinderInfo)) ||
        (!after->exists && (after->dataLength || after->hasFinderInfo)) ||
        (before->resourceLength && (!before->resource || !before->hasFinderInfo)) ||
        (after->resourceLength && (!after->resource || !after->hasFinderInfo))) return GB_BAD;
    patch = (char *)malloc(capacity);
    if (!patch) return GB_MEMORY;
    error = GDRender(before->data, before->dataLength, after->data, after->dataLength,
                     3, newline, patch, capacity, progress, context, &diff);
    if (error) { free(patch); return error; }
    out.text = output; out.used = 0; out.size = capacity; out.newline = newline; out.truncated = 0;
    if (!before->exists && after->exists) GDPText(&out, "New file.");
    else if (before->exists && !after->exists) GDPText(&out, "File deleted.");
    else GDPText(&out, "Existing file.");
    GDPEnd(&out);
    if (before->exists && after->exists && before->mode != after->mode) {
        sprintf(line, "Git mode: %lo -> %lo.", (unsigned long)before->mode, (unsigned long)after->mode);
        GDPText(&out, line); GDPEnd(&out);
    }
    oldResource = before->hasFinderInfo ? before->resourceLength : 0;
    newResource = after->hasFinderInfo ? after->resourceLength : 0;
    sameResource = oldResource == newResource &&
                   (!oldResource || !memcmp(before->resource, after->resource, oldResource));
    if (sameResource) sprintf(line, "Resource fork unchanged (%lu bytes).", (unsigned long)oldResource);
    else sprintf(line, "Resource fork changed: %lu -> %lu bytes (binary).", (unsigned long)oldResource, (unsigned long)newResource);
    GDPText(&out, line); GDPEnd(&out);
    memcpy(oldInfo, before->finderInfo, 32); memcpy(newInfo, after->finderInfo, 32);
    GDFinder(oldInfo); GDFinder(newInfo);
    if (before->hasFinderInfo != after->hasFinderInfo)
        GDPText(&out, after->hasFinderInfo ? "Macintosh attributes added." : "Macintosh attributes removed.");
    else if (before->hasFinderInfo && memcmp(oldInfo, newInfo, 32)) GDPText(&out, "Finder attributes changed.");
    else GDPText(&out, "Finder attributes unchanged.");
    GDPEnd(&out);
    if (!diff.binary) {
        GDEndings(diff.oldEndings, oldEndings); GDEndings(diff.newEndings, newEndings);
        sprintf(line, "Line endings: %s -> %s.", oldEndings, newEndings);
        GDPText(&out, line); GDPEnd(&out);
    }
    GDPEnd(&out); GDPText(&out, patch); free(patch);
    diff.truncated = diff.truncated || out.truncated; *result = diff; return 0;
}
