#include "GitCommitDiff.h"
#include "GitObjectRead.h"
#include <stdlib.h>
#include <string.h>
#include <stdio.h>

typedef GOReader HCDReader;
static int HCDStart(GSRepository *source, const HCLimits *limits, GDProgress progress,
                      void *context, HCDReader *state, GSRepository *reader) {
    GOLimits bounds;
    if (!limits || !limits->entries || !limits->pathBytes) return GB_BAD;
    bounds.objectBytes = limits->objectBytes; bounds.encodedBytes = limits->encodedBytes;
    bounds.readBytes = limits->readBytes; bounds.reads = limits->reads;
    return GOReadStart(source, &bounds, progress, context, state, reader);
}
void HCInit(HCComparison *c) { memset(c, 0, sizeof(*c)); }
void HCFree(HCComparison *c) {
    GRFree(&c->before); GRFree(&c->after); free(c->changes); HCInit(c);
}
static int HCDCommit(GSRepository *reader, const unsigned char oid[20], GHCommitInfo *info) {
    unsigned char *body = NULL;
    char type[7];
    size_t n;
    int error = GSGetObject(reader, oid, type, &body, &n);
    if (!error) error = strcmp(type, "commit") ? GS_FORMAT : GHCommitParse(body, n, info);
    free(body); return error;
}
static int HCDGitlinkValid(const GRSnapshot *s) {
    size_t i, j;
    for (i = 0; i < s->count; ++i) if (s->files[i].mode == 0160000) {
        for (j = 0; j < 20 && !s->index.entries[s->files[i].entry].oid[j]; ++j) { }
        if (j == 20) return GS_FORMAT;
    }
    return 0;
}
static int HCDMetadataEqual(const GRSnapshot *a, const GRFile *x,
                              const GRSnapshot *b, const GRFile *y) {
    if (x->hasFinderInfo != y->hasFinderInfo) return 0;
    return !x->hasFinderInfo ||
        !memcmp(a->index.entries[x->metadataEntry].oid, b->index.entries[y->metadataEntry].oid, 20);
}
static int HCDCompare(GSRepository *source, const unsigned char *before,
                        const unsigned char oid[20], int firstParent, const HCLimits *limits,
                        GDProgress progress, void *context, HCComparison *destination) {
    HCComparison next;
    HCDReader state;
    GSRepository reader;
    GIReadLimits treeLimits;
    GHCommitInfo parent;
    HCChange *change;
    const GRFile *x, *y;
    size_t a = 0, b = 0, total;
    unsigned flags;
    int error, order;
    if (!oid || !destination) return GB_BAD;
    HCInit(&next);
    error = HCDStart(source, limits, progress, context, &state, &reader);
    if (error) return error;
    treeLimits.entries = limits->entries; treeLimits.depth = limits->depth;
    treeLimits.pathBytes = limits->pathBytes; treeLimits.progress = progress; treeLimits.context = context;
    error = HCDCommit(&reader, oid, &next.commit);
    if (!error) error = GRFromTreeBounded(&reader, next.commit.tree, &next.after, &treeLimits);
    if (firstParent) before = next.commit.parents ? next.commit.parent : NULL;
    if (!error && before) {
        error = HCDCommit(&reader, before, &parent);
        if (!error) error = GRFromTreeBounded(&reader, parent.tree, &next.before, &treeLimits);
        if (!error) { next.before.haveCommit = 1; memcpy(next.before.commit, before, 20); }
    }
    if (!error) error = HCDGitlinkValid(&next.before);
    if (!error) error = HCDGitlinkValid(&next.after);
    if (error) goto done;
    next.after.haveCommit = 1; memcpy(next.after.commit, oid, 20); next.limits = *limits;
    if (next.before.count > (size_t)-1 - next.after.count) { error = GB_SPACE; goto done; }
    total = next.before.count + next.after.count;
    if (total > (size_t)-1 / sizeof(*next.changes)) { error = GB_SPACE; goto done; }
    next.changes = (HCChange *)calloc(total ? total : 1, sizeof(*next.changes));
    if (!next.changes) { error = GB_MEMORY; goto done; }
    while (a < next.before.count || b < next.after.count) {
        if (progress && (error = progress(context)) != 0) goto done;
        x = a < next.before.count ? next.before.files + a : NULL;
        y = b < next.after.count ? next.after.files + b : NULL;
        order = !x ? 1 : !y ? -1 : strcmp(x->path, y->path);
        flags = order < 0 ? HC_DELETED : order > 0 ? HC_ADDED : 0;
        if (!order) {
            if (x->mode != y->mode) flags |= HC_MODE;
            if (memcmp(next.before.index.entries[x->entry].oid, next.after.index.entries[y->entry].oid, 20)) flags |= HC_DATA;
            if (!HCDMetadataEqual(&next.before, x, &next.after, y)) flags |= HC_MAC;
        }
        if (flags) {
            change = next.changes + next.count++;
            change->before = order > 0 ? (size_t)-1 : a;
            change->after = order < 0 ? (size_t)-1 : b;
            change->path = order < 0 ? x->path : y->path;
            if ((order <= 0 && x->mode == 0160000) || (order >= 0 && y->mode == 0160000)) flags |= HC_GITLINK;
            change->flags = flags;
        }
        if (order <= 0) ++a;
        if (order >= 0) ++b;
    }
    HCFree(destination); *destination = next; HCInit(&next);
done:
    HCFree(&next); return error;
}
int HCFromCommit(GSRepository *source, const unsigned char oid[20], const HCLimits *limits,
                   GDProgress progress, void *context, HCComparison *destination) {
    return HCDCompare(source, NULL, oid, 1, limits, progress, context, destination);
}
int HCBetweenCommits(GSRepository *source, const unsigned char *before, const unsigned char after[20],
                       const HCLimits *limits, GDProgress progress, void *context, HCComparison *destination) {
    return HCDCompare(source, before, after, 0, limits, progress, context, destination);
}
int HCPreview(GSRepository *source, const HCComparison *comparison, size_t selected,
                 char newline, char *output, size_t capacity, GDProgress progress,
                 void *context, GDResult *result) {
    HCDReader state;
    GSRepository reader;
    GDFile before, after;
    const HCChange *change;
    const GRFile *x, *y;
    char oldID[41], newID[41], text[320];
    int error, n;
    if (output && capacity) output[0] = 0;
    if (result) memset(result, 0, sizeof(*result));
    if (!comparison || selected >= comparison->count || !output || !capacity || !result ||
        (newline != '\r' && newline != '\n')) return GB_BAD;
    error = HCDStart(source, &comparison->limits, progress, context, &state, &reader);
    if (error) return error;
    if (progress && (error = progress(context)) != 0) return error;
    change = comparison->changes + selected;
    if (change->flags & HC_GITLINK) {
        x = change->before == (size_t)-1 ? NULL : comparison->before.files + change->before;
        y = change->after == (size_t)-1 ? NULL : comparison->after.files + change->after;
        strcpy(oldID, "absent"); strcpy(newID, "absent");
        if (x) GBOIDFormat(comparison->before.index.entries[x->entry].oid, oldID);
        if (y) GBOIDFormat(comparison->after.index.entries[y->entry].oid, newID);
        /* Both IDs are <=40 characters and modes are fixed Git modes; this
           complete message fits320 bytes, including 32-bit octal values. */
        n = sprintf(text, "Submodule comparison.%cBefore mode %lo: %s%cAfter mode %lo: %s%c%cGitlink IDs are external; no submodule contents were fetched.%c",
            newline, x ? (unsigned long)x->mode : 0UL, oldID, newline,
            y ? (unsigned long)y->mode : 0UL, newID, newline, newline, newline);
        if (n < 0 || (size_t)n >= sizeof(text)) return GB_SPACE;
        result->truncated = (size_t)n >= capacity;
        if ((size_t)n >= capacity) n = (int)(capacity - 1);
        memcpy(output, text, (size_t)n); output[n] = 0; return 0;
    }
    GDFileInit(&before); GDFileInit(&after);
    error = GDReadFile(&reader, &comparison->before.index, change->path, &before);
    if (!error) error = GDReadFile(&reader, &comparison->after.index, change->path, &after);
    if (!error) error = GDPreview(&before, &after, newline, output, capacity, progress, context, result);
    GDFileFree(&before); GDFileFree(&after);
    if (error) { output[0] = 0; memset(result, 0, sizeof(*result)); }
    return error;
}
