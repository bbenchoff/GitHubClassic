#include "GitTreeMerge.h"
#include <stdlib.h>
#include <string.h>

typedef struct { unsigned char resource[20]; int ready; } TMCache;
typedef struct { unsigned char key[44]; size_t file; } TMMatch;
typedef struct { const char *path; size_t node; } TMPath;
typedef struct {
    TMPlan plan;
    GSRepository reader;
    GOReader bounds;
    GDProgress progress;
    void *context;
    TMCache *cache[3];
    size_t *mapping[2], *ambBase[2], *ambAdded[2], checks;
    unsigned char *claimed[2];
} TMWork;
void TMInit(TMPlan *p) { memset(p, 0, sizeof(*p)); }
void TMFree(TMPlan *p) {
    size_t i;
    for (i = 0; i < p->count; ++i) { free(p->files[i].path); FMFree(&p->files[i].proposal); }
    for (i = 0; i < p->groupCount; ++i) { free(p->groups[i].base); free(p->groups[i].added); }
    free(p->files); free(p->groups);
    for (i = 0; i < 3; ++i) GRFree(p->snapshots + i);
    TMInit(p);
}
static int TMTick(TMWork *w) { return w->progress ? w->progress(w->context) : 0; }
static int TMCheck(TMWork *w) {
    if (w->checks == w->plan.limits.pathChecks) return GB_SPACE;
    ++w->checks; return TMTick(w);
}
static char *TMString(const char *text) {
    size_t n = strlen(text); char *out = (char *)malloc(n + 1);
    if (out) memcpy(out, text, n + 1);
    return out;
}
static size_t TMFind(const GRSnapshot *s, const char *path) {
    size_t lo = 0, hi = s->count, mid;
    while (lo < hi) { mid = lo + (hi - lo) / 2;
        if (strcmp(s->files[mid].path, path) < 0) lo = mid + 1; else hi = mid; }
    return lo < s->count && !strcmp(s->files[lo].path, path) ? lo : TM_NONE;
}
static int TMResource(TMWork *w, int side, size_t file, unsigned char id[20]) {
    GRSnapshot *s = w->plan.snapshots + side;
    GRFile *f = s->files + file;
    TMCache *cache = w->cache[side] + file;
    unsigned char *body = NULL, info[32];
    const unsigned char *resource;
    size_t length, n; char type[7], *path = NULL; int error = 0;
    if (!cache->ready) {
        if (!f->resourceLength) error = GBObjectID("blob", NULL, 0, cache->resource);
        else {
            error = GSGetObject(&w->reader, s->index.entries[f->metadataEntry].oid, type, &body, &length);
            if (!error) error = strcmp(type, "blob") ? GS_FORMAT : GIMacDecode(body, length, &path, info, &resource, &n);
            if (!error && (strcmp(path, f->path) || n != f->resourceLength || memcmp(info, f->finderInfo, 32))) error = GS_FORMAT;
            if (!error) error = GBObjectID("blob", resource, n, cache->resource);
            free(path); free(body);
        }
        if (!error) cache->ready = 1;
    }
    if (!error) memcpy(id, cache->resource, 20);
    return error;
}
static int TMKey(TMWork *w, int side, size_t file, TMMatch *match) {
    GRSnapshot *s = w->plan.snapshots + side; GRFile *f = s->files + file;
    GBWord mode = f->mode & 0170000; int error;
    match->file = file; memcpy(match->key, s->index.entries[f->entry].oid, 20);
    error = TMResource(w, side, file, match->key + 20);
    match->key[40] = (unsigned char)(mode >> 24); match->key[41] = (unsigned char)(mode >> 16);
    match->key[42] = (unsigned char)(mode >> 8); match->key[43] = (unsigned char)mode;
    return error;
}
static int TMMatchOrder(const void *a, const void *b) { return memcmp(((const TMMatch *)a)->key, ((const TMMatch *)b)->key, 44); }
static int TMGroup(TMWork *w, int side, const TMMatch *base, size_t bn, const TMMatch *added, size_t an) {
    TMRenameGroup *grown, *g; size_t i, n = w->plan.groupCount;
    grown = (TMRenameGroup *)realloc(w->plan.groups, (n + 1) * sizeof(*grown));
    if (!grown) return GB_MEMORY;
    w->plan.groups = grown; g = grown + n; memset(g, 0, sizeof(*g)); ++w->plan.groupCount;
    g->side = side; g->baseCount = bn; g->addedCount = an;
    g->base = (size_t *)malloc(bn * sizeof(*g->base)); g->added = (size_t *)malloc(an * sizeof(*g->added));
    if (!g->base || !g->added) return GB_MEMORY;
    for (i = 0; i < bn; ++i) { g->base[i] = base[i].file; w->ambBase[side - 1][base[i].file] = n + 1; }
    for (i = 0; i < an; ++i) { g->added[i] = added[i].file; w->ambAdded[side - 1][added[i].file] = n + 1; }
    return 0;
}
static int TMRenames(TMWork *w, int side) {
    GRSnapshot *base = w->plan.snapshots, *s = w->plan.snapshots + side;
    TMMatch *deleted = NULL, *added = NULL;
    size_t i, at, dn = 0, an = 0, d = 0, a = 0, de, ae;
    int error = 0, order;
    w->mapping[side - 1] = (size_t *)malloc((base->count ? base->count : 1) * sizeof(size_t));
    w->claimed[side - 1] = (unsigned char *)calloc(s->count ? s->count : 1, 1);
    w->ambBase[side - 1] = (size_t *)calloc(base->count ? base->count : 1, sizeof(size_t));
    w->ambAdded[side - 1] = (size_t *)calloc(s->count ? s->count : 1, sizeof(size_t));
    deleted = (TMMatch *)malloc((base->count ? base->count : 1) * sizeof(*deleted));
    added = (TMMatch *)malloc((s->count ? s->count : 1) * sizeof(*added));
    if (!w->mapping[side - 1] || !w->claimed[side - 1] || !w->ambBase[side - 1] || !w->ambAdded[side - 1] || !deleted || !added) { error = GB_MEMORY; goto done; }
    for (i = 0; i < base->count; ++i) {
        error = TMCheck(w); if (error) goto done;
        at = TMFind(s, base->files[i].path); w->mapping[side - 1][i] = at;
        if (at != TM_NONE) w->claimed[side - 1][at] = 1;
        else { error = TMKey(w, 0, i, deleted + dn++); if (error) goto done; }
    }
    for (i = 0; i < s->count; ++i) if (!w->claimed[side - 1][i]) {
        error = TMCheck(w); if (!error) error = TMKey(w, side, i, added + an++); if (error) goto done;
    }
    qsort(deleted, dn, sizeof(*deleted), TMMatchOrder); qsort(added, an, sizeof(*added), TMMatchOrder);
    while (d < dn && a < an) {
        error = TMCheck(w); if (error) goto done;
        order = TMMatchOrder(deleted + d, added + a);
        if (order < 0) { ++d; continue; } if (order > 0) { ++a; continue; }
        de = d + 1; ae = a + 1;
        while (de < dn && !TMMatchOrder(deleted + d, deleted + de)) ++de;
        while (ae < an && !TMMatchOrder(added + a, added + ae)) ++ae;
        if (de == d + 1 && ae == a + 1) {
            w->mapping[side - 1][deleted[d].file] = added[a].file; w->claimed[side - 1][added[a].file] = 1;
        } else { error = TMGroup(w, side, deleted + d, de - d, added + a, ae - a); if (error) goto done; }
        d = de; a = ae;
    }
done:
    free(deleted); free(added); return error;
}
static const GRFile *TMFile(const TMPlan *p, int side, size_t at) { return at == TM_NONE ? NULL : p->snapshots[side].files + at; }
static int TMSame(TMWork *w, int as, size_t ai, int bs, size_t bi, int *same) {
    const GRFile *a = TMFile(&w->plan, as, ai), *b = TMFile(&w->plan, bs, bi);
    unsigned char ar[20], br[20]; int error;
    *same = 0;
    if (!a || !b) { *same = !a && !b; return 0; }
    if (a->mode != b->mode || a->hasFinderInfo != b->hasFinderInfo || a->resourceLength != b->resourceLength ||
        memcmp(w->plan.snapshots[as].index.entries[a->entry].oid, w->plan.snapshots[bs].index.entries[b->entry].oid, 20) ||
        (a->hasFinderInfo && memcmp(a->finderInfo, b->finderInfo, 32))) return 0;
    error = TMResource(w, as, ai, ar); if (!error) error = TMResource(w, bs, bi, br);
    if (!error) *same = !memcmp(ar, br, 20);
    return error;
}
static int TMVersion(TMWork *w, int side, size_t at, GRContents *contents, FMVersion *v) {
    const GRFile *f = TMFile(&w->plan, side, at); int error;
    memset(v, 0, sizeof(*v)); if (!f) return 0; v->mode = f->mode;
    if (f->mode == 0160000) { memcpy(v->gitlink, w->plan.snapshots[side].index.entries[f->entry].oid, 20); return 0; }
    error = GRReadFile(&w->reader, w->plan.snapshots + side, at, contents);
    if (!error) { v->data = contents->data; v->dataLength = contents->dataLength;
        v->resource = contents->resource; v->resourceLength = contents->resourceLength;
        v->hasFinderInfo = contents->hasFinderInfo; memcpy(v->finderInfo, contents->finderInfo, 32); }
    return error;
}
static int TMCharge(TMPlan *p, size_t n) {
    if (n > p->limits.retainedBytes - p->retainedBytes) return GB_SPACE;
    p->retainedBytes += n; return 0;
}
static int TMNodeAdd(TMWork *w, size_t b, size_t c, size_t o) {
    TMNode *node; const GRFile *bf, *cf, *of; const char *path;
    FMVersion versions[3]; GRContents contents[3]; FMLimits limits;
    size_t i; int error = 0, same;
    if (w->plan.count == w->plan.limits.nodes) return GB_SPACE;
    node = w->plan.files + w->plan.count++; node->source[0] = b; node->source[1] = c; node->source[2] = o;
    node->selected = -2; bf = TMFile(&w->plan, 0, b); cf = TMFile(&w->plan, 1, c); of = TMFile(&w->plan, 2, o);
    if (bf) {
        if (cf && strcmp(bf->path, cf->path)) node->renamed |= 1;
        if (of && strcmp(bf->path, of->path)) node->renamed |= 2;
        node->ambiguity[0] = w->ambBase[0][b]; node->ambiguity[1] = w->ambBase[1][b];
    } else { if (cf) node->ambiguity[0] = w->ambAdded[0][c]; if (of) node->ambiguity[1] = w->ambAdded[1][o]; }
    if (node->ambiguity[0] || node->ambiguity[1]) node->conflicts |= TM_RENAME_AMBIGUOUS;
    if (node->renamed == 3 && strcmp(cf->path, of->path)) node->conflicts |= TM_RENAME_DIVERGENT;
    if (((node->renamed & 1) && !of) || ((node->renamed & 2) && !cf)) node->conflicts |= TM_RENAME_DELETE;
    path = (node->renamed & 1) ? cf->path : (node->renamed & 2) ? of->path : bf ? bf->path : cf ? cf->path : of->path;
    node->path = TMString(path); if (!node->path) return GB_MEMORY;
    error = TMSame(w, 1, c, 2, o, &same); if (error) return error;
    if (same) node->selected = cf ? 1 : -2;
    else {
        error = TMSame(w, 0, b, 2, o, &same); if (error) return error;
        if (same) node->selected = cf ? 1 : -2;
        else { error = TMSame(w, 0, b, 1, c, &same); if (error) return error;
            if (same) node->selected = of ? 2 : -2; else node->selected = -1; }
    }
    if (node->selected != -1) return 0;
    for (i = 0; i < 3; ++i) GRContentsInit(contents + i);
    for (i = 0; i < 3 && !error; ++i) error = TMVersion(w, (int)i, node->source[i], contents + i, versions + i);
    limits = w->plan.limits.file;
    if (limits.text.outputBytes > w->plan.limits.read.objectBytes) limits.text.outputBytes = w->plan.limits.read.objectBytes;
    if (!error) error = FMFileMerge(bf ? versions : NULL, cf ? versions + 1 : NULL, of ? versions + 2 : NULL,
        w->plan.newline, &limits, w->progress, w->context, &node->proposal);
    if (!error) error = TMCharge(&w->plan, node->proposal.data.bytes ? node->proposal.data.length + 1 : 0);
    if (!error) error = TMCharge(&w->plan, node->proposal.resourceLength);
    if (!error) error = TMCharge(&w->plan, node->proposal.data.count * sizeof(*node->proposal.data.conflicts));
    if (!error) node->conflicts |= node->proposal.conflicts;
    for (i = 0; i < 3; ++i) GRContentsFree(contents + i);
    return error;
}
static int TMLive(const TMNode *n) { return n->conflicts || (n->selected == -1 ? n->proposal.present != 0 : n->selected != -2); }
static int TMPathOrder(const void *a, const void *b) { return strcmp(((const TMPath *)a)->path, ((const TMPath *)b)->path); }
static int TMStructure(TMWork *w) {
    TMPath *paths; TMNode *node; const GRFile *other;
    size_t i, j, n = 0, lo, hi, mid, at, end, length; int order, error = 0;
    paths = (TMPath *)malloc((w->plan.count ? w->plan.count * 2 : 1) * sizeof(*paths));
    if (!paths) return GB_MEMORY;
    for (i = 0; i < w->plan.count; ++i) {
        node = w->plan.files + i; if (!TMLive(node)) continue;
        paths[n].path = node->path; paths[n++].node = i;
        if (node->conflicts & TM_RENAME_DIVERGENT) {
            other = TMFile(&w->plan, 2, node->source[2]); paths[n].path = other->path; paths[n++].node = i;
        }
    }
    qsort(paths, n, sizeof(*paths), TMPathOrder);
    for (i = 0; i < n; ++i) {
        error = TMCheck(w); if (error) break;
        if (i && !strcmp(paths[i - 1].path, paths[i].path) && paths[i - 1].node != paths[i].node) {
            w->plan.files[paths[i - 1].node].conflicts |= TM_PATH_COLLISION;
            w->plan.files[paths[i].node].conflicts |= TM_PATH_COLLISION;
        }
        length = strlen(paths[i].path);
        for (j = 0; j < length; ++j) if (paths[i].path[j] == '/') {
            error = TMCheck(w); if (error) break;
            lo = 0; hi = n;
            while (lo < hi) {
                mid = lo + (hi - lo) / 2; order = strncmp(paths[mid].path, paths[i].path, j);
                if (!order && paths[mid].path[j]) order = 1;
                if (order < 0) lo = mid + 1; else hi = mid;
            }
            at = lo; end = at;
            while (end < n && strlen(paths[end].path) == j && !memcmp(paths[end].path, paths[i].path, j)) ++end;
            for (; at < end; ++at) if (paths[at].node != paths[i].node) {
                w->plan.files[paths[at].node].conflicts |= TM_DIRECTORY;
                w->plan.files[paths[i].node].conflicts |= TM_DIRECTORY;
            }
        }
        if (error) break;
    }
    free(paths); return error;
}
int TMFromTrees(GSRepository *source, const unsigned char *base, const unsigned char current[20],
                   const unsigned char other[20], char newline, const TMLimits *limits,
                   GDProgress progress, void *context, TMPlan *destination) {
    TMWork w; GIReadLimits trees; size_t i, j, total; int error;
    if (!destination || !current || !other || !limits || !limits->entries || !limits->nodes ||
        limits->entries > 65536 || limits->nodes > 65536 || !limits->pathBytes || !limits->pathChecks ||
        limits->file.resourceBytes > 2097152UL || limits->file.text.outputBytes > 16777216UL ||
        limits->file.text.conflicts > 8192 || (newline != '\r' && newline != '\n')) return GB_BAD;
    memset(&w, 0, sizeof(w)); w.plan.limits = *limits; w.plan.newline = newline; w.progress = progress; w.context = context;
    error = GOReadStart(source, &limits->read, progress, context, &w.bounds, &w.reader); if (error) return error;
    trees.entries = limits->entries; trees.depth = limits->depth; trees.pathBytes = limits->pathBytes;
    trees.progress = progress; trees.context = context;
    if (base) error = GRFromTreeBounded(&w.reader, base, w.plan.snapshots, &trees);
    if (!error) error = GRFromTreeBounded(&w.reader, current, w.plan.snapshots + 1, &trees);
    if (!error) error = GRFromTreeBounded(&w.reader, other, w.plan.snapshots + 2, &trees);
    if (error) goto done;
    total = w.plan.snapshots[0].count + w.plan.snapshots[1].count + w.plan.snapshots[2].count;
    if (total > limits->nodes) total = limits->nodes;
    w.plan.files = (TMNode *)calloc(total ? total : 1, sizeof(*w.plan.files));
    if (!w.plan.files) { error = GB_MEMORY; goto done; }
    for (i = 0; i < 3; ++i) {
        GRSnapshot *s = w.plan.snapshots + i;
        w.cache[i] = (TMCache *)calloc(s->count ? s->count : 1, sizeof(*w.cache[i]));
        if (!w.cache[i]) { error = GB_MEMORY; goto done; }
        for (j = 0; j < s->count; ++j) if (s->files[j].mode == 0160000) {
            size_t k; const unsigned char *id = s->index.entries[s->files[j].entry].oid;
            for (k = 0; k < 20 && !id[k]; ++k) { }
            if (k == 20) { error = GS_FORMAT; goto done; }
        }
    }
    error = TMRenames(&w, 1); if (!error) error = TMRenames(&w, 2); if (error) goto done;
    for (i = 0; i < w.plan.snapshots[0].count; ++i) {
        error = TMCheck(&w); if (!error) error = TMNodeAdd(&w, i, w.mapping[0][i], w.mapping[1][i]); if (error) goto done;
    }
    for (i = 0; i < w.plan.snapshots[1].count; ++i) if (!w.claimed[0][i]) {
        error = TMCheck(&w); if (error) goto done;
        j = TMFind(w.plan.snapshots + 2, w.plan.snapshots[1].files[i].path);
        if (j != TM_NONE && w.claimed[1][j]) j = TM_NONE;
        error = TMNodeAdd(&w, TM_NONE, i, j); if (error) goto done;
        if (j != TM_NONE) w.claimed[1][j] = 1;
    }
    for (i = 0; i < w.plan.snapshots[2].count; ++i) if (!w.claimed[1][i]) {
        error = TMCheck(&w); if (!error) error = TMNodeAdd(&w, TM_NONE, TM_NONE, i); if (error) goto done;
    }
    error = TMStructure(&w); if (error) goto done;
    for (i = 0; i < w.plan.count; ++i) if (w.plan.files[i].conflicts) ++w.plan.conflicts;
    w.plan.encodedReadBytes = w.bounds.bytes; w.plan.expandedReadBytes = w.bounds.expanded;
    w.plan.readCount = w.bounds.reads; w.plan.pathChecks = w.checks;
    error = TMTick(&w); if (!error) { TMFree(destination); *destination = w.plan; TMInit(&w.plan); }
done:
    for (i = 0; i < 3; ++i) free(w.cache[i]);
    for (i = 0; i < 2; ++i) { free(w.mapping[i]); free(w.claimed[i]); free(w.ambBase[i]); free(w.ambAdded[i]); }
    TMFree(&w.plan); return error;
}

void TMDraftInit(TMDraft *d) { memset(d, 0, sizeof(*d)); }
void TMDraftFree(TMDraft *d) {
    size_t i; GIFree(&d->index); for (i = 0; i < d->count; ++i) free(d->objects[i].bytes);
    free(d->objects); TMDraftInit(d);
}
typedef struct {
    TMDraft draft; const TMPlan *plan; size_t *map, slots, objectCapacity, indexCapacity;
    GOReader bounds; GSRepository reader; GDProgress progress; void *context;
} TMDraftWork;
static int TMDraftTick(TMDraftWork *w) { return w->progress ? w->progress(w->context) : 0; }
static size_t TMHash(const unsigned char id[20], size_t mask) {
    size_t i; GBWord h = 2166136261U; for (i = 0; i < 20; ++i) h = (h ^ id[i]) * 16777619U; return (size_t)h & mask;
}
/* Takes ownership on every path, including deduplication and failure. */
static int TMObjectAdd(TMDraftWork *w, unsigned char *bytes, size_t length, unsigned char id[20]) {
    TMObject *object; size_t at; int error;
    error = TMDraftTick(w); if (!error) error = GBObjectID("blob", bytes, length, id);
    if (error) { free(bytes); return error; }
    if (length > w->plan->limits.read.objectBytes) { free(bytes); return GB_SPACE; }
    at = TMHash(id, w->slots - 1);
    while (w->map[at]) {
        object = w->draft.objects + w->map[at] - 1;
        if (!memcmp(object->oid, id, 20)) {
            error = object->length == length && (!length || !memcmp(object->bytes, bytes, length)) ? 0 : GB_CHECKSUM;
            free(bytes); return error;
        }
        at = (at + 1) & (w->slots - 1);
    }
    if (w->draft.count == w->objectCapacity || length > w->plan->limits.retainedBytes - w->draft.retainedBytes) {
        free(bytes); return GB_SPACE;
    }
    object = w->draft.objects + w->draft.count++; memcpy(object->oid, id, 20); object->bytes = bytes; object->length = length;
    w->draft.retainedBytes += length; w->map[at] = w->draft.count; return 0;
}
static int TMBlobCopy(TMDraftWork *w, const void *bytes, size_t length, unsigned char id[20]) {
    unsigned char *copy;
    if (length > w->plan->limits.read.objectBytes) return GB_SPACE;
    copy = (unsigned char *)malloc(length ? length : 1); if (!copy) return GB_MEMORY;
    if (length) memcpy(copy, bytes, length);
    return TMObjectAdd(w, copy, length, id);
}
static int TMIndexAdd(TMDraftWork *w, const char *path, GBWord mode, const unsigned char id[20], size_t length, int stage) {
    GIEntry *entry;
    if (w->draft.index.count == w->indexCapacity) return GB_SPACE;
    entry = w->draft.index.entries + w->draft.index.count++; entry->path = TMString(path);
    if (!entry->path) return GB_MEMORY;
    entry->stat[6] = mode; entry->stat[9] = (GBWord)length; entry->flags = (unsigned short)(stage << 12);
    memcpy(entry->oid, id, 20); return 0;
}
static int TMMetaAdd(TMDraftWork *w, const char *path, const unsigned char info[32], const void *resource, size_t rn, int stage) {
    unsigned char *body = NULL, id[20]; char key[96]; size_t length; int error;
    error = GIMacMetadataPath(path, key); if (!error) error = GIMacEncode(path, info, resource, rn, &body, &length);
    if (!error) { error = TMObjectAdd(w, body, length, id); body = NULL; }
    if (!error) error = TMIndexAdd(w, key, 0100644, id, length, stage);
    free(body); return error;
}
static int TMIndexOrder(const void *a, const void *b) {
    const GIEntry *x = (const GIEntry *)a, *y = (const GIEntry *)b;
    int order = strcmp(x->path, y->path);
    return order ? order : (int)((x->flags >> 12) & 3) - (int)((y->flags >> 12) & 3);
}
static int TMOriginalAdd(TMDraftWork *w, int side, size_t at, const char *path, int stage, int *haveMeta) {
    const GRSnapshot *snapshot = w->plan->snapshots + side;
    const GRFile *file = snapshot->files + at;
    const GIEntry *entry = snapshot->index.entries + file->entry;
    GRContents contents; char key[96]; int error;
    GRContentsInit(&contents);
    error = TMIndexAdd(w, path, file->mode, entry->oid, file->dataLength, stage);
    if (!error && file->hasFinderInfo) {
        *haveMeta = 1;
        if (!strcmp(path, file->path)) {
            entry = snapshot->index.entries + file->metadataEntry;
            error = GIMacMetadataPath(path, key);
            if (!error) error = TMIndexAdd(w, key, 0100644, entry->oid, 0, stage);
        } else {
            error = GRReadFile(&w->reader, snapshot, at, &contents);
            if (!error) error = TMMetaAdd(w, path, contents.finderInfo, contents.resource, contents.resourceLength, stage);
        }
    }
    GRContentsFree(&contents); return error;
}
static int TMValueAdd(TMDraftWork *w, const char *path, const FMVersion *v, int *haveMeta) {
    unsigned char id[20]; int error = 0;
    if (v->mode == 0160000) memcpy(id, v->gitlink, 20);
    else error = TMBlobCopy(w, v->data, v->dataLength, id);
    if (!error) error = TMIndexAdd(w, path, v->mode, id, v->dataLength, 0);
    if (!error && v->hasFinderInfo) { *haveMeta = 1;
        error = TMMetaAdd(w, path, v->finderInfo, v->resource, v->resourceLength, 0); }
    return error;
}
static int TMOutputValid(const TMPlan *p, const TMOutput *o) {
    const FMVersion *v = &o->file; char key[96]; size_t i, depth = 0;
    if (!o->path || GIMacMetadataPath(o->path, key) ||
        (v->mode != 0100644 && v->mode != 0100755 && v->mode != 0120000 && v->mode != 0160000) ||
        (!v->data && v->dataLength) || (!v->resource && v->resourceLength) ||
        (v->hasFinderInfo != 0 && v->hasFinderInfo != 1) ||
        (!v->hasFinderInfo && v->resourceLength) ||
        ((v->mode & 0170000) != 0100000 && v->hasFinderInfo)) return GB_BAD;
    if (strlen(o->path) > p->limits.pathBytes || v->dataLength > 2097152UL || v->resourceLength > 2097152UL ||
        v->dataLength > p->limits.file.text.outputBytes || v->resourceLength > p->limits.file.resourceBytes) return GB_SPACE;
    for (i = 0; o->path[i]; ++i) if (o->path[i] == '/' && ++depth > p->limits.depth) return GB_SPACE;
    if (v->hasFinderInfo) {
        if (strlen(key) > p->limits.pathBytes) return GB_SPACE;
        depth = 0;
        for (i = 0; key[i]; ++i) if (key[i] == '/' && ++depth > p->limits.depth) return GB_SPACE;
    }
    if (v->mode == 0160000) {
        if (v->dataLength) return GB_BAD;
        for (i = 0; i < 20 && !v->gitlink[i]; ++i) { }
        if (i == 20) return GB_BAD;
    }
    return 0;
}
int TMBuildResolvedIndex(GSRepository *source, const TMPlan *plan, const TMResolution *choices, size_t choiceCount,
                            GDProgress progress, void *context, TMDraft *destination) {
    TMDraftWork w; const TMNode *node; const TMResolution *choice; const GIEntry *version = NULL;
    unsigned char *encoded = NULL; FMVersion value; const char *path, *versionBytes;
    size_t i, j, ci = 0, capacity = 1, length, out = 0; int error, side, haveMeta = 0, stage;
    if (!source || !plan || !destination || !plan->limits.nodes || plan->limits.nodes > 65536UL ||
        plan->count > plan->limits.nodes || choiceCount > plan->count || (!choices && choiceCount)) return GB_BAD;
    /* Bound allocation before touching caller buffers; choices cannot override
       a clean proposal or implicitly resolve a different node. */
    for (i = 0; i < choiceCount; ++i) {
        choice = choices + i;
        if (choice->node >= plan->count || (i && choices[i - 1].node >= choice->node) ||
            !plan->files[choice->node].conflicts || (!choice->outputs && choice->count)) return GB_BAD;
        if (choice->count > 65535UL - out) return GB_SPACE;
        out += choice->count;
        for (j = 0; j < choice->count; ++j) {
            error = TMOutputValid(plan, choice->outputs + j); if (error) return error;
        }
    }
    for (i = 0; i < plan->count; ++i) {
        node = plan->files + i;
        if (ci < choiceCount && choices[ci].node == i) {
            choice = choices + ci++;
            for (j = 0; j < choice->count; ++j) capacity += 1 + choice->outputs[j].file.hasFinderInfo;
        } else if (node->conflicts) {
            for (side = 0; side < 3; ++side) if (node->source[side] != TM_NONE)
                capacity += 1 + plan->snapshots[side].files[node->source[side]].hasFinderInfo;
        } else if (node->selected != -2 && (node->selected != -1 || node->proposal.present)) capacity += 2;
        if (capacity > 65536UL) return GB_SPACE;
    }
    memset(&w, 0, sizeof(w)); w.plan = plan; w.progress = progress; w.context = context;
    error = GOReadStart(source, &plan->limits.read, progress, context, &w.bounds, &w.reader); if (error) return error;
    w.objectCapacity = capacity; w.indexCapacity = capacity; w.slots = 16;
    while (w.slots < w.objectCapacity * 2) w.slots *= 2;
    w.draft.objects = (TMObject *)calloc(w.objectCapacity, sizeof(*w.draft.objects));
    w.draft.index.entries = (GIEntry *)calloc(w.indexCapacity, sizeof(*w.draft.index.entries));
    w.map = (size_t *)calloc(w.slots, sizeof(*w.map));
    if (!w.draft.objects || !w.draft.index.entries || !w.map) { error = GB_MEMORY; goto done; }
    ci = 0;
    for (i = 0; i < plan->count; ++i) {
        error = TMDraftTick(&w); if (error) goto done; node = plan->files + i;
        if (ci < choiceCount && choices[ci].node == i) {
            choice = choices + ci++;
            for (j = 0; j < choice->count; ++j) {
                error = TMDraftTick(&w);
                if (!error) error = TMValueAdd(&w, choice->outputs[j].path, &choice->outputs[j].file, &haveMeta);
                if (error) goto done;
            }
            continue;
        }
        if (node->conflicts) {
            ++w.draft.unresolved;
            for (side = 0; side < 3; ++side) if (node->source[side] != TM_NONE) {
                path = node->conflicts & (TM_DIRECTORY | TM_RENAME_DIVERGENT | TM_RENAME_AMBIGUOUS | TM_PATH_COLLISION)
                    ? plan->snapshots[side].files[node->source[side]].path : node->path;
                error = TMOriginalAdd(&w, side, node->source[side], path, side + 1, &haveMeta);
                if (error) goto done;
            }
            continue;
        }
        if (node->selected == -2 || (node->selected == -1 && !node->proposal.present)) continue;
        if (node->selected >= 0) {
            side = node->selected;
            error = TMOriginalAdd(&w, side, node->source[side], node->path, 0, &haveMeta);
        } else {
            memset(&value, 0, sizeof(value)); value.mode = node->proposal.mode;
            value.data = node->proposal.data.bytes; value.dataLength = node->proposal.data.length;
            value.resource = node->proposal.resource; value.resourceLength = node->proposal.resourceLength;
            value.hasFinderInfo = node->proposal.hasFinderInfo; memcpy(value.finderInfo, node->proposal.finderInfo, 32);
            memcpy(value.gitlink, node->proposal.gitlink, 20);
            error = TMValueAdd(&w, node->path, &value, &haveMeta);
        }
        if (error) goto done;
    }
    if (haveMeta) {
        for (i = 0; i < 3 && !version; ++i) version = GIFind(&plan->snapshots[i].index, GI_MAC_NAMESPACE "/version", 0);
        if (version) error = TMIndexAdd(&w, GI_MAC_NAMESPACE "/version", 0100644, version->oid, 0, 0);
        else {
            unsigned char id[20];
            versionBytes = GIMacVersion(&length); error = TMBlobCopy(&w, versionBytes, length, id);
            if (!error) error = TMIndexAdd(&w, GI_MAC_NAMESPACE "/version", 0100644, id, length, 0);
        }
        if (error) goto done;
    }
    qsort(w.draft.index.entries, w.draft.index.count, sizeof(*w.draft.index.entries), TMIndexOrder);
    /* Shared ambiguity members can refer to the same original. Deduplicate
       only exact path/stage/mode/identity matches; retain every other version. */
    out = 0;
    for (i = 0; i < w.draft.index.count; ++i) {
        GIEntry *entry = w.draft.index.entries + i;
        stage = (entry->flags >> 12) & 3;
        if (out && !TMIndexOrder(w.draft.index.entries + out - 1, entry)) {
            GIEntry *previous = w.draft.index.entries + out - 1;
            if (!stage || previous->stat[6] != entry->stat[6] || memcmp(previous->oid, entry->oid, 20)) { error = GS_CONFLICT; goto done; }
            free(entry->path); entry->path = NULL;
        } else {
            if (out != i) { w.draft.index.entries[out] = *entry; memset(entry, 0, sizeof(*entry)); }
            ++out;
        }
    }
    w.draft.index.count = out;
    error = GIEncode(&w.draft.index, &encoded, &length); free(encoded); encoded = NULL;
    if (error == GB_BAD) error = GS_CONFLICT;
    if (!error) error = TMDraftTick(&w);
    if (!error) { TMDraftFree(destination); *destination = w.draft; TMDraftInit(&w.draft); }
done:
    free(w.map); free(encoded); TMDraftFree(&w.draft); return error;
}
int TMBuildIndex(GSRepository *source, const TMPlan *plan, GDProgress progress, void *context, TMDraft *destination) {
    size_t i;
    if (!source || !plan || !destination || !plan->limits.nodes || plan->count > plan->limits.nodes) return GB_BAD;
    if (plan->conflicts) return GI_UNMERGED;
    for (i = 0; i < plan->count; ++i) if (plan->files[i].conflicts) return GI_UNMERGED;
    return TMBuildResolvedIndex(source, plan, NULL, 0, progress, context, destination);
}
int TMStoreObjects(GSRepository *source, const TMDraft *draft, GDProgress progress, void *context) {
    size_t i; unsigned char id[20]; int error;
    if (!source || !source->read || !source->replace || !draft) return GB_BAD;
    for (i = 0; i < draft->count; ++i) {
        if (progress && (error = progress(context)) != 0) return error;
        error = GBObjectID("blob", draft->objects[i].bytes, draft->objects[i].length, id);
        if (error) return error;
        if (memcmp(id, draft->objects[i].oid, 20)) return GB_CHECKSUM;
    }
    for (i = 0; i < draft->count; ++i) {
        if (progress && (error = progress(context)) != 0) return error;
        error = GSPutObject(source, "blob", draft->objects[i].bytes, draft->objects[i].length, id);
        if (error) return error;
        if (memcmp(id, draft->objects[i].oid, 20)) return GB_CHECKSUM;
    }
    return 0;
}
