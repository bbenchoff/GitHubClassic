#include "SSLWrapper.h"
#include "TrustRoots.h"
#include "ServerRoots.h"
#include "platform_util.h"
#include "ssl_ciphersuites.h"
#include <OSUtils.h>
#include <Script.h>
#include <string.h>
#include <stdlib.h>
#include "CryptoCheck.c"

typedef struct { const unsigned char *bytes; size_t left; } SeedInput;
static int NoReseed(void *,unsigned char *,size_t);
static int SeedRead(void *context, unsigned char *out, size_t size) {
    SeedInput *seed=(SeedInput*)context;
    if(size>seed->left) return SSL_NO_SEED;
    memcpy(out,seed->bytes,size); seed->bytes+=size; seed->left-=size;
    return 0;
}
static int Yield(SSLState *s) {
    if(s->pump && s->pump(s->context)) return SSL_CANCELLED;
    if((unsigned long)(TickCount()-s->started)>60UL*120UL) return SSL_TIMEOUT;
    return 0;
}
static int SendBIO(void *context, const unsigned char *buf, size_t size) {
    SSLState *s=(SSLState*)context; OTResult n;
    n=OTSnd(s->endpoint,(void*)buf,size,0);
    if(n==kOTFlowErr) return MBEDTLS_ERR_SSL_WANT_WRITE;
    if(n<0){s->transportError=n;s->transportEvent=OTLook(s->endpoint);}
    return n>=0 ? (int)n : MBEDTLS_ERR_SSL_INTERNAL_ERROR;
}
static int ReceiveBIO(void *context, unsigned char *buf, size_t size) {
    SSLState *s=(SSLState*)context; OTFlags flags=0; OTResult n;
    n=OTRcv(s->endpoint,buf,size,&flags);
    if(n==kOTNoDataErr) return MBEDTLS_ERR_SSL_WANT_READ;
    if(n==kOTLookErr && OTLook(s->endpoint)==T_ORDREL) {
        OTRcvOrderlyDisconnect(s->endpoint); return 0;
    }
    if(n<0){s->transportError=n;s->transportEvent=OTLook(s->endpoint);}
    return n>=0 ? (int)n : MBEDTLS_ERR_SSL_INTERNAL_ERROR;
}
static int CompareTime(const mbedtls_x509_time *t, const DateTimeRec *now) {
    int a[6],b[6],i;
    a[0]=t->year; a[1]=t->mon; a[2]=t->day;
    a[3]=t->hour; a[4]=t->min; a[5]=t->sec;
    b[0]=now->year; b[1]=now->month; b[2]=now->day;
    b[3]=now->hour; b[4]=now->minute; b[5]=now->second;
    for(i=0;i<6;++i) if(a[i]!=b[i]) return a[i]<b[i] ? -1 : 1;
    return 0;
}
/* Mbed TLS's Unix-time port is absent in the inherited CW project. Check every
   chain member here using the Macintosh clock converted from local time to UTC.
   Verification flags are only ADDED; hostname/signature/trust failures survive. */
static int CheckDate(void *context, mbedtls_x509_crt *crt, int depth, uint32_t *flags) {
    unsigned long seconds; long delta; MachineLocation location; DateTimeRec now;
    SSLState *s=(SSLState*)context;
    GetDateTime(&seconds); ReadLocation(&location);
    delta=location.u.gmtDelta & 0x00ffffffL;
    if(delta&0x00800000L) delta|=0xff000000L;
    seconds-=delta; SecondsToDate(seconds,&now);
    if(CompareTime(&crt->valid_from,&now)>0) *flags|=MBEDTLS_X509_BADCERT_FUTURE;
    if(CompareTime(&crt->valid_to,&now)<0) *flags|=MBEDTLS_X509_BADCERT_EXPIRED;
    if(s){++s->certificateChecks;if(depth>=0 && depth<8)s->certificateFlags[depth]=*flags;}
    return 0;
}
static const int gGitHubSuites[]={MBEDTLS_TLS_ECDHE_RSA_WITH_AES_128_GCM_SHA256,0};
static const mbedtls_ecp_group_id gGitHubCurves[]={MBEDTLS_ECP_DP_SECP256R1,MBEDTLS_ECP_DP_NONE};
/* Other servers commonly present ECDSA certificates and P-384 chains. Both
   suites keep ephemeral ECDH and AES-GCM; verification stays required. */
static const int gServerSuites[]={MBEDTLS_TLS_ECDHE_ECDSA_WITH_AES_128_GCM_SHA256,
    MBEDTLS_TLS_ECDHE_RSA_WITH_AES_128_GCM_SHA256,0};
static const mbedtls_ecp_group_id gServerCurves[]={MBEDTLS_ECP_DP_SECP256R1,MBEDTLS_ECP_DP_SECP384R1,MBEDTLS_ECP_DP_NONE};
int SSL_Initialize(SSLState *s, const unsigned char seed[64], SSLPump pump, void *context) {
    SeedInput input; int error;
    static const int hashes[]={MBEDTLS_MD_SHA256,MBEDTLS_MD_SHA384,MBEDTLS_MD_NONE};
    /* RSA certificate verification avoids the slow P384 certificate chain on
       the 68K emulator. This still uses ephemeral P256 ECDH and AES-GCM, with
       required chain, hostname and date verification. Native timing and
       refusal evidence must accompany this profile before release. */
    if(!s || !seed) return SSL_NO_SEED;
    memset(s,0,sizeof(*s)); s->endpoint=kOTInvalidEndpointRef;
    s->pump=pump; s->context=context; s->initialized=1;
    mbedtls_ssl_init(&s->ssl); mbedtls_ssl_config_init(&s->conf);
    mbedtls_ctr_drbg_init(&s->random); mbedtls_x509_crt_init(&s->roots);
    s->started=TickCount();error=CryptoCheck();s->cryptoTicks=TickCount()-s->started;if(error)goto fail;
    input.bytes=seed; input.left=64;
    error=mbedtls_ctr_drbg_seed(&s->random,SeedRead,&input,
                              (const unsigned char*)"GHClient MacSSL",15);
    /* SeedRead has stack lifetime: never retain it as a reseed callback. Once
       seeded, fail closed when the reseed interval is reached. */
    s->random.f_entropy=NoReseed; s->random.p_entropy=NULL;
    if(error) goto fail;
    error=mbedtls_x509_crt_parse(&s->roots,(const unsigned char*)GH_ROOT_PEM,sizeof(GH_ROOT_PEM));
    if(error) goto fail;
    error=mbedtls_ssl_config_defaults(&s->conf,MBEDTLS_SSL_IS_CLIENT,
                                    MBEDTLS_SSL_TRANSPORT_STREAM,MBEDTLS_SSL_PRESET_DEFAULT);
    if(error) goto fail;
    mbedtls_ssl_conf_rng(&s->conf,mbedtls_ctr_drbg_random,&s->random);
    mbedtls_ssl_conf_authmode(&s->conf,MBEDTLS_SSL_VERIFY_REQUIRED);
    mbedtls_ssl_conf_ca_chain(&s->conf,&s->roots,NULL);
    mbedtls_ssl_conf_verify(&s->conf,CheckDate,s);
    mbedtls_ssl_conf_sig_hashes(&s->conf,hashes);
    mbedtls_ssl_conf_ciphersuites(&s->conf,gGitHubSuites);
    mbedtls_ssl_conf_curves(&s->conf,gGitHubCurves);
    mbedtls_ssl_conf_min_version(&s->conf,3,3);
    mbedtls_ssl_conf_max_version(&s->conf,3,3);
    error=mbedtls_ssl_setup(&s->ssl,&s->conf);
    if(!error) return 0;
fail:
    SSL_Close(s); return error;
}
/* Called instead of the one-shot seed callback on a future automatic reseed. */
static int NoReseed(void *ctx,unsigned char *out,size_t size) {
    (void)ctx; (void)out; (void)size; return SSL_NO_SEED;
}
int SSL_SetServerRoots(SSLState *s,const unsigned char *extra,size_t length) {
    unsigned char *copy=NULL;int error;
    if(!s || !s->initialized || s->plain || (length && !extra) || length>262144UL) return paramErr;
    if(s->connected) SSL_Disconnect(s);
    SSL_ServerProfile(s,0);
    if(s->haveServerRoots){mbedtls_x509_crt_free(&s->serverRoots);s->haveServerRoots=0;}
    mbedtls_x509_crt_init(&s->serverRoots);
    error=mbedtls_x509_crt_parse(&s->serverRoots,(const unsigned char*)GH_ROOT_PEM,sizeof(GH_ROOT_PEM));
    if(!error) error=mbedtls_x509_crt_parse(&s->serverRoots,(const unsigned char*)GH_SERVER_ROOT_PEM,sizeof(GH_SERVER_ROOT_PEM));
    if(!error && length) {
        /* PEM parsing needs a terminator; DER is passed with its exact length.
           A partly readable bundle is refused, not silently shortened. */
        copy=(unsigned char*)malloc(length+1);
        if(!copy) error=MBEDTLS_ERR_X509_ALLOC_FAILED;
        else {
            memcpy(copy,extra,length);copy[length]=0;
            if(strlen((char*)copy)==length && strstr((char*)copy,"-----BEGIN CERTIFICATE-----"))
                error=mbedtls_x509_crt_parse(&s->serverRoots,copy,length+1);
            else error=mbedtls_x509_crt_parse_der(&s->serverRoots,copy,length);
            if(error>0) error=MBEDTLS_ERR_X509_INVALID_FORMAT;
            free(copy);
        }
    }
    if(error){mbedtls_x509_crt_free(&s->serverRoots);return error;}
    s->haveServerRoots=1;return 0;
}
int SSL_ServerProfile(SSLState *s,int server) {
    if(!s || !s->initialized || s->plain) return paramErr;
    if(server && !s->haveServerRoots) return paramErr;
    mbedtls_ssl_conf_ca_chain(&s->conf,server?&s->serverRoots:&s->roots,NULL);
    mbedtls_ssl_conf_ciphersuites(&s->conf,server?gServerSuites:gGitHubSuites);
    mbedtls_ssl_conf_curves(&s->conf,server?gServerCurves:gGitHubCurves);
    return 0;
}
static OSStatus OpenTCP(SSLState *s,InetAddress *address) {
    TBind bind; TCall call; OSStatus error; int ret;
    s->endpoint=OTOpenEndpoint(OTCreateConfiguration(kTCPName),0,NULL,&error);
    if(error) return error;
    memset(&bind,0,sizeof(bind)); error=OTBind(s->endpoint,&bind,NULL);
    if(error) return error;
    memset(&call,0,sizeof(call)); call.addr.buf=(UInt8*)address;
    call.addr.len=sizeof(*address); call.addr.maxlen=sizeof(*address);
    error=OTSetNonBlocking(s->endpoint); if(error) return error;
    error=OTConnect(s->endpoint,&call,NULL);
    if(error==kOTNoDataErr) {
        do { ret=Yield(s); if(ret) return ret;
             error=OTRcvConnect(s->endpoint,NULL);
        } while(error==kOTNoDataErr);
    }
    return error;
}
int SSL_InitializePlain(SSLState *s,SSLPump pump,void *context) {
    if(!s) return paramErr;
    memset(s,0,sizeof(*s)); s->endpoint=kOTInvalidEndpointRef;
    s->pump=pump; s->context=context; s->initialized=1; s->plain=1;
    return 0;
}
int SSL_ConnectPlain(SSLState *s,const char *peer,InetAddress *address) {
    OSStatus error;
    if(!s || !s->initialized || !s->plain || !peer || !peer[0] || strlen(peer)>=sizeof(s->peerName)) return paramErr;
    SSL_Disconnect(s); s->started=TickCount();s->transportError=s->transportEvent=0;
    error=OpenTCP(s,address);
    if(error){SSL_Disconnect(s);return (int)error;}
    s->connectTicks=TickCount()-s->started;
    strcpy(s->peerName,peer);++s->connectionSerial;
    if(!s->connectionSerial)++s->connectionSerial;
    s->connected=1; return 0;
}
int SSL_Connect(SSLState *s,const char *hostname,InetAddress *address) {
    OSStatus error; int ret,state;unsigned long phaseStart;
    if(!s || !s->initialized || s->plain || !hostname || !hostname[0] || strlen(hostname)>=sizeof(s->peerName)) return paramErr;
    SSL_Disconnect(s); s->started=TickCount();s->transportError=s->transportEvent=0;s->handshakeTicks=0;
    s->connectTicks=0;s->certificateChecks=0;s->verifyFlags=0xffffffffUL;s->lastHandshakeState=-1;
    memset(s->phaseTicks,0,sizeof(s->phaseTicks));memset(s->certificateFlags,0,sizeof(s->certificateFlags));
    s->random.f_entropy=NoReseed; s->random.p_entropy=NULL;
    ret=mbedtls_ssl_session_reset(&s->ssl); if(ret) return ret;
    ret=mbedtls_ssl_set_hostname(&s->ssl,hostname); if(ret) return ret;
    error=OpenTCP(s,address);
    if(error) goto failure;
    s->connectTicks=TickCount()-s->started;
    mbedtls_ssl_set_bio(&s->ssl,s,SendBIO,ReceiveBIO,NULL);
    while(s->ssl.state!=MBEDTLS_SSL_HANDSHAKE_OVER) {
        ret=Yield(s); if(ret) { error=ret; goto failure; }
        state=s->ssl.state;s->lastHandshakeState=state;phaseStart=TickCount();
        ret=mbedtls_ssl_handshake_step(&s->ssl);
        if(state>=0 && state<32)s->phaseTicks[state]+=TickCount()-phaseStart;
        if(ret && ret!=MBEDTLS_ERR_SSL_WANT_READ && ret!=MBEDTLS_ERR_SSL_WANT_WRITE) {error=ret;goto failure;}
    }
    s->handshakeTicks=TickCount()-s->started;
    s->verifyFlags=mbedtls_ssl_get_verify_result(&s->ssl);
    if(s->verifyFlags) { error=MBEDTLS_ERR_X509_CERT_VERIFY_FAILED; goto failure; }
    strcpy(s->peerName,hostname);++s->connectionSerial;
    if(!s->connectionSerial)++s->connectionSerial;
    s->connected=1; return 0;
failure:
    s->handshakeTicks=TickCount()-s->started;s->verifyFlags=mbedtls_ssl_get_verify_result(&s->ssl);
    SSL_Disconnect(s); return (int)error;
}
int SSL_CanReuse(SSLState *s,const char *hostname) {
    return s && s->initialized && s->connected && hostname &&
        !strcmp(s->peerName,hostname) && s->endpoint!=kOTInvalidEndpointRef &&
        (s->plain || !mbedtls_ssl_get_bytes_avail(&s->ssl)) && OTLook(s->endpoint)==0;
}
void SSL_BeginIO(SSLState *s) {
    if(s && s->connected)s->started=TickCount();
}
int SSL_Send(SSLState *s,const void *buffer,size_t size) {
    const unsigned char *p=(const unsigned char*)buffer; int n,error;
    if(!s->connected) return paramErr;
    while(size) {
        error=Yield(s); if(error) return error;
        n=s->plain ? SendBIO(s,p,size) : mbedtls_ssl_write(&s->ssl,p,size);
        if(n==MBEDTLS_ERR_SSL_WANT_READ || n==MBEDTLS_ERR_SSL_WANT_WRITE) continue;
        if(n<=0) return n ? n : MBEDTLS_ERR_SSL_INTERNAL_ERROR;
        s->started=TickCount(); /* The I/O deadline measures inactivity. */
        p+=n; size-=n;
    }
    return 0;
}
int SSL_Receive(SSLState *s,void *buffer,size_t size) {
    int n,error;
    if(!s->connected) return paramErr;
    do {
        error=Yield(s); if(error) return error;
        n=s->plain ? ReceiveBIO(s,(unsigned char*)buffer,size) : mbedtls_ssl_read(&s->ssl,buffer,size);
    } while(n==MBEDTLS_ERR_SSL_WANT_READ || n==MBEDTLS_ERR_SSL_WANT_WRITE);
    /* A plain peer's orderly close ends the response; TLS needs its notify. */
    if(s->plain && n==0) return 0;
    if(n==MBEDTLS_ERR_SSL_PEER_CLOSE_NOTIFY) return 0;
    if(n==0) return MBEDTLS_ERR_SSL_CONN_EOF;
    if(n>0)s->started=TickCount();
    return n;
}
void SSL_Disconnect(SSLState *s) {
    if(!s || !s->initialized) return;
    if(s->endpoint!=kOTInvalidEndpointRef) OTCloseProvider(s->endpoint);
    s->endpoint=kOTInvalidEndpointRef; s->connected=0;s->peerName[0]=0;
}
void SSL_Close(SSLState *s) {
    if(!s || !s->initialized) return;
    SSL_Disconnect(s);
    if(!s->plain) {
        mbedtls_ssl_free(&s->ssl); mbedtls_ssl_config_free(&s->conf);
        mbedtls_ctr_drbg_free(&s->random); mbedtls_x509_crt_free(&s->roots);
        if(s->haveServerRoots) mbedtls_x509_crt_free(&s->serverRoots);
    }
    mbedtls_platform_zeroize(s,sizeof(*s)); s->endpoint=kOTInvalidEndpointRef;
}
