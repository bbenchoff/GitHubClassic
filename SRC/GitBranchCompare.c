#include "GitBranchCompare.h"
#include "GitHistory.h"
#include <stdlib.h>
#include <string.h>
typedef struct {
    GSRepository *source;
    const BCLimits *limits;
    int (*progress)(void *);
    void *context;
    size_t encoded, expanded, reads;
} BCReader;
typedef struct {
    BCGraph graph;
    size_t capacity, parentCapacity, slots, *map;
    const BCLimits *limits;
} BCWork;
void BCInit(BCGraph *g) { memset(g, 0, sizeof(*g)); }
void BCFree(BCGraph *g) {
    free(g->nodes); free(g->parents); free(g->order); BCInit(g);
}
static int BCTick(BCReader *r) { return r->progress ? r->progress(r->context) : 0; }
static int BCNoWrite(void *context, const char *key, const void *a, size_t an,
                        const void *b, size_t bn) {
    (void)context; (void)key; (void)a; (void)an; (void)b; (void)bn; return GB_BAD;
}
static int BCRead(void *context, const char *key, unsigned char **bytes, size_t *length) {
    BCReader *r = (BCReader *)context;
    int error;
    *bytes = NULL; *length = 0;
    if (strncmp(key, "objects/", 8)) return GB_BAD;
    if (r->reads == r->limits->reads) return GB_SPACE;
    error = BCTick(r); if (error) return error;
    ++r->reads;
    error = r->source->read(r->source->context, key, bytes, length);
    if (!error && (*length > r->limits->encodedBytes ||
                   *length > r->limits->readBytes - r->encoded)) error = GB_SPACE;
    if (error) { free(*bytes); *bytes = NULL; *length = 0; }
    else r->encoded += *length;
    return error;
}
static int BCNonzero(const unsigned char *id) {
    size_t i;
    for (i = 0; i < 20; ++i) if (id[i]) return 1;
    return 0;
}
static size_t BCHash(const unsigned char *id, size_t mask) {
    size_t i;
    GBWord h = 2166136261U;
    for (i = 0; i < 20; ++i) h = (h ^ id[i]) * 16777619U;
    return (size_t)h & mask;
}
static int BCAdd(BCWork *w, const unsigned char *id, size_t *index) {
    size_t at, i, capacity;
    BCNode *grown;
    if (!BCNonzero(id)) return GS_FORMAT;
    at = BCHash(id, w->slots - 1);
    while (w->map[at]) {
        i = w->map[at] - 1;
        if (!memcmp(w->graph.nodes[i].oid, id, 20)) { *index = i; return 0; }
        at = (at + 1) & (w->slots - 1);
    }
    if (w->graph.count == w->limits->commits) return GB_SPACE;
    if (w->graph.count == w->capacity) {
        capacity = w->capacity ? w->capacity * 2 : 16;
        if (capacity < w->capacity || capacity > w->limits->commits) capacity = w->limits->commits;
        grown = (BCNode *)realloc(w->graph.nodes, capacity * sizeof(*grown));
        if (!grown) return GB_MEMORY;
        w->graph.nodes = grown; w->capacity = capacity;
    }
    *index = w->graph.count++;
    memset(w->graph.nodes + *index, 0, sizeof(BCNode));
    memcpy(w->graph.nodes[*index].oid, id, 20);
    w->map[at] = *index + 1;
    return 0;
}
static int BCEdges(BCWork *w, size_t wanted) {
    size_t capacity;
    size_t *grown;
    if (wanted > w->limits->parents - w->graph.parentCount) return GB_SPACE;
    wanted += w->graph.parentCount;
    if (wanted <= w->parentCapacity) return 0;
    capacity = w->parentCapacity ? w->parentCapacity : 16;
    while (capacity < wanted) {
        if (capacity > w->limits->parents / 2) { capacity = w->limits->parents; break; }
        capacity *= 2;
    }
    if (capacity > w->limits->parents) capacity = w->limits->parents;
    grown = (size_t *)realloc(w->graph.parents, capacity * sizeof(*grown));
    if (!grown) return GB_MEMORY;
    w->graph.parents = grown; w->parentCapacity = capacity;
    return 0;
}
static int BCParents(BCWork *w, BCReader *reader, size_t node,
                        const unsigned char *body, size_t length) {
    GHCommitInfo info;
    size_t at = 46, end, parent, first = w->graph.parentCount;
    unsigned char id[20];
    char hex[41];
    int error = GHCommitParse(body, length, &info);
    if (error) return error;
    error = BCEdges(w, (size_t)info.parents);
    if (error) return error;
    while (at < info.messageOffset - 1) {
        end = at;
        while (end < info.messageOffset && body[end] != '\n') ++end;
        if (end - at >= 7 && !memcmp(body + at, "parent ", 7)) {
            error = BCTick(reader); if (error) return error;
            memcpy(hex, body + at + 7, 40); hex[40] = 0;
            error = GBOIDParse(hex, id);
            if (!error) error = BCAdd(w, id, &parent);
            if (error) return error;
            w->graph.parents[w->graph.parentCount++] = parent;
        }
        at = end + 1;
    }
    if (w->graph.parentCount - first != (size_t)info.parents) return GS_FORMAT;
    /* BCAdd may have moved nodes. Never retain a node pointer across it. */
    w->graph.nodes[node].parentFirst = first;
    w->graph.nodes[node].parentCount = (size_t)info.parents;
    return 0;
}
static int BCOrder(BCGraph *g, BCReader *reader) {
    size_t *children = NULL, i, j, parent, used = 0, at;
    unsigned char *covered = NULL;
    BCNode *node;
    int error = GB_MEMORY;
    children = (size_t *)calloc(g->count, sizeof(*children));
    covered = (unsigned char *)calloc(g->count, 1);
    g->order = (size_t *)malloc(g->count * sizeof(*g->order));
    if (!children || !covered || !g->order) goto done;
    for (i = 0; i < g->parentCount; ++i) ++children[g->parents[i]];
    for (i = 0; i < g->count; ++i) if (!children[i]) g->order[used++] = i;
    error = 0;
    for (at = 0; at < used; ++at) {
        error = BCTick(reader); if (error) goto done;
        i = g->order[at]; node = g->nodes + i;
        if (node->reach == BC_LEFT) ++g->onlyLeft;
        else if (node->reach == BC_RIGHT) ++g->onlyRight;
        else if (node->reach == (BC_LEFT | BC_RIGHT)) {
            ++g->common;
            if (!covered[i]) { node->base = 1; ++g->bases; }
        } else { error = GS_FORMAT; goto done; }
        for (j = 0; j < node->parentCount; ++j) {
            error = BCTick(reader); if (error) goto done;
            parent = g->parents[node->parentFirst + j];
            g->nodes[parent].reach |= node->reach;
            if (covered[i] || node->reach == (BC_LEFT | BC_RIGHT)) covered[parent] = 1;
            if (!--children[parent]) g->order[used++] = parent;
        }
    }
    if (used != g->count) error = GS_FORMAT;
done:
    free(children); free(covered); return error;
}
int BCBuild(GSRepository *source, const unsigned char left[20], const unsigned char right[20],
               const BCLimits *limits, int (*progress)(void *), void *context, BCGraph *destination) {
    BCWork work;
    BCReader state;
    GSRepository reader;
    size_t i, index, n, maximum;
    unsigned char *body = NULL;
    char type[7];
    int error;
    if (!source || !source->read || !left || !right || !BCNonzero(left) || !BCNonzero(right) ||
        !destination || !limits || !limits->commits || !limits->objectBytes ||
        !limits->encodedBytes || !limits->readBytes || !limits->reads) return GB_BAD;
    if (limits->commits > (size_t)-1 / sizeof(BCNode) ||
        limits->parents > (size_t)-1 / sizeof(size_t)) return GB_SPACE;
    memset(&work, 0, sizeof(work)); memset(&state, 0, sizeof(state));
    work.limits = limits; work.slots = 1;
    while (work.slots < limits->commits) {
        if (work.slots > (size_t)-1 / 2) return GB_SPACE;
        work.slots *= 2;
    }
    if (work.slots > (size_t)-1 / 2 || work.slots * 2 > (size_t)-1 / sizeof(size_t)) return GB_SPACE;
    work.slots *= 2; work.map = (size_t *)calloc(work.slots, sizeof(size_t));
    if (!work.map) return GB_MEMORY;
    state.source = source; state.limits = limits; state.progress = progress; state.context = context;
    reader.context = &state; reader.read = BCRead; reader.replace = BCNoWrite;
    error = BCAdd(&work, left, &index);
    if (!error) work.graph.nodes[index].reach = BC_LEFT;
    if (!error) error = BCAdd(&work, right, &index);
    if (!error) work.graph.nodes[index].reach |= BC_RIGHT;
    for (i = 0; !error && i < work.graph.count; ++i) {
        maximum = limits->readBytes - state.expanded;
        if (maximum > limits->objectBytes) maximum = limits->objectBytes;
        error = GSGetObjectLimit(&reader, work.graph.nodes[i].oid, type, &body, &n, maximum);
        if (!error) {
            state.expanded += n;
            error = strcmp(type, "commit") ? GS_FORMAT : BCParents(&work, &state, i, body, n);
        }
        free(body); body = NULL;
    }
    if (!error) error = BCOrder(&work.graph, &state);
    if (!error) {
        work.graph.encodedReadBytes = state.encoded; work.graph.expandedReadBytes = state.expanded;
        work.graph.readCount = state.reads;
        memcpy(work.graph.left, left, 20); memcpy(work.graph.right, right, 20);
        BCFree(destination); *destination = work.graph; BCInit(&work.graph);
    }
    BCFree(&work.graph); free(work.map); return error;
}
const BCNode *BCCommitAt(const BCGraph *g, unsigned side, size_t ordinal) {
    size_t i;
    const BCNode *node;
    if (!g || (side != BC_LEFT && side != BC_RIGHT)) return NULL;
    for (i = 0; i < g->count; ++i) {
        node = g->nodes + g->order[i];
        if (node->reach == side && !ordinal--) return node;
    }
    return NULL;
}
const BCNode *BCBaseAt(const BCGraph *g, size_t ordinal) {
    size_t i;
    const BCNode *node;
    if (!g) return NULL;
    for (i = 0; i < g->count; ++i) {
        node = g->nodes + g->order[i];
        if (node->base && !ordinal--) return node;
    }
    return NULL;
}
