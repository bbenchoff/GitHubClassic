#include "GHAuth.h"
#include "GHCore.h"
#include <stdlib.h>
#include <string.h>

void OAClear(void *p, size_t n) {
    volatile unsigned char *v = (volatile unsigned char *)p;
    while (n--)
        *v++ = 0;
}
void OAInit(OAFlow *f) { memset(f, 0, sizeof(*f)); }
static int OATerminal(OAFlow *f, int state) {
    OAClear(f->device, sizeof(f->device));
    OAClear(f->userCode, sizeof(f->userCode));
    f->state = state;
    return OA_BAD_RESPONSE;
}
void OACancel(OAFlow *f) { OATerminal(f, OA_CANCELLED); }
int OAClientValid(const char *s) {
    size_t i;
    if (!s || !*s || strlen(s) > 128)
        return 0;
    for (i = 0; s[i]; ++i)
        if (!((s[i] >= 'a' && s[i] <= 'z') || (s[i] >= 'A' && s[i] <= 'Z') ||
              (s[i] >= '0' && s[i] <= '9') || s[i] == '_' || s[i] == '-'))
            return 0;
    return 1;
}
static unsigned long OAElapsed(unsigned long now, unsigned long then) {
    return (now - then) & 0xffffffffUL;
}
static int OAAppend(char *out, size_t cap, const char *name, const char *value) {
    char *encoded;
    size_t used = strlen(out), n = strlen(value);
    int error = -1;
    if (n > (32768UL - 1) / 3)
        return -1;
    encoded = (char *)malloc(n * 3 + 1);
    if (!encoded)
        return -1;
    if (!GHURLEncode(value, encoded, n * 3 + 1) &&
        used + strlen(name) + strlen(encoded) + 2 + (used != 0) < cap) {
        if (used)
            strcat(out, "&");
        strcat(out, name);
        strcat(out, "=");
        strcat(out, encoded);
        error = 0;
    }
    OAClear(encoded, n * 3 + 1);
    free(encoded);
    return error;
}
int OAStartForm(OAFlow *f, const char *client, int privateAccess, char *out, size_t cap) {
    if (!f || !out || !cap)
        return OA_BAD_RESPONSE;
    OAInit(f);
    out[0] = 0;
    if (!OAClientValid(client))
        return OA_BAD_RESPONSE;
    strcpy(f->client, client);
    f->privateAccess = privateAccess != 0;
    if (OAAppend(out, cap, "client_id", client) ||
        OAAppend(out, cap, "scope",
                 privateAccess ? "repo offline_access" : "public_repo offline_access")) {
        OAClear(out, cap);
        return OATerminal(f, OA_FAILED);
    }
    return 0;
}
static void OAString(GHJSONMember *m, const char *name, char *out, size_t cap, int required) {
    memset(m, 0, sizeof(*m));
    m->name = name;
    m->text = out;
    m->capacity = cap;
    m->kind = 1;
    m->required = required;
}
static void OANumber(GHJSONMember *m, const char *name, unsigned long *out, int required) {
    memset(m, 0, sizeof(*m));
    m->name = name;
    m->number = out;
    m->kind = 2;
    m->required = required;
}
int OADeviceReply(OAFlow *f, const char *json, size_t n, unsigned long now) {
    char url[128];
    unsigned long life = 0, interval = 0;
    size_t i;
    GHJSONMember m[5];
    OAString(m, "device_code", f->device, sizeof(f->device), 1);
    OAString(m + 1, "user_code", f->userCode, sizeof(f->userCode), 1);
    OAString(m + 2, "verification_uri", url, sizeof(url), 1);
    OANumber(m + 3, "expires_in", &life, 1);
    OANumber(m + 4, "interval", &interval, 0);
    if (f->state != OA_IDLE || n > 32768UL || GHJSONMembers(json, n, m, 5) || !f->device[0] ||
        !f->userCode[0] || strcmp(url, "https://github.com/login/device") || !life ||
        life > 86400UL)
        return OATerminal(f, OA_FAILED);
    for (i = 0; f->userCode[i]; ++i)
        if (!((f->userCode[i] >= 'A' && f->userCode[i] <= 'Z') ||
              (f->userCode[i] >= '0' && f->userCode[i] <= '9') || f->userCode[i] == '-'))
            return OATerminal(f, OA_FAILED);
    if (!m[4].present)
        interval = 5;
    if (!interval || interval > 3600UL)
        return OATerminal(f, OA_FAILED);
    f->started = f->lastPoll = now;
    f->lifetime = life;
    f->interval = interval;
    f->state = OA_WAITING;
    return 0;
}
int OAPollForm(OAFlow *f, unsigned long now, char *out, size_t cap) {
    if (!out || !cap)
        return OA_BAD_RESPONSE;
    out[0] = 0;
    if (f->state != OA_WAITING)
        return OA_BAD_RESPONSE;
    if (OAElapsed(now, f->started) >= f->lifetime)
        return OATerminal(f, OA_EXPIRED);
    if (OAElapsed(now, f->lastPoll) < f->interval)
        return OA_NOT_DUE;
    if (OAAppend(out, cap, "client_id", f->client) ||
        OAAppend(out, cap, "device_code", f->device) ||
        OAAppend(out, cap, "grant_type", "urn:ietf:params:oauth:grant-type:device_code")) {
        OAClear(out, cap);
        return OATerminal(f, OA_FAILED);
    }
    f->lastPoll = now;
    return 0;
}
int OAHasScope(const char *scopes, const char *wanted) {
    const char *start;
    size_t n = strlen(wanted);
    while (*scopes) {
        while (*scopes == ' ' || *scopes == ',')
            ++scopes;
        start = scopes;
        while (*scopes && *scopes != ' ' && *scopes != ',')
            ++scopes;
        if ((size_t)(scopes - start) == n && !memcmp(start, wanted, n))
            return 1;
    }
    return 0;
}
static int OASecretValid(const char *s) {
    if (!*s)
        return 0;
    while (*s) {
        if ((unsigned char)*s < 33 || (unsigned char)*s > 126)
            return 0;
        ++s;
    }
    return 1;
}
static int OAReadToken(const char *json, size_t n, unsigned long now, OACredentials *out,
                       char error[128], unsigned long *interval) {
    char type[32];
    GHJSONMember m[8];
    OAString(m, "access_token", out->access, sizeof(out->access), 0);
    OAString(m + 1, "refresh_token", out->refresh, sizeof(out->refresh), 0);
    OAString(m + 2, "scope", out->scope, sizeof(out->scope), 0);
    OAString(m + 3, "token_type", type, sizeof(type), 0);
    OANumber(m + 4, "expires_in", &out->expires, 0);
    OANumber(m + 5, "refresh_token_expires_in", &out->refreshExpires, 0);
    OAString(m + 6, "error", error, 128, 0);
    OANumber(m + 7, "interval", interval, 0);
    OAClear(out, sizeof(*out));
    if (n > 32768UL || GHJSONMembers(json, n, m, 8))
        goto bad;
    if (m[6].present) {
        if (!error[0] || m[0].present || m[1].present || m[2].present || m[3].present ||
            m[4].present || m[5].present)
            goto bad;
        return OA_PENDING;
    }
    if (!OASecretValid(out->access) || strcmp(type, "bearer") || !m[2].present)
        goto bad;
    if (out->refresh[0]) {
        if (!OASecretValid(out->refresh))
            goto bad;
        if (!out->expires || !out->refreshExpires || out->expires >= 0x80000000UL ||
            out->refreshExpires >= 0x80000000UL)
            goto bad;
    } else if (m[1].present || m[4].present || m[5].present)
        goto bad;
    out->issued = now;
    out->deviceIssued = 1;
    return 0;
bad:
    OAClear(out, sizeof(*out));
    return OA_BAD_RESPONSE;
}
int OATokenReply(OAFlow *f, const char *json, size_t n, unsigned long now, OACredentials *out) {
    char error[128];
    unsigned long interval = 0;
    int r;
    OAClear(out, sizeof(*out));
    if (f->state != OA_WAITING)
        return OA_BAD_RESPONSE;
    if (OAElapsed(now, f->started) >= f->lifetime)
        return OATerminal(f, OA_EXPIRED);
    r = OAReadToken(json, n, now, out, error, &interval);
    if (r == OA_PENDING) {
        if (!strcmp(error, "authorization_pending"))
            return OA_PENDING;
        if (!strcmp(error, "slow_down")) {
            if (f->interval > 3595 || interval > 3600)
                return OATerminal(f, OA_FAILED);
            f->interval += 5;
            if (interval > f->interval)
                f->interval = interval;
            return OA_PENDING;
        }
        if (!strcmp(error, "access_denied"))
            return OATerminal(f, OA_DENIED);
        if (!strcmp(error, "expired_token") || !strcmp(error, "token_expired"))
            return OATerminal(f, OA_EXPIRED);
    }
    if (r)
        return OATerminal(f, OA_FAILED);
    if (!OAHasScope(out->scope, f->privateAccess ? "repo" : "public_repo") &&
        !(f->privateAccess == 0 && OAHasScope(out->scope, "repo"))) {
        OAClear(out, sizeof(*out));
        OATerminal(f, OA_FAILED);
        return OA_PERMISSION;
    }
    strcpy(out->clientID, f->client);
    OATerminal(f, OA_VERIFY);
    return 0;
}
int OAAccount(OACredentials *c, const char *json, size_t n, const char *expected) {
    char login[128], id[32];
    size_t i;
    GHJSONMember m[2];
    OAString(m, "login", login, sizeof(login), 1);
    OAString(m + 1, "id", id, sizeof(id), 1);
    m[1].kind = 3;
    if (!c->access[0] || n > 32768UL || GHJSONMembers(json, n, m, 2) || !login[0] ||
        !strcmp(id, "0") || strlen(id) > 20)
        goto bad;
    for (i = 0; login[i]; ++i)
        if (!((login[i] >= 'a' && login[i] <= 'z') || (login[i] >= 'A' && login[i] <= 'Z') ||
              (login[i] >= '0' && login[i] <= '9') || login[i] == '-'))
            goto bad;
    if (expected && *expected && strcmp(expected, id)) {
        OAClear(c, sizeof(*c));
        return OA_WRONG_ACCOUNT;
    }
    strcpy(c->login, login);
    strcpy(c->accountID, id);
    c->bound = 1;
    return 0;
bad:
    OAClear(c, sizeof(*c));
    return OA_BAD_RESPONSE;
}
int OARefreshNeeded(const OACredentials *c, unsigned long now) {
    return c->bound && c->expires &&
           (OAElapsed(now, c->issued) >= c->expires ||
            c->expires - OAElapsed(now, c->issued) <= 60);
}
int OARefreshForm(const OACredentials *c, const char *client, unsigned long now, char *out,
                  size_t cap) {
    if (!out || !cap)
        return OA_BAD_RESPONSE;
    out[0] = 0;
    if (!c->bound || !c->deviceIssued || !c->refresh[0] || !OAClientValid(client) ||
        strcmp(client, c->clientID) || OAElapsed(now, c->issued) >= c->refreshExpires)
        return OA_BAD_RESPONSE;
    if (OAAppend(out, cap, "client_id", client) ||
        OAAppend(out, cap, "grant_type", "refresh_token") ||
        OAAppend(out, cap, "refresh_token", c->refresh)) {
        OAClear(out, cap);
        return OA_BAD_RESPONSE;
    }
    return 0;
}
int OARefreshReply(const OACredentials *old, const char *json, size_t n, unsigned long now,
                   OACredentials *out) {
    char error[128];
    unsigned long interval = 0;
    int r;
    if (out == old)
        return OA_BAD_RESPONSE;
    r = OAReadToken(json, n, now, out, error, &interval);
    if (r || !old->bound || !old->deviceIssued || !OAClientValid(old->clientID) ||
        !out->refresh[0] || (OAHasScope(old->scope, "repo") && !OAHasScope(out->scope, "repo")) ||
        (OAHasScope(old->scope, "public_repo") && !OAHasScope(out->scope, "public_repo") &&
         !OAHasScope(out->scope, "repo"))) {
        OAClear(out, sizeof(*out));
        return OA_BAD_RESPONSE;
    }
    strcpy(out->clientID, old->clientID);
    return 0;
}
