#include "GitRebaseCommit.h"
#include "GitHistory.h"
#include <stdlib.h>
#include <string.h>

void RCInit(RCCommit *c){memset(c,0,sizeof(*c));}
void RCFree(RCCommit *c){free(c->body);RCInit(c);}
static int RCNonzero(const unsigned char *id) {
    size_t i;for(i=0;i<20;++i)if(id[i])return 1;return 0;
}
static int RCTime(const unsigned char *p,size_t n,const unsigned char *zone,size_t zn) {
    size_t i=0;int h,m;
    if(!n || zn!=5 || (zone[0]!='+' && zone[0]!='-'))return 0;
    if((n>1 && p[0]=='0') || n>19 || (n==19 && memcmp(p,"9223372036854775807",19)>0))return 0;
    for(;i<n;++i)if(p[i]<'0' || p[i]>'9')return 0;
    for(i=1;i<5;++i)if(zone[i]<'0' || zone[i]>'9')return 0;
    h=(zone[1]-'0')*10+zone[2]-'0';m=(zone[3]-'0')*10+zone[4]-'0';return h<=23 && m<=59;
}
static int RCIdentity(const unsigned char *p,size_t n) {
    size_t i,left=(size_t)-1,right=(size_t)-1;
    for(i=0;i<n;++i) {
        if(p[i]<32 || p[i]==127)return 0;
        if(p[i]=='<'){if(left!=(size_t)-1)return 0;left=i;}
        if(p[i]=='>'){if(right!=(size_t)-1)return 0;right=i;}
    }
    return left!=(size_t)-1 && right==n-1 && left>1 && p[left-1]==' ' && right>left+1;
}
static int RCAuthor(const unsigned char *p,size_t n) {
    size_t zone=n,stamp,identity;
    while(zone && p[zone-1]!=' ')--zone;if(!zone)return 0;
    stamp=zone-1;while(stamp && p[stamp-1]!=' ')--stamp;if(!stamp)return 0;
    identity=stamp-1;
    return RCIdentity(p,identity) && RCTime(p+stamp,zone-stamp-1,p+zone,n-zone);
}
static int RCAdd(size_t *n,size_t extra,size_t limit) {
    if(extra>limit || *n>limit-extra)return GB_SPACE;*n+=extra;return 0;
}
int RCRewrite(const void *original,size_t length,const unsigned char tree[20],const unsigned char parent[20],
    const char *committer,const char *seconds,const char *zone,size_t limit,RCCommit *out) {
    const unsigned char *raw=(const unsigned char *)original;GHCommitInfo info;RCCommit next;
    size_t at,end,key,value,author=0,authorLength=0,encoding=0,encodingLength=0,total=0,pos=0,i;
    size_t cn,sn,zn;unsigned int dropped=0,flag;int result;char hex[41];
    if(!raw || !length || !tree || !parent || !committer || !seconds || !zone || !out || !limit)return GB_BAD;
    if(length>limit)return GB_SPACE;
    cn=strlen(committer);sn=strlen(seconds);zn=strlen(zone);
    if(!RCNonzero(tree) || !RCNonzero(parent) || !RCIdentity((const unsigned char *)committer,cn) ||
       !RCTime((const unsigned char *)seconds,sn,(const unsigned char *)zone,zn))return GB_BAD;
    result=GHCommitParse(raw,length,&info);if(result)return result;
    if(info.parents!=1)return GB_BAD;
    at=0;
    while(at<info.messageOffset-1) {
        end=at;while(raw[end]!='\n')++end;
        key=at;while(key<end && raw[key]!=' ')++key;value=key+1;
        if(key-at==4 && !memcmp(raw+at,"tree",4)){}
        else if(key-at==6 && !memcmp(raw+at,"parent",6)){}
        else if(key-at==6 && !memcmp(raw+at,"author",6)) {
            if(!RCAuthor(raw+value,end-value))return GB_BAD;
            author=at;authorLength=end-at+1;
        } else if(key-at==9 && !memcmp(raw+at,"committer",9)) {
            if(!RCAuthor(raw+value,end-value))return GB_BAD;
        } else if(key-at==8 && !memcmp(raw+at,"encoding",8)) {
            if(encodingLength || value==end)return GB_BAD;
            for(i=value;i<end;++i)if(raw[i]<33 || raw[i]>126)return GB_BAD;
            encoding=at;encodingLength=end-at+1;
        } else {
            if(key-at==6 && !memcmp(raw+at,"gpgsig",6))flag=RC_DROP_GPGSIG;
            else if(key-at==13 && !memcmp(raw+at,"gpgsig-sha256",13))flag=RC_DROP_GPGSIG_SHA256;
            else return GB_BAD;
            if(dropped&flag || value==end)return GB_BAD;dropped|=flag;
            while(end+1<info.messageOffset-1 && raw[end+1]==' ') {
                ++end;while(raw[end]!='\n')++end;
            }
        }
        at=end+1;
    }
    /* tree + parent, original author, replacement committer, optional encoding,
       separator and exact message. Check every addition before allocation. */
    result=RCAdd(&total,46+48,limit);
    if(!result)result=RCAdd(&total,authorLength,limit);
    if(!result)result=RCAdd(&total,10,limit);
    if(!result)result=RCAdd(&total,cn,limit);
    if(!result)result=RCAdd(&total,1,limit);
    if(!result)result=RCAdd(&total,sn,limit);
    if(!result)result=RCAdd(&total,1,limit);
    if(!result)result=RCAdd(&total,zn,limit);
    if(!result)result=RCAdd(&total,1,limit);
    if(!result)result=RCAdd(&total,encodingLength,limit);
    if(!result)result=RCAdd(&total,1,limit);
    if(!result)result=RCAdd(&total,length-info.messageOffset,limit);
    if(result)return result;
    RCInit(&next);next.body=(unsigned char *)malloc(total);if(!next.body)return GB_MEMORY;
    next.length=total;next.dropped=dropped;
    GBOIDFormat(tree,hex);memcpy(next.body+pos,"tree ",5);pos+=5;memcpy(next.body+pos,hex,40);pos+=40;next.body[pos++]='\n';
    GBOIDFormat(parent,hex);memcpy(next.body+pos,"parent ",7);pos+=7;memcpy(next.body+pos,hex,40);pos+=40;next.body[pos++]='\n';
    memcpy(next.body+pos,raw+author,authorLength);pos+=authorLength;
    memcpy(next.body+pos,"committer ",10);pos+=10;memcpy(next.body+pos,committer,cn);pos+=cn;next.body[pos++]=' ';
    memcpy(next.body+pos,seconds,sn);pos+=sn;next.body[pos++]=' ';memcpy(next.body+pos,zone,zn);pos+=zn;next.body[pos++]='\n';
    memcpy(next.body+pos,raw+encoding,encodingLength);pos+=encodingLength;next.body[pos++]='\n';
    memcpy(next.body+pos,raw+info.messageOffset,length-info.messageOffset);
    RCFree(out);*out=next;return 0;
}
