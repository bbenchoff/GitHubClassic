#include "GHVaultMac.h"
#include <Folders.h>
#include <Script.h>
#include <Errors.h>
#include <stdlib.h>
#include <string.h>
#include <stdio.h>

static int VFError(VFStore *s,OSErr error) {s->lastError=error;return error?VF_IO:0;}
static void VFName(const char *text,Str31 name) {name[0]=(unsigned char)strlen(text);memcpy(name+1,text,name[0]);}
void VFInit(VFStore *s){memset(s,0,sizeof(*s));}
int VFClose(VFStore *s) {
    OSErr error;
    if(!s)return VF_FORMAT;
    if(s->haveIO){error=FSClose(s->ioRef);if(error)return VFError(s,error);s->haveIO=0;s->ioRef=0;}
    if(s->haveLease){error=FSClose(s->leaseRef);if(error)return VFError(s,error);s->haveLease=0;s->leaseRef=0;}
    return 0;
}
static int VFSpec(VFStore *s,const char *text,FSSpec *spec) {
    Str31 name;OSErr error;VFName(text,name);error=FSMakeFSSpec(s->volume,s->directory,name,spec);
    return error==fnfErr?0:VFError(s,error);
}
static int VFCatalog(VFStore *s,const FSSpec *spec,OSType type,long *length) {
    CInfoPBRec pb;OSErr error;unsigned char *info;
    memset(&pb,0,sizeof(pb));pb.hFileInfo.ioNamePtr=(StringPtr)spec->name;
    pb.hFileInfo.ioVRefNum=spec->vRefNum;pb.hFileInfo.ioDirID=spec->parID;
    error=PBGetCatInfoSync(&pb);if(error==fnfErr)return 1;if(error)return VFError(s,error);
    info=(unsigned char *)&pb.hFileInfo.ioFlFndrInfo;
    if((pb.hFileInfo.ioFlAttrib&16) || (info[8]&0x80) || pb.hFileInfo.ioFlFndrInfo.fdCreator!='GHCl' ||
       pb.hFileInfo.ioFlFndrInfo.fdType!=type || pb.hFileInfo.ioFlRLgLen || pb.hFileInfo.ioFlLgLen<0)return VF_FORMAT;
    *length=pb.hFileInfo.ioFlLgLen;return 0;
}
static int VFBegin(VFStore *s) {
    FSSpec lock;long length;int result;OSErr error;
    if(!s)return VF_FORMAT;
    result=VFClose(s);if(result)return result;s->lastError=0;
    error=FindFolder(kOnSystemDisk,kPreferencesFolderType,true,&s->volume,&s->directory);if(error)return VFError(s,error);
    result=VFSpec(s,"GHClient Credentials Lease",&lock);if(result)return result;
    error=FSpCreate(&lock,'GHCl','GHVL',smSystemScript);if(error && error!=dupFNErr)return VFError(s,error);
    error=FSpOpenDF(&lock,fsWrPerm,&s->leaseRef);
    if(error)return error==opWrErr || error==permErr || error==-5006?VF_CONFLICT:VFError(s,error);
    s->haveLease=1;result=VFCatalog(s,&lock,'GHVL',&length);if(!result && length)result=VF_FORMAT;
    if(result){VFClose(s);return result;}return 0;
}
static int VFReadHeld(VFStore *s,unsigned char **out,size_t *outLength,int *present) {
    FSSpec target;long length,count,done=0,actual;unsigned char *bytes;int result;OSErr error;
    result=VFSpec(s,"GHClient Credentials",&target);if(result)return result;
    result=VFCatalog(s,&target,'GHVC',&length);
    if(result==1){*out=NULL;*outLength=0;*present=0;return 0;}if(result)return result;
    if((unsigned long)length>GV_MAX_PLAIN+GV_HEADER+GV_TAG)return VF_FORMAT;
    bytes=(unsigned char *)malloc(length?(size_t)length:1);if(!bytes)return GV_MEMORY;
    error=FSpOpenDF(&target,fsRdPerm,&s->ioRef);if(!error)s->haveIO=1;
    if(!error){error=GetEOF(s->ioRef,&actual);if(!error && actual!=length)error=ioErr;}
    while(!error && done<length){count=length-done;error=FSRead(s->ioRef,&count,bytes+done);if(count<0 || count>length-done){error=ioErr;break;}done+=count;if(!error && !count)error=ioErr;}
    if(!error){error=FSClose(s->ioRef);if(!error){s->haveIO=0;s->ioRef=0;}}
    if(error){GVClear(bytes,(size_t)length);free(bytes);return VFError(s,error);}
    *out=bytes;*outLength=(size_t)length;*present=1;return 0;
}
int VFRead(VFStore *s,unsigned char **out,size_t *outLength,int *present) {
    unsigned char *bytes=NULL;size_t n=0;int exists=0,result,closed;
    if(!out || !outLength || !present)return VF_FORMAT;
    result=VFBegin(s);if(!result)result=VFReadHeld(s,&bytes,&n,&exists);
    closed=VFClose(s);if(!result)result=closed;
    if(result){if(bytes){GVClear(bytes,n);free(bytes);}return result;}
    *out=bytes;*outLength=n;*present=exists;return 0;
}
static int VFExpected(VFStore *s,const void *expected,size_t en,int present) {
    unsigned char *bytes=NULL;size_t n=0;int exists,result;
    result=VFReadHeld(s,&bytes,&n,&exists);
    if(!result && (present!=exists || (exists && (en!=n || memcmp(expected,bytes,n)))))result=VF_CONFLICT;
    if(bytes){GVClear(bytes,n);free(bytes);}return result;
}
static int VFTemporary(VFStore *s,const void *bytes,size_t length,FSSpec *spec) {
    char text[32];unsigned long i;size_t done=0;long count;OSErr error;int result;
    for(i=0;i<4096;++i) {
        sprintf(text,".ghvault%08lx",s->serial++);result=VFSpec(s,text,spec);if(result)return result;
        error=FSpCreate(spec,'GHCl','GHVC',smSystemScript);if(error==dupFNErr)continue;if(error)return VFError(s,error);
        error=FSpOpenDF(spec,fsWrPerm,&s->ioRef);if(!error)s->haveIO=1;
        while(!error && done<length){count=(long)(length-done);error=FSWrite(s->ioRef,&count,(const unsigned char *)bytes+done);if(count<0 || (size_t)count>length-done){error=ioErr;break;}done+=(size_t)count;if(!error && !count)error=ioErr;}
        if(!error){error=FSClose(s->ioRef);if(!error){s->haveIO=0;s->ioRef=0;}}
        if(!error)error=FlushVol(NULL,s->volume);
        return VFError(s,error);
    }
    return VF_CONFLICT;
}
static int VFInput(const void *expected,size_t en,int present) {
    return (present!=0 && present!=1) || (present && (!expected || en>GV_MAX_PLAIN+GV_HEADER+GV_TAG)) || (!present && (expected || en));
}
int VFReplace(VFStore *s,const void *expected,size_t en,int present,const void *encoded,size_t length) {
    FSSpec target,temp;int result,closed;OSErr error;const unsigned char *p=(const unsigned char *)encoded;
    if(VFInput(expected,en,present) || !p || length<GV_HEADER+GV_TAG || length>GV_MAX_PLAIN+GV_HEADER+GV_TAG || memcmp(p,"GHVA0001",8))return VF_FORMAT;
    result=VFBegin(s);if(!result)result=VFExpected(s,expected,en,present);
    if(!result)result=VFSpec(s,"GHClient Credentials",&target);
    if(!result)result=VFTemporary(s,encoded,length,&temp);
    if(!result) {
        error=present?FSpExchangeFiles(&temp,&target):FSpRename(&temp,target.name);
        if(error){s->lastError=error;result=error==dupFNErr?VF_CONFLICT:VF_UNCERTAIN;}
        else {
            error=FlushVol(NULL,s->volume);
            if(error){s->lastError=error;result=VF_UNCERTAIN;}
            else if(present) {
                /* Only our successful exchange's private backup is removed.
                   Failure leaves a credential backup, never a partial live file. */
                error=FSpDelete(&temp);if(!error)FlushVol(NULL,s->volume);
            }
        }
    }
    closed=VFClose(s);if(!result)result=closed;return result;
}
int VFDelete(VFStore *s,const void *expected,size_t en,int present) {
    FSSpec target;int result,closed;OSErr error;
    if(VFInput(expected,en,present))return VF_FORMAT;
    result=VFBegin(s);if(!result)result=VFExpected(s,expected,en,present);
    if(!result && present){result=VFSpec(s,"GHClient Credentials",&target);if(!result){error=FSpDelete(&target);result=VFError(s,error);}}
    if(!result && present){error=FlushVol(NULL,s->volume);if(error){s->lastError=error;result=VF_UNCERTAIN;}}
    closed=VFClose(s);if(!result)result=closed;return result;
}
