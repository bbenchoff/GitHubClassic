/* Faceless native RAM-only unlock cache. No credential/key files, network,
   clipboard, scripting dictionary or logging. A Mac reboot loses the cache.
   Classic Mac OS has shared memory: this is not isolation from local programs. */
#include <Types.h>
#include <Quickdraw.h>
#include <Fonts.h>
#include <Windows.h>
#include <Menus.h>
#include <TextEdit.h>
#include <Dialogs.h>
#include <Events.h>
#include <Memory.h>
#include <AppleEvents.h>
#include <Processes.h>
#include <string.h>
static char gUnlock[1025];
static unsigned char gKey[64];
static int gHaveKey;
static int gQuit;
static void LHWipe(void *p,unsigned long n){volatile unsigned char *b=(volatile unsigned char *)p;while(n--)*b++=0;}
static pascal OSErr LHEvent(const AppleEvent *event,AppleEvent *reply,long action) {
    char pending[1025];Size length=0;DescType actual;OSErr error;unsigned long i;
    if(action==0)return noErr;
    if(action==1 || action==4){if(action==1)gQuit=1;LHWipe(gUnlock,sizeof(gUnlock));LHWipe(gKey,sizeof(gKey));gHaveKey=0;return noErr;}
    if(action==5 || action==6) {
        memset(pending,0,sizeof(pending));
        error=AEGetParamPtr(event,keyDirectObject,typeData,&actual,pending,64,&length);
        if(!error && (actual!=typeData || length!=(action==5?64:32)))error=paramErr;
        if(!error && !gUnlock[0])error=fnfErr;
        if(!error && action==5){LHWipe(gKey,sizeof(gKey));memcpy(gKey,pending,64);gHaveKey=1;}
        if(!error && action==6)error=gHaveKey && !memcmp(pending,gKey,32)?AEPutParamPtr(reply,keyDirectObject,typeData,gKey+32,32):fnfErr;
        LHWipe(pending,sizeof(pending));return error;
    }
    if(action==3)return gUnlock[0]?AEPutParamPtr(reply,keyDirectObject,typeChar,gUnlock,(Size)strlen(gUnlock)):fnfErr;
    memset(pending,0,sizeof(pending));
    error=AEGetParamPtr(event,keyDirectObject,typeChar,&actual,pending,1024,&length);
    if(!error && (length<1 || length>1024))error=paramErr;
    if(!error)for(i=0;i<(unsigned long)length;++i)if((unsigned char)pending[i]<32 || (unsigned char)pending[i]>126){error=paramErr;break;}
    if(!error){LHWipe(gUnlock,sizeof(gUnlock));LHWipe(gKey,sizeof(gKey));gHaveKey=0;memcpy(gUnlock,pending,(unsigned long)length);}
    LHWipe(pending,sizeof(pending));return error;
}
int main(void) {
    EventRecord event;AEEventHandlerUPP handler;OSErr error;
    InitGraf(&qd.thePort);InitFonts();InitWindows();InitMenus();TEInit();InitDialogs(NULL);MaxApplZone();
    handler=NewAEEventHandlerProc(LHEvent);if(!handler)return 1;
    error=AEInstallEventHandler(kCoreEventClass,kAEOpenApplication,handler,0,false);
    if(!error)error=AEInstallEventHandler(kCoreEventClass,kAEQuitApplication,handler,1,false);
    if(!error)error=AEInstallEventHandler('GHVk','stor',handler,2,false);
    if(!error)error=AEInstallEventHandler('GHVk','load',handler,3,false);
    if(!error)error=AEInstallEventHandler('GHVk','drop',handler,4,false);
    if(!error)error=AEInstallEventHandler('GHVk','ksto',handler,5,false);
    if(!error)error=AEInstallEventHandler('GHVk','kloa',handler,6,false);
    if(!error)while(!gQuit){if(WaitNextEvent(everyEvent,&event,60,NULL) && event.what==kHighLevelEvent)AEProcessAppleEvent(&event);}
    LHWipe(gUnlock,sizeof(gUnlock));LHWipe(gKey,sizeof(gKey));DisposeRoutineDescriptor((UniversalProcPtr)handler);return error?1:0;
}
