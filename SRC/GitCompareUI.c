/* Native snapshot branch comparison; included after the graphical branch picker. */
static struct {
    BCGraph graph;
    HCComparison files;
    char *current, *other;
    unsigned side, fileSide;
    int view, selected, ready;
    int pullRequest,pullKind;
    size_t pullConflicts,pullFiles;
    char *pullOwner;
    size_t page, basis, rows, offset;
    GHCommitInfo messages[GH_HISTORY_CAPACITY];
    unsigned char ids[GH_HISTORY_CAPACITY][20];
} gBranchCompare;
static int BCUIActive(void) {return gBranchCompare.other!=NULL;}
static void BCUIReset(void) {
    BCFree(&gBranchCompare.graph);HCFree(&gBranchCompare.files);
    free(gBranchCompare.current);free(gBranchCompare.other);
    free(gBranchCompare.pullOwner);
    memset(&gBranchCompare,0,sizeof(gBranchCompare));
}
static void BCUIReader(GSRepository *r) {
    r->context=&gWork.database;r->replace=HistoryNoWrite;
    r->read=HistoryRead;
}
static int BCUIRead(void *context,const char *key,unsigned char **bytes,size_t *length) {
    return GSMacReadLimit((GSMacStore *)context,key,bytes,length,
                         !strncmp(key,"objects/",8)?3UL*1024*1024:16384);
}
static const char *BCUISide(void) {return gBranchCompare.pullRequest?
    (gBranchCompare.side==BC_RIGHT?"Base-only":"Proposed"):(gBranchCompare.side==BC_RIGHT?"Incoming":"Outgoing");}
static void BCUIName(const char *ref,char text[256]) {
    char name[256];
    LocalDisplayPath(ref+(GSValidTrackingRef(ref)?13:11),name);
    if(strlen(name)>245 || strlen(ref)>266){name[242]=0;strcat(name,"...");}
    snprintf(text,256,"%s%.245s",GSValidTrackingRef(ref)?"Remote: ":"",name);
}
static size_t BCUITotal(void) {
    return gBranchCompare.view==1?gBranchCompare.files.count:
        gBranchCompare.side==BC_LEFT?gBranchCompare.graph.onlyLeft:gBranchCompare.graph.onlyRight;
}
static void BCUIPreviewReady(void) {
    gDiffTop=0;FindReset();DiffScroll();ShowDiffControls();InvalRect(&gWindow->portRect);
}
static void BCUIPullSummary(void) {
    OperationPrompt information;char head[256],base[256],state[560],kind[256],headID[41],baseID[41],files[48];char *details;int n;
    BCUIName(gBranchCompare.current,head);BCUIName(gBranchCompare.other,base);
    GBOIDFormat(gBranchCompare.graph.left,headID);GBOIDFormat(gBranchCompare.graph.right,baseID);
    snprintf(state,sizeof(state),"Proposed: %s\rTarget base: %s",head,base);
    if(gBranchCompare.pullKind==PV_EMPTY)strcpy(kind,"The proposed branch has no commits beyond this base.");
    else if(gBranchCompare.pullKind==PV_CLEAN)strcpy(kind,"Local merge check: these committed snapshots merge cleanly.");
    else if(gBranchCompare.pullKind==PV_CONFLICT)snprintf(kind,sizeof(kind),"Local merge check: %lu conflicting logical files. This preview keeps the conflicts and original files in place.",(unsigned long)gBranchCompare.pullConflicts);
    else if(gBranchCompare.pullKind==PV_UNRELATED)strcpy(kind,"These histories have no common ancestor. A pull-request file comparison is unavailable.");
    else strcpy(kind,"These histories have multiple best common ancestors. A combined-base policy is needed for a pull-request file preview.");
    if(gBranchCompare.graph.bases==1)snprintf(files,sizeof(files),"%lu",(unsigned long)gBranchCompare.pullFiles);else strcpy(files,"unavailable");
    memset(&information,0,sizeof(information));information.title="Pull Request Preview";information.repository=gBranchCompare.pullOwner;
    information.state=state;information.primaryText=kind;information.secondaryText="Only committed history is included. Staged and working edits remain separate.";
    information.footer="Preview reads local history without a GitHub request. View > Changes or History leaves this view; Preview Pull Request chooses a new base. GitHub's live branch state can differ.";
    information.labels[0]="Proposed reference";information.values[0]=gBranchCompare.current;
    information.labels[1]="Target base reference";information.values[1]=gBranchCompare.other;
    information.labels[2]="Proposed commit";information.values[2]=headID;information.labels[3]="Base commit";information.values[3]=baseID;
    details=OperationDetails(&information);
    n=snprintf(gPatch,sizeof(gPatch),"Pull request preview\r\rProposed commits: %lu\rBase-only commits: %lu\rProposed changed files: %s\rBest common ancestors: %lu\r\r%s\r",
        (unsigned long)gBranchCompare.graph.onlyLeft,(unsigned long)gBranchCompare.graph.onlyRight,files,(unsigned long)gBranchCompare.graph.bases,
        details?details:"The complete identity summary could not be allocated. Files and Commits remain available.");
    free(details);gPatchTruncated=n<0 || (size_t)n>=sizeof(gPatch);gBranchCompare.selected=-1;BCUIPreviewReady();
    SetStatus("Local pull-request snapshots. Proposed contains this branch's contributions; Base-only inspects target history.");
}
static void BCUISummary(void) {
    char current[256],other[256],left[41],right[41],base[41];
    const BCNode *node;
    if(gBranchCompare.pullRequest){BCUIPullSummary();return;}
    BCUIName(gBranchCompare.current,current);BCUIName(gBranchCompare.other,other);
    GBOIDFormat(gBranchCompare.graph.left,left);GBOIDFormat(gBranchCompare.graph.right,right);
    node=BCBaseAt(&gBranchCompare.graph,gBranchCompare.basis);
    strcpy(base,"Not selected");if(node)GBOIDFormat(node->oid,base);
    snprintf(gPatch,sizeof(gPatch),
        "Current branch: %s\rCommit: %s\r\rOther branch: %s\rCommit: %s\r\r"
        "Incoming commits: %lu\rOutgoing commits: %lu\rBest common ancestors: %lu\rComparison base: %s\r\r"
        "Incoming shows the other branch since a common ancestor.\rOutgoing shows the current branch since a common ancestor.\r\r"
        "Files compares committed snapshots. Commits lists unique commits through every merge parent.\r"
        "Staged and working edits are excluded. No branch, index or file is changed.\r\r%s\r"
        "Changes, History and Refresh leave this comparison. Choose Compare to Branch again to read newer tips.\r",
        current,left,other,right,(unsigned long)gBranchCompare.graph.onlyRight,
        (unsigned long)gBranchCompare.graph.onlyLeft,(unsigned long)gBranchCompare.graph.bases,base,
        !gBranchCompare.graph.bases?"These histories have no common ancestor. A merge-base file comparison is unavailable.":
        gBranchCompare.graph.bases>1?"There are multiple best bases. Files asks which base to use explicitly; this is not a combined merge preview.":
        "Files uses the unique best common ancestor.");
    gBranchCompare.selected=-1;gPatchTruncated=0;BCUIPreviewReady();
    SetStatus("Branch snapshots are read-only. Incoming is the other branch; Outgoing is the current branch.");
}
static int BCUIReadRows(GSRepository *reader,const BCGraph *graph,unsigned side,size_t page,
                          GHCommitInfo info[GH_HISTORY_CAPACITY],unsigned char ids[GH_HISTORY_CAPACITY][20],size_t *rows) {
    const BCNode *node;
    size_t i,n;
    unsigned char *body=NULL;
    char type[7];
    int error=0;
    *rows=0;
    for(i=0;i<GH_HISTORY_CAPACITY;++i) {
        node=BCCommitAt(graph,side,page*GH_HISTORY_CAPACITY+i);if(!node)break;
        error=HistoryProgress(NULL);
        if(!error)error=GSGetObjectLimit(reader,node->oid,type,&body,&n,2UL*1024*1024);
        if(!error)error=strcmp(type,"commit")?GS_FORMAT:GHCommitParse(body,n,info+i);
        free(body);body=NULL;if(error)break;
        memcpy(ids[i],node->oid,20);++*rows;
    }
    return error;
}
static int BCUIMessage(GSRepository *reader,const unsigned char id[20],unsigned side,char **text,int *truncated) {
    unsigned char *body=NULL;GHCommitInfo info;size_t n,at,out;char type[7],hex[41];int error;
    *text=NULL;*truncated=0;error=HistoryProgress(NULL);
    if(!error)error=GSGetObjectLimit(reader,id,type,&body,&n,2UL*1024*1024);
    if(!error)error=strcmp(type,"commit")?GS_FORMAT:GHCommitParse(body,n,&info);
    if(!error){*text=(char *)malloc(sizeof(gPatch));if(!*text)error=GB_MEMORY;}
    if(!error) {
        GBOIDFormat(id,hex);
        snprintf(*text,sizeof(gPatch),"%s commit %s\rAuthor: %.255s\r\r",gBranchCompare.pullRequest?
            (side==BC_RIGHT?"Base-only":"Proposed"):(side==BC_RIGHT?"Incoming":"Outgoing"),hex,info.author);
        out=strlen(*text);at=info.messageOffset;*truncated=n-at>=sizeof(gPatch)-out;
        for(;at<n && out+1<sizeof(gPatch);++at)(*text)[out++]=body[at]=='\n'?'\r':body[at]<32 && body[at]!='\r' && body[at]!='\t'?'?':(char)body[at];
        (*text)[out]=0;
    }
    free(body);return error;
}
static int BCUILoadRows(unsigned side,size_t page,int message) {
    GSRepository reader;
    static GHCommitInfo info[GH_HISTORY_CAPACITY];static unsigned char ids[GH_HISTORY_CAPACITY][20];size_t rows;
    int error,truncated=0;char *text=NULL;
    BCUIReader(&reader);gBusy=1;gCancel=0;LocalEditState();
    error=BCUIReadRows(&reader,&gBranchCompare.graph,side,page,info,ids,&rows);
    if(!error && message && rows)error=BCUIMessage(&reader,ids[0],side,&text,&truncated);
    gBusy=0;LocalEditState();
    if(error || gDone){free(text);if(error && !gDone)LocalError("Read comparison commits",error);return error?error:-99;}
    memcpy(gBranchCompare.messages,info,rows*sizeof(*info));
    memcpy(gBranchCompare.ids,ids,rows*20);gBranchCompare.rows=rows;
    gBranchCompare.side=side;gBranchCompare.page=page;gBranchCompare.offset=0;gBranchCompare.selected=-1;
    if(text){strcpy(gPatch,text);free(text);gPatchTruncated=truncated;gBranchCompare.selected=(int)(page*GH_HISTORY_CAPACITY);
        gBranchCompare.view=2;BCUIPreviewReady();SetStatus("Unique committed message. Files compares the whole branch direction, not just this commit.");}
    return 0;
}
static int BCUIBaseRow(void *context,size_t at,char label[256],char name[256],char info[256]) {
    const BCNode *node=BCBaseAt((const BCGraph *)context,at);
    if(!node)return 0;GBOIDFormat(node->oid,name);snprintf(label,256,"Base %lu: %s",(unsigned long)(at+1),name);
    strcpy(info,"One ancestor; not a combined merge.");return 1;
}
static char *BCUIBaseDetails(void *context,size_t at) {
    const BCNode *node=BCBaseAt((const BCGraph *)context,at);char hex[41];
    if(!node)return NULL;GBOIDFormat(node->oid,hex);
    return ChoiceIdentityDetails("Common ancestor commit\rChoosing this base compares one snapshot; it is not a combined merge preview.",hex);
}
static size_t BCUIPickBase(void) {
    NativeChoices choices;
    choices.context=&gBranchCompare.graph;choices.count=gBranchCompare.graph.bases;choices.initial=gBranchCompare.basis;
    choices.row=BCUIBaseRow;choices.details=BCUIBaseDetails;choices.title="Choose Comparison Base";
    choices.description="Multiple common ancestors were found.\rChoose one explicitly for the file comparison.";
    choices.action="Compare";choices.noun="Bases";return PickNativeChoice(&choices);
}
static void BCUIFile(size_t selected) {
    GSRepository reader;GDResult diff;char basis[41],tip[41],status[256];size_t n;int error;
    if(selected>=gBranchCompare.files.count)return;
    BCUIReader(&reader);gBusy=1;gCancel=0;LocalEditState();
    GBOIDFormat(gBranchCompare.files.before.commit,basis);GBOIDFormat(gBranchCompare.files.after.commit,tip);
    snprintf(gPatch,sizeof(gPatch),"%s branch changes%s\rBase %s\rTip  %s\rPath: %s\r\r",
        BCUISide(),gBranchCompare.graph.bases>1?" (one selected base; not a combined merge)":"",basis,tip,gBranchCompare.files.changes[selected].path);
    n=strlen(gPatch);error=HCPreview(&reader,&gBranchCompare.files,selected,'\r',gPatch+n,sizeof(gPatch)-n,
                                     HistoryProgress,NULL,&diff);
    gBusy=0;LocalEditState();
    if(error){gBranchCompare.selected=-1;strcpy(gPatch,"The committed file preview was cancelled or could not be verified.\rChoose a file to retry.\r");if(!gDone)LocalError("Read branch file",error);}
    else {gBranchCompare.selected=(int)selected;gPatchTruncated=diff.truncated;
        snprintf(status,sizeof(status),"%s file %lu of %lu: +%lu -%lu lines. Merge-base snapshot comparison; working edits are separate.",
            BCUISide(),(unsigned long)(selected+1),(unsigned long)gBranchCompare.files.count,
            (unsigned long)diff.added,(unsigned long)diff.removed);SetStatus(status);}
    BCUIPreviewReady();
}
static void BCUICommit(size_t row) {
    GSRepository reader;char *text=NULL;int error,truncated;
    if(row>=gBranchCompare.rows)return;
    BCUIReader(&reader);gBusy=1;gCancel=0;LocalEditState();
    error=BCUIMessage(&reader,gBranchCompare.ids[row],gBranchCompare.side,&text,&truncated);
    gBusy=0;LocalEditState();
    if(error || gDone){free(text);if(error && !gDone)LocalError("Read comparison commit",error);return;}
    strcpy(gPatch,text);free(text);gPatchTruncated=truncated;gBranchCompare.view=2;
    gBranchCompare.selected=(int)(gBranchCompare.page*GH_HISTORY_CAPACITY+row);
    BCUIPreviewReady();SetStatus("Unique committed message. Files compares the entire selected branch direction, not just this commit.");
}
static void BCUIFiles(unsigned side,int choose) {
    GSRepository reader;HCComparison next;HCLimits limits;const BCNode *base;size_t selected;int error;
    if(!gBranchCompare.graph.bases){Message("No Common Ancestor","These branch histories have no common ancestor. Their unique commits can be inspected, but a merge-base file comparison is unavailable.");return;}
    if(gBranchCompare.pullRequest && gBranchCompare.graph.bases>1){Message("Combined Base Needed","Several best common ancestors were found. A pull-request file preview needs a combined base; no ancestor was chosen. The proposed commits remain available.");return;}
    selected=gBranchCompare.basis;
    if(gBranchCompare.graph.bases>1 && (choose || selected==(size_t)-1))selected=BCUIPickBase();
    if(selected==(size_t)-1 || gDone)return;
    base=BCBaseAt(&gBranchCompare.graph,selected);if(!base)return;
    BCUIReader(&reader);HCInit(&next);gBusy=1;gCancel=0;LocalEditState();
    limits.entries=8192;limits.depth=64;limits.pathBytes=1024;limits.objectBytes=2UL*1024*1024;
    limits.encodedBytes=3UL*1024*1024;limits.readBytes=64UL*1024*1024;limits.reads=32768;
    SetStatus("Reading committed branch files... Escape cancels.");
    error=HCBetweenCommits(&reader,base->oid,side==BC_LEFT?gBranchCompare.graph.left:gBranchCompare.graph.right,
                           &limits,HistoryProgress,NULL,&next);
    gBusy=0;LocalEditState();
    if(error || gDone){HCFree(&next);if(error && !gDone)LocalError("Compare branch files",error);return;}
    HCFree(&gBranchCompare.files);gBranchCompare.files=next;gBranchCompare.ready=1;gBranchCompare.fileSide=side;
    gBranchCompare.side=side;gBranchCompare.basis=selected;gBranchCompare.view=1;gBranchCompare.page=0;gBranchCompare.offset=0;gBranchCompare.selected=-1;
    if(gBranchCompare.files.count)BCUIFile(0);
    else {strcpy(gPatch,"No committed file changes in this branch direction since the selected common ancestor.\rStaged and working edits are excluded.\r");gPatchTruncated=0;BCUIPreviewReady();SetStatus("No committed file changes for this branch direction.");}
}
static void BCUIMode(int view) {
    if(!BCUIActive() || gBusy)return;
    if(view==1){BCUIFiles(gBranchCompare.side,1);return;}
    if(BCUILoadRows(gBranchCompare.side,0,view==2))return;
    gBranchCompare.view=view;
    if(view==0 || !gBranchCompare.rows)BCUISummary();
}
static void BCUIDirection(unsigned side) {
    if(!BCUIActive() || gBusy || side==gBranchCompare.side)return;
    if(gBranchCompare.view==1){BCUIFiles(side,0);return;}
    if(BCUILoadRows(side,0,gBranchCompare.view==2))return;
    if(gBranchCompare.view==0 || !gBranchCompare.rows)BCUISummary();
}
static void BCUISelect(int row) {
    size_t at=gBranchCompare.offset+(size_t)row;
    if(row<0 || row>=gUI.rows || at>=GH_HISTORY_CAPACITY || !BCUIActive() || gBusy)return;
    if(gBranchCompare.view==1)BCUIFile(gBranchCompare.page*GH_HISTORY_CAPACITY+at);
    else if(at<gBranchCompare.rows)BCUICommit(at);
}
static void BCUIPage(int direction) {
    int page=(int)gBranchCompare.page,offset=(int)gBranchCompare.offset,count,moved;
    size_t total=BCUITotal(),available=total-gBranchCompare.page*GH_HISTORY_CAPACITY;
    count=available>GH_HISTORY_CAPACITY?GH_HISTORY_CAPACITY:(int)available;
    moved=GHPageMove(direction,gUI.rows,count,available>GH_HISTORY_CAPACITY,&page,&offset);
    if(!moved)return;
    if(moved==2 && gBranchCompare.view!=1)
        if(BCUILoadRows(gBranchCompare.side,(size_t)page,0))return;
    gBranchCompare.page=(size_t)page;gBranchCompare.offset=(size_t)offset;
    if(gBranchCompare.view==0)BCUISummary();else BCUISelect(0);
    InvalRect(&gWindow->portRect);
}
static void BCUIDrawToolbar(void) {
    int incoming=gBranchCompare.side==BC_RIGHT;
    Box(10,101,95,124,incoming?39:238,incoming?97:238,incoming?169:238);Bevel(10,101,95,124,incoming);
    Text(17,117,gBranchCompare.pullRequest?"Base only":"Incoming",gChicago,12,incoming?255:0,incoming?255:0,incoming?255:0);
    Box(100,101,185,124,incoming?238:39,incoming?238:97,incoming?238:169);Bevel(100,101,185,124,!incoming);
    Text(106,117,gBranchCompare.pullRequest?"Proposed":"Outgoing",gChicago,12,incoming?0:255,incoming?0:255,incoming?0:255);
    if(gBranchCompare.page || gBranchCompare.offset){Bevel(190,101,209,123,0);Text(196,116,"<",gGeneva,9,0,0,0);}
    if(gBranchCompare.page*GH_HISTORY_CAPACITY+gBranchCompare.offset+gUI.rows<BCUITotal()){Bevel(211,101,230,123,0);Text(217,116,">",gGeneva,9,0,0,0);}
}
static void BCUIDrawRows(void) {
    size_t i,at;short y;char display[256],hex[41];const HCChange *file;const char *status;
    for(i=0;i<(size_t)gUI.rows && i+gBranchCompare.offset<GH_HISTORY_CAPACITY;++i) {
        at=gBranchCompare.page*GH_HISTORY_CAPACITY+gBranchCompare.offset+i;if(at>=BCUITotal())break;y=(short)(148+i*28);
        if((int)at==gBranchCompare.selected)Box(10,y-14,230,y+13,225,217,240);
        if(gBranchCompare.view==1) {
            file=gBranchCompare.files.changes+at;HistoryDisplayName(file->path,display);
            status=file->flags&HC_ADDED?"Added":file->flags&HC_DELETED?"Deleted":file->flags&HC_GITLINK?"Submodule":file->flags==HC_MODE?"Mode":file->flags==HC_MAC?"Macintosh":"Modified";
            FitText(17,y,display,gGeneva,9,205,0,0,0);Text(17,y+11,status,gGeneva,9,96,96,96);
        } else if(i+gBranchCompare.offset<gBranchCompare.rows) {
            HistoryDisplayName(gBranchCompare.messages[i+gBranchCompare.offset].summary,display);GBOIDFormat(gBranchCompare.ids[i+gBranchCompare.offset],hex);
            FitText(17,y,display,gGeneva,9,205,0,0,0);FitText(17,y+11,hex,gMonaco,9,65,96,96,96);
        }
    }
    if(!BCUITotal())Text(17,151,gBranchCompare.view==1?"No committed file changes":"No unique commits",gGeneva,9,96,96,96);
}
static void BCUIDrawHeader(void) {
    short i,l,r;int on;char title[256];const char *labels[3]={"Summary","Files","Commits"};
    Text(255,86,gBranchCompare.pullRequest?"Pull Request Preview":"Branch Comparison",gChicago,12,255,255,255);
    if(gBranchCompare.pullRequest){BCUIName(gBranchCompare.other,title);FitText(420,86,title,gGeneva,9,(short)(RightEdge(772)-420),255,255,255);}
    if(gBranchCompare.view==1 && gBranchCompare.selected>=0)
        HistoryDisplayName(gBranchCompare.files.changes[gBranchCompare.selected].path,title);
    else snprintf(title,sizeof(title),"%s branch %s",BCUISide(),gBranchCompare.view==2?"commits":"summary");
    FitText(255,113,title,gChicago,12,RightEdge(525),0,0,0);
    for(i=0;i<3;++i){l=(short)(255+i*120);r=(short)(i==2?600:l+110);on=gBranchCompare.view==i;
        Box(l,119,r,144,on?39:238,on?97:238,on?169:238);Bevel(l,119,r,144,on);
        Text(l+10,136,labels[i],gChicago,12,on?255:0,on?255:0,on?255:0);}
}
static void CompareBranch(void) {
    CUIBranches branches;BCGraph graph;BCLimits limits;GSRepository reader;
    char *chosen,*other=NULL,*current=NULL,*check=NULL;size_t n,rows=0;
    unsigned char left[20],right[20],again[20];
    static unsigned char ids[GH_HISTORY_CAPACITY][20];static GHCommitInfo info[GH_HISTORY_CAPACITY];int error,closed,entered=0;
    if(!gLocal || !gWork.haveHead || gLocalBlocked || gBusy)return;
    error=CUILoadNamed(&branches,1);
    if(error){CUIFree(&branches);LocalError("Read comparison branches",error);return;}
    chosen=CUIPickNamed(&branches,"Compare to Branch");
    if(!chosen || gDone){CUIFree(&branches);return;}
    n=strlen(chosen);other=(char *)malloc(n+1);if(other)memcpy(other,chosen,n+1);
    CUIFree(&branches);
    if(!other){LocalError("Compare branches",GB_MEMORY);return;}
    BCInit(&graph);BCUIReader(&reader);reader.read=BCUIRead;
    gBusy=1;gCancel=0;LocalEditState();SetStatus("Reading complete branch ancestry... Escape cancels.");
    error=GSMacEnter(&gWork.database,0);if(!error)entered=1;
    if(!error)error=GSHead(&reader,&current,left);
    if(!error && (strcmp(current,gWork.branch) || memcmp(left,gWork.tip,20)))error=GS_CONFLICT;
    if(!error)error=GSReadRef(&reader,other,right);
    limits.commits=4096;limits.parents=65536;limits.objectBytes=2UL*1024*1024;limits.encodedBytes=3UL*1024*1024;
    limits.readBytes=64UL*1024*1024;limits.reads=4096;
    if(!error)error=BCBuild(&reader,left,right,&limits,HistoryProgress,NULL,&graph);
    if(!error)error=BCUIReadRows(&reader,&graph,BC_RIGHT,0,info,ids,&rows);
    if(!error)error=GSHead(&reader,&check,again);
    if(!error && (strcmp(check,current) || memcmp(left,again,20)))error=GS_CONFLICT;
    free(check);check=NULL;
    if(!error)error=GSReadRef(&reader,other,again);
    if(!error && memcmp(right,again,20))error=GS_CONFLICT;
    closed=entered?GSMacLeave(&gWork.database):0;
    if(closed){gLocalBlocked=1;if(!error)error=closed;}
    gBusy=0;LocalEditState();
    if(error || gDone){BCFree(&graph);free(other);free(current);if(error && !gDone)LocalError("Compare branch ancestry",error);return;}
    LocalHistoryReset();gBranchCompare.graph=graph;gBranchCompare.current=current;gBranchCompare.other=other;
    gBranchCompare.side=BC_RIGHT;gBranchCompare.basis=graph.bases==1?0:(size_t)-1;
    gBranchCompare.rows=rows;memcpy(gBranchCompare.messages,info,rows*sizeof(*info));memcpy(gBranchCompare.ids,ids,rows*20);
    if(gCommitField){TEDeactivate(gCommitField==1?gSummaryEdit:gDescriptionEdit);gCommitField=0;}
    gBranchCompare.selected=-1;gTab=1;LocalEditState();BCUISummary();
}
