/* Local browser handoff; included after PR/default/network helpers. No HTTP. */
typedef struct {
    NetBinding binding;GUDefault observed;GUUpstream baseRoute;
    char repository[256],local[1025],head[1025],base[1025],tracking[1100];
    unsigned char tip[20],published[20];
    char *url,*details,*message;
} WUIReview;
enum {WUI_UPSTREAM=1,WUI_PUBLISH,WUI_DEFAULT,WUI_BASE,WUI_SELF};
static int WUIBase(GSRepository *reader,WUIReview *review,int *notice) {
    int result,exists,source;const char *selected;
    result=GUDefaultRead(reader,review->repository,&review->observed,&exists);if(result)return result;
    if(gBranchCompare.pullRequest) {
        if(!gBranchCompare.current || !gBranchCompare.other || !gBranchCompare.pullOwner ||
           strcmp(gBranchCompare.current,review->local) || strcmp(gBranchCompare.pullOwner,review->repository) ||
           memcmp(gBranchCompare.graph.left,review->tip,20))return GS_CONFLICT;
        selected=gBranchCompare.other;result=GSReadRef(reader,selected,review->published);
        if(result)return result;if(memcmp(review->published,gBranchCompare.graph.right,20))return GS_CONFLICT;
        if(GSValidTrackingRef(selected)) {
            strcpy(review->base,"refs/heads/");strcat(review->base,selected+sizeof("refs/remotes/origin/")-1);return 0;
        }
        result=GUUpstreamResolve(reader,review->repository,selected,review->binding.legacy,&review->baseRoute,&source);if(result)return result;
        if(review->baseRoute.tracked){
            strcpy(review->base,review->baseRoute.remoteBranch);strcpy(review->tracking,"refs/remotes/origin/");strcat(review->tracking,review->base+11);
            result=GSReadRef(reader,review->tracking,review->published);if(result==GS_NOT_FOUND)*notice=WUI_BASE;return result;
        }
        if(source!=GU_UPSTREAM_EXPLICIT && exists && review->observed.known && !strcmp(selected,review->observed.branch)){strcpy(review->base,review->observed.branch);return 0;}
        *notice=WUI_BASE;return GS_NOT_FOUND;
    }
    if(!exists || !review->observed.known){*notice=WUI_DEFAULT;return GS_NOT_FOUND;}
    strcpy(review->base,review->observed.branch);return 0;
}
static void WUINotice(int notice) {
    if(notice==WUI_UPSTREAM)Message("Choose a Published Branch","Set this branch's upstream in Repository Settings, then Push or Fetch it. The GitHub address uses that published name, including when it differs from the local name.");
    else if(notice==WUI_PUBLISH)Message("Publish These Commits First","Push this branch, then try again. The cached published tip must match the current local commit before preparing a pull request. This command does not push or fetch automatically.");
    else if(notice==WUI_DEFAULT)Message("Choose a Pull Request Base","Use Fetch Default Branch to learn the origin default, or Preview Pull Request to choose a fetched base. Then prepare the address again.");
    else if(notice==WUI_BASE)Message("Base Has No Published Route","The preview's local base has no published upstream. Choose its upstream in Repository Settings, or preview a fetched origin branch as the base.");
    else Message("Choose a Different Base","The proposed published branch and target base have the same name. Use Preview Pull Request to choose another published base.");
}
static void LocalGitHubAddress(short command) {
    WUIReview *review;GSRepository reader;OperationPrompt info;size_t n;int kind,result,closed,notice=0;
    if(!gLocal || gBusy || gLocalBlocked || gDone)return;
    kind=command==MC_NEW_ISSUE?GL_ISSUE:command==MC_BRANCH_ADDRESS?GL_BRANCH:command==MC_COMPARE_ADDRESS?GL_COMPARE:command==MC_CREATE_PR?GL_PULL_REQUEST:GL_REPOSITORY;
    if(kind>=GL_BRANCH && (!gWork.haveHead || !gWork.branch || strlen(gWork.branch)>1024)){WUINotice(WUI_PUBLISH);return;}
    review=(WUIReview *)calloc(1,sizeof(*review));if(!review){CheckoutError("GitHub Address",GB_MEMORY);return;}
    if(kind>=GL_BRANCH){strcpy(review->local,gWork.branch);memcpy(review->tip,gWork.tip,20);}
    result=CheckoutAttach(&gWork.folder);if(!result)result=GSMacEnter(&gUICheckout.store,0);
    if(!result)NetReader(&reader,&gUICheckout.store);
    if(!result && kind<GL_BRANCH)result=NetOriginRead(&gUICheckout.store,review->repository,review->binding.legacy,&review->binding.origin,&review->binding.originLength);
    if(!result && kind>=GL_BRANCH) {
        result=NetHeadCheck(&reader,review->local,review->tip,1);
        if(!result)result=NetBindingCapture(&gUICheckout.store,review->local,NULL,&review->binding);
        if(!result) {
            strcpy(review->repository,review->binding.repository);
            if(!review->binding.route.tracked){notice=WUI_UPSTREAM;result=GS_NOT_FOUND;}
        }
        if(!result) {
            strcpy(review->head,review->binding.route.remoteBranch);strcpy(review->tracking,"refs/remotes/origin/");strcat(review->tracking,review->head+11);
            result=GSReadRef(&reader,review->tracking,review->published);
            if(result==GS_NOT_FOUND){notice=WUI_PUBLISH;}
            if(!result && kind==GL_PULL_REQUEST && memcmp(review->published,review->tip,20)){notice=WUI_PUBLISH;result=GS_CONFLICT;}
        }
        if(!result && kind>=GL_COMPARE)result=WUIBase(&reader,review,&notice);
        if(!result && kind==GL_PULL_REQUEST && !strcmp(review->base,review->head)){notice=WUI_SELF;result=GS_CONFLICT;}
    }
    if(!result)result=GLAddress(review->repository,review->base,review->head,kind,&review->url);
    if(!result && kind>=GL_BRANCH)result=NetHeadCheck(&reader,review->local,review->tip,1);
    if(!result)result=kind>=GL_BRANCH?NetBindingCheck(&gUICheckout.store,&review->binding):NetExact(&gUICheckout.store,"ghclient-origin",review->binding.origin,review->binding.originLength);
    closed=CheckoutRelease();if(closed){gLocalBlocked=1;notice=0;if(!result)result=closed;}
    if(!result && !gDone) {
        memset(&info,0,sizeof(info));info.title=kind==GL_PULL_REQUEST?"Create Pull Request on GitHub":"GitHub Address";info.repository=review->repository;
        info.state="Open this address in a modern browser. Copy copies the complete address only.";
        info.primaryText=kind>=GL_BRANCH?"Uses the configured published branch. GitHub compares its current remote state.":"Open the configured GitHub origin.";
        info.footer="This command reads local settings without contacting GitHub or changing repository files.";
        if(kind>=GL_BRANCH){info.labels[0]="Local branch";info.values[0]=review->local;info.labels[1]="Published branch";info.values[1]=review->head;}
        if(kind>=GL_COMPARE){info.labels[2]="Target base";info.values[2]=review->base;}
        review->details=OperationDetails(&info);
        if(!review->details)result=GB_MEMORY;
        if(!result){n=strlen(review->url)+strlen(review->details)+5;review->message=(char *)malloc(n);if(!review->message)result=GB_MEMORY;
            else {snprintf(review->message,n,"%s\r\r%s",review->url,review->details);Message(info.title,review->message);}}
    }
    if(result && !gDone){if(notice)WUINotice(notice);else CheckoutError("GitHub Address",result);}
    NetBindingFree(&review->binding);free(review->url);free(review->details);free(review->message);free(review);
}
