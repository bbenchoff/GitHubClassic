#include "GitWorkspaceRestore.h"
#include <stdlib.h>
#include <string.h>

static int WRReserved(const char *path) {
    size_t n=sizeof(GI_MAC_NAMESPACE)-1;
    return !strncmp(path,GI_MAC_NAMESPACE,n) && (!path[n] || path[n]=='/');
}
static int WRFail(GQError *why,const char *path) {
    size_t n;
    if(why) {
        why->reason=GQ_STAGED;n=strlen(path);if(n>=sizeof(why->path))n=sizeof(why->path)-1;
        memcpy(why->path,path,n);why->path[n]=0;
    }
    return GS_CONFLICT;
}
static int WREntrySame(const GIEntry *a,const GIEntry *b) {
    return (!a && !b) || (a && b && a->stat[6]==b->stat[6] && !memcmp(a->oid,b->oid,20) &&
        (a->flags&0xf000U)==(b->flags&0xf000U) && a->extended==b->extended);
}
static int WRIndexSame(const GIIndex *a,const GIIndex *b) {
    size_t i;if(a->count!=b->count)return 0;
    for(i=0;i<a->count;++i)
        if(strcmp(a->entries[i].path,b->entries[i].path) || !WREntrySame(a->entries+i,b->entries+i))return 0;
    return 1;
}
static int WRGroupSame(const GIIndex *a,const GIIndex *b,const char *path) {
    char metadata[96];int result=GIMacMetadataPath(path,metadata);if(result)return result;
    return WREntrySame(GIFind(a,path,0),GIFind(b,path,0)) &&
        WREntrySame(GIFind(a,metadata,0),GIFind(b,metadata,0))?0:GS_CONFLICT;
}
/* Bound the expanded, reencodable representation before any deep clone or
   snapshot allocation. Parsed v4 prefix compression must not hide huge paths. */
static int WRBounds(const GIIndex *index,const WSLimits *l,size_t *bytes,size_t *files) {
    size_t i,n,cost,total=32,count=0;
    if(!index || (index->count && !index->entries) || index->count>l->files*4)return GB_SPACE;
    if(index->originalLength>l->stateBytes || (index->originalLength && !index->original))return GB_SPACE;
    for(i=0;i<index->count;++i) {
        const GIEntry *e=index->entries+i;
        if(!e->path || !GIValidPath(e->path))return GS_FORMAT;
        if((e->flags>>12)&3)return GI_UNMERGED;
        if(e->extended)return GI_UNSUPPORTED;
        n=strlen(e->path);
        if(n>l->pathBytes || n>(size_t)-1-72)return GB_SPACE;
        cost=(n+70)&~(size_t)7;
        if(total>l->stateBytes || cost>l->stateBytes-total)return GB_SPACE;
        total+=cost;if(!WRReserved(e->path) && ++count>l->files)return GB_SPACE;
    }
    if(bytes)*bytes=total;
    if(files)*files=count;
    return 0;
}
static int WRClone(const GIIndex *source,GIIndex *out) {
    size_t i,n;
    if(source->count>(size_t)-1/sizeof(*out->entries))return GB_SPACE;
    if(source->count){out->entries=(GIEntry *)calloc(source->count,sizeof(*out->entries));if(!out->entries)return GB_MEMORY;}
    for(i=0;i<source->count;++i) {
        GIEntry *d=out->entries+i;*d=source->entries[i];d->path=NULL;++out->count;
        n=strlen(source->entries[i].path)+1;d->path=(char *)malloc(n);if(!d->path)return GB_MEMORY;
        memcpy(d->path,source->entries[i].path,n);
    }
    if(source->original) {
        out->original=(unsigned char *)malloc(source->originalLength?source->originalLength:1);
        if(!out->original)return GB_MEMORY;
        memcpy(out->original,source->original,source->originalLength);out->originalLength=source->originalLength;
    }
    return 0;
}
static int WRSet(GIIndex *index,const GIEntry *e,const WSLimits *l) {
    const GIEntry *old;GIEntry *next;size_t total,files,cost;int result;
    if(!e)return 0;
    result=WRBounds(index,l,&total,&files);if(result)return result;
    old=GIFind(index,e->path,0);cost=(strlen(e->path)+70)&~(size_t)7;
    if(old)total-=(strlen(old->path)+70)&~(size_t)7;
    if(cost>l->stateBytes-total || (!old && index->count>=l->files*4) ||
        (!old && !WRReserved(e->path) && files>=l->files))return GB_SPACE;
    result=GISet(index,e->path,e->stat[6],e->oid,e->stat[9]);
    if(!result) {
        next=(GIEntry *)GIFind(index,e->path,0);if(!next)return GS_FORMAT;
        memcpy(next->stat,e->stat,sizeof(next->stat));next->flags=e->flags;next->extended=e->extended;
    }
    return result;
}
static int WRNoWrite(void *ctx,const char *key,const void *a,size_t an,const void *b,size_t bn) {
    (void)ctx;(void)key;(void)a;(void)an;(void)b;(void)bn;return GS_FORMAT;
}
int WRMergeIndex(GSRepository *source,const GIIndex *original,const GIIndex *expected,const GIIndex *current,
    const GQProtection *paths,const WSLimits *l,GIIndex *out,int *wireChoice,GQError *why) {
    GIIndex next;GRSnapshot snapshots[3];GSRepository r;
    const GIEntry *ov,*ev,*cv,*version;size_t i;char metadata[96];int result=0,needVersion=0,choice;
    if(!source || !source->read || !original || !expected || !current || !paths || !out || !wireChoice ||
        out==original || out==expected || out==current || !l || l->stateBytes<32 || !l->files || l->files>(size_t)-1/4 ||
        !l->paths || !l->pathBytes || paths->changed || paths->count>l->paths || (paths->count && !paths->paths))return GB_BAD;
    GIInit(&next);for(i=0;i<3;++i)GRInit(snapshots+i);r=*source;r.replace=WRNoWrite;
    for(i=0;i<paths->count;++i)
        if(!GIValidPath(paths->paths[i]) || WRReserved(paths->paths[i]) || strlen(paths->paths[i])>l->pathBytes ||
            (i && strcmp(paths->paths[i-1],paths->paths[i])>=0)){result=GB_BAD;break;}
    if(!result)result=WRBounds(original,l,NULL,NULL);
    if(!result)result=WRBounds(expected,l,NULL,NULL);
    if(!result)result=WRBounds(current,l,NULL,NULL);
    if(!result)result=GRFromIndex(&r,original,snapshots);
    if(!result)result=GRFromIndex(&r,expected,snapshots+1);
    if(!result)result=GRFromIndex(&r,current,snapshots+2);
    for(i=0;!result && i<paths->count;++i) {
        result=WRGroupSame(current,expected,paths->paths[i]);
        if(result==GS_CONFLICT)result=WRFail(why,paths->paths[i]);
    }
    if(!result)result=WRClone(current,&next);
    /* A file may replace an original directory, or the reverse. Remove every
       selected group first so insertion order cannot discard an old sibling. */
    for(i=0;!result && i<paths->count;++i)result=GIRemoveMac(&next,paths->paths[i]);
    for(i=0;!result && i<paths->count;++i) {
        result=WRSet(&next,GIFind(original,paths->paths[i],0),l);
        if(!result)result=GIMacMetadataPath(paths->paths[i],metadata);
        if(!result)result=WRSet(&next,GIFind(original,metadata,0),l);
        if(result==GS_CONFLICT)result=WRFail(why,paths->paths[i]);
    }
    ov=GIFind(original,GI_MAC_NAMESPACE "/version",0);ev=GIFind(expected,GI_MAC_NAMESPACE "/version",0);
    cv=GIFind(current,GI_MAC_NAMESPACE "/version",0);version=cv;
    if(!result) {
        if(WREntrySame(cv,ev))version=ov;
        else if(!WREntrySame(ov,ev) && !WREntrySame(cv,ov))result=WRFail(why,GI_MAC_NAMESPACE "/version");
        for(i=0;!result && i<next.count;++i)
            if(WRReserved(next.entries[i].path) && strcmp(next.entries[i].path,GI_MAC_NAMESPACE "/version"))needVersion=1;
        /* Later unrelated forks still need their current declaration. A later
           explicit removal cannot be silently undone to restore new forks. */
        if(!result && needVersion && !version) {
            if(cv)version=cv;else result=WRFail(why,GI_MAC_NAMESPACE "/version");
        }
        if(!result) {
            if(version)result=WRSet(&next,version,l);
            else result=GIRemove(&next,GI_MAC_NAMESPACE "/version");
        }
    }
    if(!result)result=WRBounds(&next,l,NULL,NULL);
    if(!result){GRFree(snapshots);result=GRFromIndex(&r,&next,snapshots);}
    if(!result) {
        choice=WRIndexSame(&next,original)?WR_ORIGINAL_INDEX:WRIndexSame(&next,current)?WR_CURRENT_INDEX:WR_MERGED_INDEX;
        GIFree(out);*out=next;GIInit(&next);*wireChoice=choice;
    }
    GIFree(&next);for(i=0;i<3;++i)GRFree(snapshots+i);return result;
}
