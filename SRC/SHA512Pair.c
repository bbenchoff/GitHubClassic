/* SHA-384/512 with explicit 32-bit halves for CW4's 68K ABI.
   Constants are generated from the bundled upstream SHA-512 table. */
#include <string.h>
#ifndef GH512Context
typedef struct { unsigned int high,low; } GHWord64;
typedef struct { GHWord64 total[2],state[8];unsigned char buffer[128];int is384; } GH512Context;
#endif
#include "SHA512Constants.h"
static GHWord64 Pair(unsigned long high,unsigned long low) {GHWord64 w;w.high=high;w.low=low;return w;}
static GHWord64 Add64(GHWord64 a,GHWord64 b) {GHWord64 c;c.low=a.low+b.low;c.high=a.high+b.high+(c.low<a.low);return c;}
static GHWord64 Xor64(GHWord64 a,GHWord64 b) {return Pair(a.high^b.high,a.low^b.low);}
static GHWord64 Rotate64(GHWord64 a,int n) {
    if(n==32) return Pair(a.low,a.high);
    if(n>32) return Rotate64(Pair(a.low,a.high),n-32);
    return Pair((a.high>>n)|(a.low<<(32-n)),(a.low>>n)|(a.high<<(32-n)));
}
static GHWord64 Shift64(GHWord64 a,int n) {
    return n>=32 ? Pair(0,a.high>>(n-32)) : Pair(a.high>>n,(a.low>>n)|(a.high<<(32-n)));
}
static GHWord64 Sigma64(GHWord64 a,int x,int y,int z,int shift) {
    return Xor64(Xor64(Rotate64(a,x),Rotate64(a,y)),shift?Shift64(a,z):Rotate64(a,z));
}
static unsigned long Get32(const unsigned char *p) {
    return ((unsigned long)p[0]<<24)|((unsigned long)p[1]<<16)|((unsigned long)p[2]<<8)|p[3];
}
static void Put32(unsigned long w,unsigned char *p) {p[0]=(unsigned char)(w>>24);p[1]=(unsigned char)(w>>16);p[2]=(unsigned char)(w>>8);p[3]=(unsigned char)w;}
static void GH512Block(GH512Context *ctx,const unsigned char *data) {
    GHWord64 w[80],a,b,c,d,e,f,g,h,t1,t2,choice,majority;int i;
    for(i=0;i<16;++i) w[i]=Pair(Get32(data+8*i),Get32(data+8*i+4));
    for(i=16;i<80;++i) w[i]=Add64(Add64(Sigma64(w[i-2],19,61,6,1),w[i-7]),Add64(Sigma64(w[i-15],1,8,7,1),w[i-16]));
    a=ctx->state[0];b=ctx->state[1];c=ctx->state[2];d=ctx->state[3];e=ctx->state[4];f=ctx->state[5];g=ctx->state[6];h=ctx->state[7];
    for(i=0;i<80;++i) {
        choice=Pair((e.high&f.high)^((~e.high)&g.high),(e.low&f.low)^((~e.low)&g.low));
        majority=Pair((a.high&b.high)^(a.high&c.high)^(b.high&c.high),(a.low&b.low)^(a.low&c.low)^(b.low&c.low));
        t1=Add64(Add64(Add64(h,Sigma64(e,14,18,41,0)),choice),Add64(GH512K[i],w[i]));
        t2=Add64(Sigma64(a,28,34,39,0),majority);
        h=g;g=f;f=e;e=Add64(d,t1);d=c;c=b;b=a;a=Add64(t1,t2);
    }
    ctx->state[0]=Add64(ctx->state[0],a);ctx->state[1]=Add64(ctx->state[1],b);
    ctx->state[2]=Add64(ctx->state[2],c);ctx->state[3]=Add64(ctx->state[3],d);
    ctx->state[4]=Add64(ctx->state[4],e);ctx->state[5]=Add64(ctx->state[5],f);
    ctx->state[6]=Add64(ctx->state[6],g);ctx->state[7]=Add64(ctx->state[7],h);
    memset(w,0,sizeof(w));
}
static int GH512Start(GH512Context *ctx,int is384) {
    int i;if(is384!=0 && is384!=1)return -1;memset(ctx,0,sizeof(*ctx));ctx->is384=is384;
    for(i=0;i<8;++i) ctx->state[i]=GH512Initial[is384][i];
    return 0;
}
static int GH512Update(GH512Context *ctx,const unsigned char *data,size_t length) {
    size_t left=(size_t)(ctx->total[0].low&127),take;GHWord64 old=ctx->total[0];
    ctx->total[0]=Add64(old,Pair(0,(unsigned long)length));
    if(ctx->total[0].high<old.high || (ctx->total[0].high==old.high && ctx->total[0].low<old.low))
        ctx->total[1]=Add64(ctx->total[1],Pair(0,1));
    while(length) {take=128-left;if(take>length)take=length;memcpy(ctx->buffer+left,data,take);left+=take;data+=take;length-=take;if(left==128) {GH512Block(ctx,ctx->buffer);left=0;}}
    return 0;
}
static int GH512Finish(GH512Context *ctx,unsigned char *output) {
    unsigned char pad[128],bits[16];size_t left=(size_t)(ctx->total[0].low&127);GHWord64 high,low;int i;
    high=Pair((ctx->total[1].high<<3)|(ctx->total[1].low>>29),(ctx->total[1].low<<3)|(ctx->total[0].high>>29));
    low=Pair((ctx->total[0].high<<3)|(ctx->total[0].low>>29),ctx->total[0].low<<3);
    Put32(high.high,bits);Put32(high.low,bits+4);Put32(low.high,bits+8);Put32(low.low,bits+12);
    memset(pad,0,sizeof(pad));pad[0]=128;GH512Update(ctx,pad,left<112 ? 112-left : 240-left);GH512Update(ctx,bits,16);
    for(i=0;i<(ctx->is384?6:8);++i) {Put32(ctx->state[i].high,output+8*i);Put32(ctx->state[i].low,output+8*i+4);}return 0;
}
