#include "GitBranchEdit.h"
#include "GitUpstream.h"
#include "GitHistory.h"
#include "GHCore.h"
#include <stdlib.h>
#include <string.h>

void BEInit(BEPlan *p){memset(p,0,sizeof(*p));}
void BEFree(BEPlan *p){GCFree(&p->transaction);free(p->source);free(p->target);BEInit(p);}
static void BEHash(const void *p,size_t n,unsigned char hash[20]) {
    GBSHA1 h;GBSHA1Start(&h);GBSHA1Update(&h,p,n);GBSHA1Finish(&h,hash);
}
static void *BECopy(const void *p,size_t n) {
    void *b=malloc(n?n:1);if(b && n)memcpy(b,p,n);return b;
}
static GCMetadata *BEFind(GCTransaction *t,const char *key) {
    size_t i;for(i=0;i<t->metadataCount;++i)if(!strcmp(t->metadata[i].path,key))return t->metadata+i;
    return NULL;
}
static int BECapture(GSRepository *r,GCTransaction *t,const char *key,size_t max) {
    GCMetadata *m,*grown;unsigned char *b=NULL;size_t n=0;int result;
    if(BEFind(t,key))return 0;
    result=r->read(r->context,key,&b,&n);
    if(result && result!=GS_NOT_FOUND){free(b);return result;}
    if(!result && (!b || n>max)){free(b);return n>max?GB_SPACE:GS_FORMAT;}
    grown=(GCMetadata *)realloc(t->metadata,(t->metadataCount+1)*sizeof(*grown));
    if(!grown){free(b);return GB_MEMORY;}
    t->metadata=grown;m=grown+t->metadataCount++;memset(m,0,sizeof(*m));
    m->path=(char *)BECopy(key,strlen(key)+1);
    if(!m->path){free(b);return GB_MEMORY;}
    if(!result){m->before=b;m->beforeLength=n;m->beforePresent=1;
        m->after=(unsigned char *)BECopy(b,n);if(!m->after)return GB_MEMORY;
        m->afterLength=n;m->afterPresent=1;
    }else free(b);
    return 0;
}
static int BEAfter(GCMetadata *m,const void *p,size_t n,int present) {
    unsigned char *b=NULL;
    if(!m || (present!=0 && present!=1) || (!present && n))return GB_BAD;
    if(present){b=(unsigned char *)BECopy(p,n);if(!b)return GB_MEMORY;}
    free(m->after);m->after=b;m->afterLength=n;m->afterPresent=present;return 0;
}
static int BERef(GSRepository *r,GCTransaction *t,const char *name,const unsigned char *tip,size_t max) {
    char key[64],hex[41];GCMetadata *m;int result=GSRefKey(name,key);size_t n=strlen(name);
    if(!result)result=BECapture(r,t,key,max);
    if(result)return result;
    m=BEFind(t,key);if(m->beforePresent!=(tip!=NULL))return GS_CONFLICT;
    if(!tip)return 0;
    GBOIDFormat(tip,hex);
    return m->beforeLength==n+42 && !memcmp(m->before,name,n+1) &&
        !memcmp(m->before+n+1,hex,40) && m->before[n+41]=='\n'?0:GS_CONFLICT;
}
static int BECommit(GSRepository *r,const unsigned char *tip) {
    unsigned char *body=NULL;size_t n=0;char type[7];GHCommitInfo info;int result;
    if(!tip)return 0;
    result=GSGetObject(r,tip,type,&body,&n);
    if(!result)result=strcmp(type,"commit")?GS_FORMAT:GHCommitParse(body,n,&info);
    free(body);return result;
}
/* The legacy origin default is an effective upstream only for an exactly
   equal local name. Materialize that effective mapping at the renamed name. */
static int BEOrigin(const GCMetadata *m,char repo[255],char branch[1025]) {
    const unsigned char *a,*b;size_t rn,bn;
    repo[0]=branch[0]=0;if(!m->beforePresent)return 0;
    if(m->beforeLength<13 || m->beforeLength>2048 ||
       memcmp(m->before,"GHOrigin1\n",10) || memchr(m->before,0,m->beforeLength))return GS_FORMAT;
    a=(const unsigned char *)memchr(m->before+10,'\n',m->beforeLength-10);if(!a)return GS_FORMAT;
    rn=(size_t)(a-m->before)-10;
    b=(const unsigned char *)memchr(a+1,'\n',m->beforeLength-(size_t)(a+1-m->before));
    if(!b || b!=m->before+m->beforeLength-1)return GS_FORMAT;
    bn=(size_t)(b-a)-1;if(!rn || rn>254 || !bn || bn>1024)return GS_FORMAT;
    memcpy(repo,m->before+10,rn);repo[rn]=0;memcpy(branch,a+1,bn);branch[bn]=0;
    return GHValidRepository(repo) && GSValidRef(branch)?0:GS_FORMAT;
}
static int BEUpstream(GSRepository *r,BEPlan *p,size_t max) {
    char oldKey[80],newKey[80],repo[255],legacy[1025];GUUpstream u;
    GCMetadata *old,*next;unsigned char *encoded=NULL;size_t n=0;int result,have=0;
    result=BEOrigin(BEFind(&p->transaction,"ghclient-origin"),repo,legacy);
    if(!result)result=GUUpstreamKey(p->source,oldKey);
    if(!result)result=BECapture(r,&p->transaction,oldKey,max);
    if(result)return result;
    old=BEFind(&p->transaction,oldKey);GUUpstreamInit(&u);
    if(old->beforePresent) {
        result=GUUpstreamParse(old->before,old->beforeLength,&u);
        if(!result && (strcmp(u.localBranch,p->source) ||
            (repo[0] && strcmp(u.repository,repo))))result=GS_CONFLICT;
        if(result)return result;
        have=1;
    } else if(repo[0]) {
        strcpy(u.repository,repo);strcpy(u.localBranch,p->source);
        if(!strcmp(legacy,p->source)){u.tracked=1;strcpy(u.remoteBranch,legacy);}have=1;
    }
    result=BEAfter(old,NULL,0,0);if(result || p->kind==BE_DELETE)return result;
    result=GUUpstreamKey(p->target,newKey);
    if(!result)result=BECapture(r,&p->transaction,newKey,max);
    if(result)return result;
    next=BEFind(&p->transaction,newKey);if(next->beforePresent)return GS_CONFLICT;
    if(have) {
        strcpy(u.localBranch,p->target);result=GUUpstreamEncode(&u,&encoded,&n);
        if(!result)result=BEAfter(next,encoded,n,1);
        free(encoded);
    }
    return result;
}
static int BEEqual(void *ctx,const char *a,const char *b){(void)ctx;return !strcmp(a,b);}
static int BELog(GSRepository *r,BEPlan *p,size_t max) {
    unsigned char *encoded=NULL,digest[20];char hex[41],key[80];size_t n=0;GCMetadata *m;
    int result=GCEncode(&p->transaction,BEEqual,NULL,&encoded,&n);
    if(!result && n>max)result=GB_SPACE;
    if(!result) {
        BEHash(encoded,n,digest);GBOIDFormat(digest,hex);
        strcpy(key,"ghclient-branch-log/");strncat(key,hex,2);strcat(key,"/");
        strncat(key,hex+2,12);strcat(key,"/");strcat(key,hex+14);
        result=BECapture(r,&p->transaction,key,max);
        if(!result){m=BEFind(&p->transaction,key);if(m->beforePresent)result=GS_CONFLICT;
            else result=BEAfter(m,encoded,n,1);}
    }
    free(encoded);return result;
}
static int BEIdlePush(const GCMetadata *m) {
    unsigned char digest[20];
    if(!m->beforePresent)return 0;
    BEHash("GHPUSH00",8,digest);
    return m->beforeLength==28 && !memcmp(m->before,"GHPUSH00",8) &&
        !memcmp(m->before+8,digest,20)?0:BE_PENDING_PUSH;
}
int BEPrepare(GSRepository *r,int kind,const char *current,const unsigned char *currentTip,
    const char *source,const unsigned char *sourceTip,const char *target,
    const BELimits *limits,BENamespace names,void *nameCtx,GOProgress progress,void *ctx,BEPlan *out) {
    BEPlan next;GOReader bounded;GSRepository objects;GCMetadata *m;
    unsigned char *bytes=NULL;size_t n,i,total=0;char key[64],hex[41];
    int result,found=0;
    if(!r || !r->read || !r->replace || !out || !limits || !limits->stateBytes ||
       !GSValidRef(current) || strlen(current)>1024 || !GSValidRef(source) || strlen(source)>1024 ||
       (kind!=BE_RENAME && kind!=BE_DELETE) ||
       (kind==BE_RENAME && (!target || !names || !GSValidRef(target) || strlen(target)>1024 || !strcmp(source,target))) ||
       (kind==BE_DELETE && (target || !sourceTip)) ||
       (!sourceTip && (kind!=BE_RENAME || strcmp(current,source) || currentTip)) ||
       (!strcmp(current,source) && ((currentTip!=NULL)!=(sourceTip!=NULL) ||
           (currentTip && memcmp(currentTip,sourceTip,20)))))return GB_BAD;
    if(kind==BE_DELETE && !strcmp(source,current))return BE_CURRENT;
    BEInit(&next);next.kind=kind;next.merged=1;
    next.source=(char *)BECopy(source,strlen(source)+1);
    if(target)next.target=(char *)BECopy(target,strlen(target)+1);
    result=(!next.source || (target && !next.target))?GB_MEMORY:GTNormalWriteAllowed(r);
    if(!result)result=GTNextGeneration(r,&next.transaction.generation);
    next.transaction.phase=GC_PREPARE;
    if(!result && target)result=names(nameCtx,source,target);
    if(!result)result=BECapture(r,&next.transaction,"HEAD",limits->stateBytes);
    if(!result) {
        m=BEFind(&next.transaction,"HEAD");n=strlen(current);
        if(!m->beforePresent || m->beforeLength!=n+6 || memcmp(m->before,"ref: ",5) ||
           memcmp(m->before+5,current,n) || m->before[n+5]!='\n')result=GS_CONFLICT;
    }
    if(!result)result=BERef(r,&next.transaction,current,currentTip,limits->stateBytes);
    if(!result)result=BERef(r,&next.transaction,source,sourceTip,limits->stateBytes);
    if(!result)result=BECapture(r,&next.transaction,"index",limits->stateBytes);
    if(!result)result=BECapture(r,&next.transaction,"ghclient-map",limits->stateBytes);
    if(!result)result=BECapture(r,&next.transaction,"ghclient-origin",limits->stateBytes);
    if(!result)result=BECapture(r,&next.transaction,"ghclient-push",limits->stateBytes);
    if(!result)result=BEIdlePush(BEFind(&next.transaction,"ghclient-push"));
    if(!result)result=GOReadStart(r,&limits->read,progress,ctx,&bounded,&objects);
    if(!result)result=BECommit(&objects,currentTip);
    if(!result)result=BECommit(&objects,sourceTip);
    if(!result && kind==BE_DELETE) {
        if(currentTip)result=GVIsAncestor(&objects,sourceTip,currentTip,&limits->graph,NULL,NULL,&found);
        next.merged=found;
    }
    if(!result && target) {
        result=BERef(r,&next.transaction,target,NULL,limits->stateBytes);
        if(!result && sourceTip) {
            n=strlen(target);bytes=(unsigned char *)malloc(n+42);if(!bytes)result=GB_MEMORY;
            else {GBOIDFormat(sourceTip,hex);memcpy(bytes,target,n+1);memcpy(bytes+n+1,hex,40);bytes[n+41]='\n';
                GSRefKey(target,key);result=BEAfter(BEFind(&next.transaction,key),bytes,n+42,1);free(bytes);bytes=NULL;}
        }
        if(!result && !strcmp(current,source)) {
            n=strlen(target);bytes=(unsigned char *)malloc(n+6);if(!bytes)result=GB_MEMORY;
            else {memcpy(bytes,"ref: ",5);memcpy(bytes+5,target,n);bytes[n+5]='\n';
                result=BEAfter(BEFind(&next.transaction,"HEAD"),bytes,n+6,1);free(bytes);bytes=NULL;}
        }
    }
    if(!result){GSRefKey(source,key);result=BEAfter(BEFind(&next.transaction,key),NULL,0,0);}
    if(!result)result=BEUpstream(r,&next,limits->stateBytes);
    for(i=0;!result && i<next.transaction.metadataCount;++i) {
        m=next.transaction.metadata+i;
        if(m->beforeLength>limits->stateBytes-total)result=GB_SPACE;
        else total+=m->beforeLength;
        if(!result && m->afterLength>limits->stateBytes-total)result=GB_SPACE;
        else if(!result)total+=m->afterLength;
    }
    if(!result)result=BELog(r,&next,limits->stateBytes);
    if(!result)result=BECheck(r,&next,names,nameCtx,1);
    if(!result){BEFree(out);*out=next;BEInit(&next);}
    BEFree(&next);return result;
}
int BECheck(GSRepository *r,const BEPlan *p,BENamespace names,void *nameCtx,int allowUnmerged) {
    const GCMetadata *m;unsigned char *b=NULL;size_t i,n=0;GBWord generation;int result,present;
    if(!r || !r->read || !p || (p->kind!=BE_RENAME && p->kind!=BE_DELETE) ||
       (allowUnmerged!=0 && allowUnmerged!=1) || p->transaction.fileCount ||
       !p->source || !GSValidRef(p->source) ||
       (p->kind==BE_RENAME && (!p->target || !GSValidRef(p->target) || !names)))return GB_BAD;
    if(p->kind==BE_DELETE && !p->merged && !allowUnmerged)return BE_UNMERGED;
    result=GTNormalWriteAllowed(r);
    if(!result)result=GTNextGeneration(r,&generation);
    if(!result && generation!=p->transaction.generation)result=GS_CONFLICT;
    if(!result && p->kind==BE_RENAME)result=names(nameCtx,p->source,p->target);
    for(i=0;!result && i<p->transaction.metadataCount;++i) {
        m=p->transaction.metadata+i;result=r->read(r->context,m->path,&b,&n);present=!result;
        if(result==GS_NOT_FOUND)result=0;
        if(!result && (present!=m->beforePresent || (present &&
            (!b || n!=m->beforeLength || (n && memcmp(b,m->before,n))))))result=GS_CONFLICT;
        free(b);b=NULL;
    }
    return result;
}
