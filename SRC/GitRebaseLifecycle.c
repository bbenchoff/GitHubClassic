#include "GitRebaseLifecycle.h"
#include "GitWorkspacePlanSupport.h"
#include <stdlib.h>
#include <string.h>

void RLSessionInit(RLSession *s){memset(s,0,sizeof(*s));}
void RLSessionFree(RLSession *s){RKFree(&s->state);RVFree(&s->replay);MSWorkspaceFree(&s->drafts);GRFree(&s->preview);GIFree(&s->workIndex);GIFree(&s->index);GPFree(&s->mapping);RLSessionInit(s);}
void RLInit(RLPlan *p){memset(p,0,sizeof(*p));}
void RLFree(RLPlan *p){RKFree(&p->state);GQFree(&p->checkout);RLInit(p);}
typedef struct {GSRepository *source,objects;GOReader object;const RLLimits *limits;size_t bytes,reads;GDProgress progress;void *context;} RLIO;
static int RLTick(RLIO *io){return io->progress?io->progress(io->context):0;}
static int RLRead(void *context,const char *key,unsigned char **bytes,size_t *n) {
    RLIO *io=(RLIO *)context;size_t maximum;int result;*bytes=NULL;*n=0;
    if(!strncmp(key,"objects/",8)) {
        io->object.limits.reads=io->limits->replay.all.reads-io->reads;
        io->object.limits.readBytes=io->limits->replay.all.readBytes-io->bytes;
        return io->objects.read(io->objects.context,key,bytes,n);
    }
    if(io->reads>=io->limits->replay.all.reads-io->object.reads)return GB_SPACE;
    ++io->reads;maximum=!strcmp(key,"checkout-journal") || !strcmp(key,"checkout-intent")?io->limits->journalBytes:io->limits->state.records.bytes;
    result=RLTick(io);if(!result)result=io->source->read(io->source->context,key,bytes,n);
    if(!result && (*n>maximum || *n>io->limits->replay.all.readBytes-io->bytes ||
        io->object.bytes>io->limits->replay.all.readBytes-io->bytes-*n || io->object.expanded>io->limits->replay.all.readBytes-io->bytes-*n))result=GB_SPACE;
    if(!result){io->bytes+=*n;result=RLTick(io);}if(result){free(*bytes);*bytes=NULL;*n=0;}return result;
}
static int RLWrite(void *context,const char *key,const void *old,size_t on,const void *next,size_t nn) {
    RLIO *io=(RLIO *)context;int result;if(strncmp(key,"objects/",8) || old || on || !next || !nn)return GB_BAD;
    result=RLTick(io);if(!result)result=io->source->replace(io->source->context,key,NULL,0,next,nn);if(!result)result=RLTick(io);return result;
}
static int RLIOStart(GSRepository *source,const RLLimits *limits,GDProgress fn,void *ctx,RLIO *io,GSRepository *r) {
    int result;if(!source || !source->read || !limits || !limits->state.records.bytes || limits->state.records.bytes>16777216UL ||
        !limits->journalBytes || limits->journalBytes>67108864UL || !limits->state.records.paths || limits->state.records.paths>65536UL)return GB_BAD;
    memset(io,0,sizeof(*io));io->source=source;io->limits=limits;io->progress=fn;io->context=ctx;
    result=GOReadStart(source,&limits->replay.all,fn,ctx,&io->object,&io->objects);
    if(!result){r->context=io;r->read=RLRead;r->replace=source->replace?RLWrite:WXReadOnly;}return result;
}
static int RLAffected(WXKeys *paths,const GRSnapshot *original,const RSStep *step,const MSChoices *choices,const GRSnapshot *preview,const MSLimits *limits) {
    const TMNode *node;size_t i,j,a=0,b=0;int result=0,order;
    for(i=0;!result && i<step->merge.count;++i){node=step->merge.files+i;if(!node->conflicts)continue;result=WXPathAdd(paths,limits,node->path);
        for(j=0;!result && j<3;++j)if(node->source[j]!=TM_NONE)result=WXPathAdd(paths,limits,step->merge.snapshots[j].files[node->source[j]].path);}
    for(i=0;!result && i<choices->count;++i)for(j=0;!result && j<choices->items[i].count;++j)result=WXPathAdd(paths,limits,choices->items[i].files[j].path);
    while(!result && (a<original->count || b<preview->count)) {
        order=a==original->count?1:b==preview->count?-1:strcmp(original->files[a].path,preview->files[b].path);
        if(order<0)result=WXPathAdd(paths,limits,original->files[a++].path);
        else if(order>0)result=WXPathAdd(paths,limits,preview->files[b++].path);
        else {if(!WXFileSame(original,original->files+a,preview,preview->files+b))result=WXPathAdd(paths,limits,original->files[a].path);++a;++b;}
    }
    return result;
}
static int RLPreview(GSRepository *r,const RZState *state,const RVVerified *replay,GDProgress fn,void *ctx,MSWorkspace *drafts,unsigned char tree[20],unsigned char commit[20],GRSnapshot *preview) {
    GIReadLimits traversal;int result=RYBuildWorkspace(r,&replay->conflict,state->branch,state->ontoRef,&state->choices,fn,ctx,drafts);
    if(!result)result=TMStoreObjects(r,&drafts->preview,fn,ctx);if(!result)result=TMStoreObjects(r,&drafts->index,fn,ctx);
    if(!result)result=GIWriteTree(r,&drafts->preview.index,tree);
    if(!result)result=GSWriteCommitObject(r,tree,state->tip,1,"GHClient Replay <replay@localhost>","GHClient Replay <replay@localhost>","0","+0000","GHClient replay workspace",commit);
    memset(&traversal,0,sizeof(traversal));traversal.entries=replay->conflict.merge.limits.entries;traversal.depth=replay->conflict.merge.limits.depth;
    traversal.pathBytes=replay->conflict.merge.limits.pathBytes;traversal.progress=fn;traversal.context=ctx;
    if(!result)result=GRFromTreeBounded(r,tree,preview,&traversal);return result;
}
/* GTNextGeneration verifies the checksummed idle record and absence of any
   intent. Completed transactions are compacted to GHCI0001; their full active
   journal is deliberately not available here. Native binding, exact installed
   metadata and independently reconstructed objects establish the checkpoint.
   A later rolled-back update consumes a generation while retaining this prior
   revision, so revision need not equal the most recent idle generation. */
static int RLLive(GSRepository *r,const RKState *state,GBWord *generation) {
    const RZState *s=&state->replay;MSBytes marker;char branch[64],incoming[64];GBWord next=0;int result;
    marker.bytes=state->original;marker.length=state->originalLength;marker.present=1;
    result=GTNextGeneration(r,&next);if(!result && (!state->original || s->generation>=next || s->revision>=next || (*generation && *generation!=next)))result=GS_CONFLICT;
    if(!result)result=GSRefKey(s->branch,branch);if(!result)result=GSRefKey(s->ontoRef,incoming);if(!result && !strcmp(branch,incoming))result=GS_FORMAT;
    if(!result)result=WXMatch(r,"HEAD",s->before);if(!result)result=WXMatch(r,branch,s->before+1);if(!result)result=WXMatch(r,"index",&state->index);
    if(!result)result=WXMatch(r,"ghclient-map",&state->mapping);if(!result)result=WXMatch(r,"ghclient-rebase",&marker);
    if(!result)*generation=next;return result;
}
int RLOpen(GSRepository *source,const RLLimits *limits,const unsigned char binding[32],GPEqual eq,void *eqCtx,GDProgress fn,void *ctx,RLSession *out) {
    RLSession *next;RLIO io;GSRepository r;WXKeys required,keys;GIIndex original,expected;GPMap oldMap;unsigned char *wire=NULL,tree[20],commit[20];size_t n=0,i;GBWord generation=0;int result;
    if(!out || !binding || !eq)return GB_BAD;result=RLIOStart(source,limits,fn,ctx,&io,&r);if(result)return result;r.replace=WXReadOnly;
    next=(RLSession *)calloc(1,sizeof(*next));if(!next)return GB_MEMORY;memset(&required,0,sizeof(required));memset(&keys,0,sizeof(keys));GIInit(&original);GIInit(&expected);GPInit(&oldMap);
    result=GTNormalWriteAllowed(&r);if(result==GT_REBASE_ACTIVE)result=0;
    if(!result)result=r.read(r.context,"ghclient-rebase",&wire,&n);if(!result)result=RKParse(wire,n,&limits->state,eq,eqCtx,&next->state);
    if(!result && memcmp(binding,next->state.replay.binding,32))result=GS_CONFLICT;
    if(!result)result=RLLive(&r,&next->state,&generation);
    if(!result)result=RVVerify(&r,&next->state.replay,&limits->state,&limits->replay,eq,eqCtx,fn,ctx,&next->replay);
    if(!result)result=RLPreview(&r,&next->state.replay,&next->replay,fn,ctx,&next->drafts,tree,commit,&next->preview);
    if(!result && memcmp(commit,next->state.workspace,20))result=GS_CONFLICT;
    if(!result)result=RLAffected(&required,&next->replay.original,&next->replay.conflict,&next->state.replay.choices,&next->preview,&limits->state.records);
    if(!result)result=WXKeysMake((const char *const *)next->state.affected,next->state.affectedCount,&keys);
    for(i=0;!result && i<required.count;++i)if(!WXOwns(&keys,required.paths[i]))result=GS_CONFLICT;
    if(!result)result=GIParse(next->state.replay.before[2].bytes,next->state.replay.before[2].length,&original);
    if(!result)result=GIParse(next->state.workIndex.bytes,next->state.workIndex.length,&next->workIndex);
    if(!result)result=GIParse(next->state.index.bytes,next->state.index.length,&next->index);
    if(!result)result=WXCompose(&next->replay.original.index,&original,&next->drafts.preview.index,&keys,&expected);
    if(!result && !WXIndexSame(&expected,&next->workIndex))result=GS_CONFLICT;
    if(!result)result=WXCompose(&next->replay.original.index,&original,&next->drafts.index.index,&keys,&expected);
    if(!result && !WXIndexSame(&expected,&next->index))result=GS_CONFLICT;
    if(!result)result=GPParse(next->state.mapping.bytes,next->state.mapping.length,eq,eqCtx,&next->mapping);
    if(!result && next->state.replay.before[3].present)result=GPParse(next->state.replay.before[3].bytes,next->state.replay.before[3].length,eq,eqCtx,&oldMap);
    if(!result)result=WXMapCheck(&next->preview,&next->mapping,&oldMap,&keys,eq,eqCtx);
    if(!result)result=RLLive(&r,&next->state,&generation);if(!result)result=RLTick(&io);
    if(!result){RLSessionFree(out);*out=*next;RLSessionInit(next);}free(wire);WXKeysFree(&required);WXKeysFree(&keys);GIFree(&original);GIFree(&expected);GPFree(&oldMap);RLSessionFree(next);free(next);return result;
}
static int RLSeed(const RQReview *review,const RRResult *replay,const char *committer,const char *seconds,const char *zone,
    const RLLimits *limits,const unsigned char binding[32],GBWord generation,GPEqual eq,void *eqCtx,RZState *out) {
    RZState s;unsigned char (*proofs)[20],*wire=NULL;size_t i,n=0;int result;
    if(!review || !replay || replay->kind!=RR_CONFLICT || !replay->plan.count || replay->plan.count>limits->state.steps ||
        replay->plan.count>4096 || !replay->plan.commits || !review->graph.commits || !replay->items ||
        replay->completed>=replay->plan.count || replay->plan.kind!=RB_REPLAY ||
        review->graph.kind!=RB_REPLAY || review->graph.count!=replay->plan.count || memcmp(review->graph.commits,replay->plan.commits,replay->plan.count*20))return GB_BAD;
    RZInit(&s);proofs=(unsigned char (*)[20])calloc(replay->completed?replay->completed:1,20);if(!proofs)return GB_MEMORY;
    s.branch=review->branch;s.ontoRef=review->ontoRef;s.committer=(char *)committer;s.seconds=(char *)seconds;s.zone=(char *)zone;
    memcpy(s.head,review->graph.graph.left,20);memcpy(s.onto,review->graph.graph.right,20);memcpy(s.tip,replay->tip,20);memcpy(s.binding,binding,32);s.generation=s.revision=generation;s.newline=review->newline;
    for(i=0;i<5;++i){s.before[i].bytes=review->guards[i].bytes;s.before[i].length=review->guards[i].length;s.before[i].present=review->guards[i].present;}
    s.commits=replay->plan.commits;s.count=replay->plan.count;s.receipts=replay->items;s.completed=replay->completed;s.proofs=proofs;
    result=RZStepID(&replay->conflict,s.branch,s.ontoRef,s.planID);memcpy(s.choices.planID,s.planID,20);
    if(!result)result=RZEncode(&s,&limits->state,eq,eqCtx,&wire,&n);if(!result)result=RZParse(wire,n,&limits->state,eq,eqCtx,out);free(wire);free(proofs);return result;
}
int RLBegin(GSRepository *source,const RQReview *review,const RRResult *replay,const char *committer,const char *seconds,const char *zone,
    const RLLimits *limits,const unsigned char binding[32],const GQWork *work,size_t count,GPEqual eq,void *eqCtx,GDProgress fn,void *ctx,RLPlan *out,GQError *why) {
    RLPlan *next;RVVerified verified;MSWorkspace drafts;GRSnapshot preview;WXKeys paths,keys,protectionPaths;RLIO io;GSRepository r;GQProtection protection;
    GIIndex original,expected,actual;const GCMetadata *m,*map,*index;RKState parsed;unsigned char *wire=NULL,*bytes=NULL;size_t n=0,wn=0,i;GBWord generation=0;int result;
    if(!source || !source->replace || !review || !replay || !committer || !seconds || !zone || !binding || !out || !eq || (count && !work))return GB_BAD;
    if(why)memset(why,0,sizeof(*why));result=RLIOStart(source,limits,fn,ctx,&io,&r);if(result)return result;
    next=(RLPlan *)calloc(1,sizeof(*next));if(!next)return GB_MEMORY;RVInit(&verified);MSWorkspaceInit(&drafts);GRInit(&preview);memset(&paths,0,sizeof(paths));memset(&keys,0,sizeof(keys));memset(&protectionPaths,0,sizeof(protectionPaths));
    GIInit(&original);GIInit(&expected);GIInit(&actual);RKInit(&parsed);memset(&protection,0,sizeof(protection));
    result=RQRecheck(&r,review);if(!result)result=GTNextGeneration(&r,&generation);if(!result && generation==0xffffffffU)result=GB_SPACE;
    if(!result)result=RLSeed(review,replay,committer,seconds,zone,limits,binding,generation,eq,eqCtx,&next->state.replay);
    if(!result)result=RVVerify(&r,&next->state.replay,&limits->state,&limits->replay,eq,eqCtx,fn,ctx,&verified);
    if(!result)result=RLPreview(&r,&next->state.replay,&verified,fn,ctx,&drafts,next->tree,next->state.workspace,&preview);
    if(!result)result=RLAffected(&paths,&verified.original,&verified.conflict,&next->state.replay.choices,&preview,&limits->state.records);
    if(!result){next->state.affected=paths.paths;next->state.affectedCount=paths.count;memset(&paths,0,sizeof(paths));}
    if(!result)result=WXKeysMake((const char *const *)next->state.affected,next->state.affectedCount,&keys);
    for(i=0;!result && i<verified.original.count;++i)result=WXPathAdd(&protectionPaths,&limits->state.records,verified.original.files[i].path);
    for(i=0;!result && i<next->state.affectedCount;++i)result=WXPathAdd(&protectionPaths,&limits->state.records,next->state.affected[i]);
    protection.paths=(const char *const *)protectionPaths.paths;protection.count=protectionPaths.count;protection.changed=1;
    if(!result)result=GQToCommitProtected(&r,review->branch,verified.original.commit,next->state.workspace,work,count,&protection,eq,eqCtx,&next->checkout,why);
    if(!result)result=GIParse(review->guards[2].bytes,review->guards[2].length,&original);
    if(!result)result=WXCompose(&verified.original.index,&original,&drafts.preview.index,&keys,&expected);
    if(!result && !WXIndexSame(&expected,&next->checkout.index))result=GS_CONFLICT;
    if(!result)result=WXCompose(&verified.original.index,&original,&drafts.index.index,&keys,&actual);
    if(!result)result=GIEncode(&actual,&bytes,&n);if(!result)result=WXBytesSet(&next->state.index,bytes,n,1);free(bytes);bytes=NULL;
    index=WXMeta(&next->checkout.transaction,"index");map=WXMeta(&next->checkout.transaction,"ghclient-map");
    if(!result && (!index || !map))result=GS_FORMAT;
    if(!result)result=WXBytesSet(&next->state.workIndex,index->after,index->afterLength,index->afterPresent);
    if(!result)result=WXBytesSet(&next->state.mapping,map->after,map->afterLength,map->afterPresent);
    if(!result)result=RKEncode(&next->state,&limits->state,eq,eqCtx,&wire,&wn);if(!result)result=RKParse(wire,wn,&limits->state,eq,eqCtx,&parsed);
    if(!result){RKFree(&next->state);next->state=parsed;RKInit(&parsed);}
    for(i=0;!result && i<5;++i) {
        const MMGuard *g=review->guards+i;m=WXMeta(&next->checkout.transaction,g->key);
        if((!m && i!=4) || (m && (m->beforePresent!=g->present || m->beforeLength!=g->length || (g->present && g->length && memcmp(m->before,g->bytes,g->length))))) {result=GS_CONFLICT;break;}
        if(i==2)result=WXMetaSet(&next->checkout.transaction,g->key,g->bytes,g->length,g->present,next->state.index.bytes,next->state.index.length,1);
        else if(i==3)result=WXMetaSet(&next->checkout.transaction,g->key,g->bytes,g->length,g->present,next->state.mapping.bytes,next->state.mapping.length,1);
        else result=WXMetaSet(&next->checkout.transaction,g->key,g->bytes,g->length,g->present,g->bytes,g->length,g->present);
    }
    if(!result)result=WXMetaSet(&next->checkout.transaction,"ghclient-rebase",NULL,0,0,wire,wn,1);
    next->checkout.transaction.generation=generation;next->unresolved=drafts.index.unresolved;
    if(!result)result=GCEncode(&next->checkout.transaction,eq,eqCtx,&bytes,&n);if(!result && n>limits->journalBytes)result=GB_SPACE;
    if(!result)result=RQRecheck(&r,review);if(!result){GBWord observed;result=GTNextGeneration(&r,&observed);if(!result && observed!=generation)result=GS_CONFLICT;}
    if(!result)result=RLTick(&io);if(!result){RLFree(out);*out=*next;RLInit(next);}
    free(bytes);free(wire);RKFree(&parsed);GIFree(&original);GIFree(&expected);GIFree(&actual);WXKeysFree(&paths);WXKeysFree(&keys);WXKeysFree(&protectionPaths);GRFree(&preview);MSWorkspaceFree(&drafts);RVFree(&verified);RLFree(next);free(next);return result;
}
int RLStart(GSRepository *r,GCBackend *b,GTControl *c,const unsigned char binding[32],GPEqual eq,void *ctx,const RLPlan *p) {
    const GCMetadata *m;if(!p || !binding || memcmp(binding,p->state.replay.binding,32) || !p->state.original || p->state.replay.generation!=p->checkout.transaction.generation || p->state.replay.revision!=p->state.replay.generation)return GS_CONFLICT;
    m=WXMeta(&p->checkout.transaction,"ghclient-rebase");if(!m || m->beforePresent || !m->afterPresent || m->afterLength!=p->state.originalLength || memcmp(m->after,p->state.original,m->afterLength))return GS_CONFLICT;
    return GTStartAtGeneration(r,b,c,binding,eq,ctx,p->state.replay.generation,&p->checkout.transaction);
}

#include "GitRebaseTransitions.c"

#include "GitRebaseUpdate.c"

#include "GitRebaseContinue.c"
