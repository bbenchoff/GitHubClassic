/* Included after GitRebaseMac.c; shares the private native checkout backend. */
#include "GitRebaseWorkspaceMac.h"
typedef struct {GXCheckout *checkout;const RLLimits *limits;} GXRLReader;
static int GXRLRead(void *context,const char *key,unsigned char **bytes,size_t *n) {
    GXRLReader *io=(GXRLReader *)context;size_t maximum;
    maximum=!strncmp(key,"objects/",8)?io->limits->replay.all.encodedBytes:
        !strcmp(key,"checkout-journal") || !strcmp(key,"checkout-intent")?io->limits->journalBytes:io->limits->state.records.bytes;
    return GSMacReadLimit(&io->checkout->store,key,bytes,n,maximum);
}
static int GXRLReplace(void *context,const char *key,const void *before,size_t bn,const void *after,size_t an) {
    GXCheckout *x=((GXRLReader *)context)->checkout;
    return x->raw.replace(x->raw.context,key,before,bn,after,an);
}
static void GXRLRepository(GXCheckout *x,const RLLimits *limits,GXRLReader *io,GSRepository *r) {
    io->checkout=x;io->limits=limits;r->context=io;r->read=GXRLRead;r->replace=GXRLReplace;
}
/* Explicit conflict-only entry. Existing clean replay/refusal API stays intact
   until the UI has an installed-session resolver and Abort path. */
int GXRebaseBegin(GXCheckout *x,const GXRebaseReview *review,const char *committer,const char *seconds,
    const char *zone,const RLLimits *limits,GQError *why,int *started) {
    RQCheckout *replayed;RLPlan *candidate;GFInventory inventory;GPMap map;GXState *s;
    GSRepository reader,r;GXRLReader io;GCBackend backend;GTControl control;unsigned char binding[32];int result,closed;
    if(!started)return GB_BAD;*started=0;
    if(!x || !x->state || !review || !limits || x->store.leaseHeld || x->held.haveData || x->held.haveResource)return GB_BAD;
    replayed=(RQCheckout *)calloc(1,sizeof(*replayed));candidate=(RLPlan *)calloc(1,sizeof(*candidate));
    if(!replayed || !candidate){free(replayed);free(candidate);return GB_MEMORY;}
    if(why)memset(why,0,sizeof(*why));s=x->state;GXClearPlan(s);GFInit(&inventory);GPInit(&map);GXRLRepository(x,limits,&io,&reader);
    result=GSMacEnter(&x->store,0);if(!result)result=GXCheckCondition(x);
    if(!result)result=GXBinding(x,NULL,binding);
    if(!result && memcmp(binding,review->repositoryBinding,32))result=GS_CONFLICT;
    if(!result)result=RQRecheck(&reader,&review->review);
    if(!result)result=GXStorage(x,1);
    if(!result)result=GPLoad(&reader,GWMacNameEqual,NULL,&map);
    if(!result)result=GFCollect(&x->root,&map,&inventory,&x->lastError);
    if(!result)result=RQBuildCheckout(&reader,&review->review,inventory.items,inventory.count,GWMacNameEqual,NULL,
        committer,seconds,zone,GXRebaseProgress,x,replayed,why);
    if(!result && replayed->kind!=RQ_CONFLICT)result=GS_CONFLICT;
    if(!result)result=RLBegin(&reader,&review->review,&replayed->replay,committer,seconds,zone,limits,s->binding,
        inventory.items,inventory.count,GWMacNameEqual,NULL,GXRebaseProgress,x,candidate,why);
    if(!result)result=GXBinding(x,NULL,binding);
    if(!result && memcmp(binding,review->repositoryBinding,32))result=GS_CONFLICT;
    if(!result)result=GXCheckCondition(x);
    if(!result) {
        x->store.recoveryOwner=1;s->handedLease=1;s->starting=1;s->candidate=&candidate->checkout;s->inventory=&inventory;
        GXCallbacks(x,&r,&backend,&control);result=RLStart(&r,&backend,&control,s->binding,GWMacNameEqual,NULL,candidate);
        if(!result)*started=1;
    }
    s->candidate=NULL;s->inventory=NULL;s->starting=0;s->handedLease=0;
    if(x->store.leaseHeld && !x->held.haveData && !x->held.haveResource){closed=GSMacLeave(&x->store);if(!result)result=closed;}
    GPFree(&map);GFFree(&inventory);RQCheckoutFree(replayed);RLFree(candidate);free(replayed);free(candidate);return result;
}
int GXRebaseOpen(GXCheckout *x,const RLLimits *limits,RLSession *out) {
    RLSession *next;GSRepository reader;GXRLReader io;int result,closed;
    if(!x || !x->state || !limits || !out || x->store.leaseHeld || x->held.haveData || x->held.haveResource)return GB_BAD;
    next=(RLSession *)calloc(1,sizeof(*next));if(!next)return GB_MEMORY;GXClearPlan(x->state);GXRLRepository(x,limits,&io,&reader);
    result=GSMacEnter(&x->store,1);if(!result)result=GXStorage(x,0);
    if(!result)result=RLOpen(&reader,limits,x->state->binding,GWMacNameEqual,NULL,GXRebaseProgress,x,next);
    if(x->store.leaseHeld && !x->held.haveData && !x->held.haveResource){closed=GSMacLeave(&x->store);if(!result)result=closed;}
    if(!result){RLSessionFree(out);*out=*next;RLSessionInit(next);}RLSessionFree(next);free(next);return result;
}
int GXRebaseAbort(GXCheckout *x,const void *expected,size_t length,const RLLimits *limits,GQError *why,int *finished) {
    RLSession *opened;RLPlan *candidate;GFInventory inventory;GXState *s;GSRepository reader,r;GXRLReader io;
    GCBackend backend;GTControl control;char hex[41],token[32];int result,closed;
    if(!finished)return GB_BAD;*finished=0;
    if(!x || !x->state || !expected || !length || !limits || x->store.leaseHeld || x->held.haveData || x->held.haveResource)return GB_BAD;
    if(why)memset(why,0,sizeof(*why));opened=(RLSession *)calloc(1,sizeof(*opened));candidate=(RLPlan *)calloc(1,sizeof(*candidate));
    if(!opened || !candidate){free(opened);free(candidate);return GB_MEMORY;}
    s=x->state;GXClearPlan(s);GFInit(&inventory);GXRLRepository(x,limits,&io,&reader);result=GSMacEnter(&x->store,1);
    if(!result)result=GXStorage(x,0);
    if(!result)result=RLOpen(&reader,limits,s->binding,GWMacNameEqual,NULL,GXRebaseProgress,x,opened);
    if(!result && (length!=opened->state.originalLength || memcmp(expected,opened->state.original,length)))result=GS_CONFLICT;
    if(!result)result=GFCollect(&x->root,&opened->mapping,&inventory,&x->lastError);
    if(!result){GBOIDFormat(opened->state.replay.planID,hex);sprintf(token,"%08lx-%.20s",(unsigned long)opened->state.replay.revision,hex);result=GSMacOwnerToken(&x->store,token);}
    RLSessionFree(opened);
    if(!result)result=RLAbort(&reader,expected,length,limits,s->binding,inventory.items,inventory.count,GWMacNameEqual,NULL,GXRebaseProgress,x,candidate,why);
    if(!result){s->handedLease=1;s->starting=1;s->candidate=&candidate->checkout;s->inventory=&inventory;GXCallbacks(x,&r,&backend,&control);
        result=RLAbortStart(&r,&backend,&control,s->binding,GWMacNameEqual,NULL,candidate);if(!result)*finished=1;}
    s->candidate=NULL;s->inventory=NULL;s->starting=0;s->handedLease=0;
    if(x->store.leaseHeld && !x->held.haveData && !x->held.haveResource){closed=GSMacLeave(&x->store);if(!result)result=closed;}
    GFFree(&inventory);RLSessionFree(opened);RLFree(candidate);free(opened);free(candidate);return result;
}
int GXRebaseResolve(GXCheckout *x,const void *expected,size_t length,const TMResolution *values,size_t count,
    const RLLimits *limits,GQError *why,int *installed) {
    RLSession *opened;RLPlan *candidate;MSChoices choices;GFInventory inventory;GXState *s;GSRepository reader,r;GXRLReader io;
    GCBackend backend;GTControl control;char hex[41],token[32];unsigned char proof[20];int result,closed;
    if(!installed)return GB_BAD;*installed=0;
    if(!x || !x->state || !expected || !length || (count && !values) || !limits || x->store.leaseHeld || x->held.haveData || x->held.haveResource)return GB_BAD;
    if(why)memset(why,0,sizeof(*why));opened=(RLSession *)calloc(1,sizeof(*opened));candidate=(RLPlan *)calloc(1,sizeof(*candidate));
    if(!opened || !candidate){free(opened);free(candidate);return GB_MEMORY;}
    s=x->state;GXClearPlan(s);MSChoicesInit(&choices);GFInit(&inventory);GXRLRepository(x,limits,&io,&reader);result=GSMacEnter(&x->store,1);
    if(!result)result=GXStorage(x,0);
    if(!result)result=RLOpen(&reader,limits,s->binding,GWMacNameEqual,NULL,GXRebaseProgress,x,opened);
    if(!result && (length!=opened->state.originalLength || memcmp(expected,opened->state.original,length)))result=GS_CONFLICT;
    if(!result){GBOIDFormat(opened->state.replay.planID,hex);sprintf(token,"%08lx-%.20s",(unsigned long)opened->state.replay.revision,hex);result=GSMacOwnerToken(&x->store,token);}
    if(!result)result=RYMakeProof(&reader,&opened->replay.conflict,opened->state.replay.branch,opened->state.replay.ontoRef,
        values,count,&limits->state,GXRebaseProgress,x,&choices,proof);
    if(!result)result=GFCollect(&x->root,&opened->mapping,&inventory,&x->lastError);RLSessionFree(opened);
    if(!result)result=RLUpdate(&reader,expected,length,limits,s->binding,&choices,inventory.items,inventory.count,GWMacNameEqual,NULL,GXRebaseProgress,x,candidate,why);
    if(!result){s->handedLease=1;s->starting=1;s->candidate=&candidate->checkout;s->inventory=&inventory;GXCallbacks(x,&r,&backend,&control);
        result=RLUpdateStart(&r,&backend,&control,s->binding,GWMacNameEqual,NULL,candidate);if(!result)*installed=1;}
    s->candidate=NULL;s->inventory=NULL;s->starting=0;s->handedLease=0;
    if(x->store.leaseHeld && !x->held.haveData && !x->held.haveResource){closed=GSMacLeave(&x->store);if(!result)result=closed;}
    GFFree(&inventory);MSChoicesFree(&choices);RLSessionFree(opened);RLFree(candidate);free(opened);free(candidate);return result;
}
int GXRebaseContinue(GXCheckout *x,const void *expected,size_t length,const RLLimits *limits,GQError *why,GXRebaseOutcome *out) {
    RLSession *opened;RLCPlan *candidate;GFInventory inventory;GXState *s;GSRepository reader,r;GXRLReader io;GXRebaseOutcome next;
    GCBackend backend;GTControl control;char hex[41],token[32];int result,closed;
    if(!x || !x->state || !expected || !length || !limits || !out || x->store.leaseHeld || x->held.haveData || x->held.haveResource)return GB_BAD;
    if(why)memset(why,0,sizeof(*why));opened=(RLSession *)calloc(1,sizeof(*opened));candidate=(RLCPlan *)calloc(1,sizeof(*candidate));
    if(!opened || !candidate){free(opened);free(candidate);return GB_MEMORY;}
    s=x->state;GXClearPlan(s);GFInit(&inventory);memset(&next,0,sizeof(next));GXRLRepository(x,limits,&io,&reader);result=GSMacEnter(&x->store,1);
    if(!result)result=GXStorage(x,0);
    if(!result)result=RLOpen(&reader,limits,s->binding,GWMacNameEqual,NULL,GXRebaseProgress,x,opened);
    if(!result && (length!=opened->state.originalLength || memcmp(expected,opened->state.original,length)))result=GS_CONFLICT;
    if(!result)result=GFCollect(&x->root,&opened->mapping,&inventory,&x->lastError);
    if(!result){GBOIDFormat(opened->state.replay.planID,hex);sprintf(token,"%08lx-%.20s",(unsigned long)opened->state.replay.revision,hex);result=GSMacOwnerToken(&x->store,token);}
    RLSessionFree(opened);
    if(!result)result=RLContinue(&reader,expected,length,limits,s->binding,inventory.items,inventory.count,GWMacNameEqual,NULL,GXRebaseProgress,x,candidate,why);
    if(!result){s->handedLease=1;s->starting=1;s->candidate=&candidate->plan.checkout;s->inventory=&inventory;GXCallbacks(x,&r,&backend,&control);
        result=RLContinueStart(&r,&backend,&control,s->binding,GWMacNameEqual,NULL,candidate);}
    if(!result){next.kind=candidate->finished?RQ_READY:RQ_CONFLICT;next.advanced=candidate->finished;next.completed=candidate->completed;
        memcpy(next.tip,candidate->tip,20);next.droppedSignatures=candidate->droppedSignatures;
        if(!candidate->finished){next.conflicts=candidate->plan.unresolved;memcpy(next.conflict,candidate->plan.state.replay.commits[candidate->completed],20);}}
    s->candidate=NULL;s->inventory=NULL;s->starting=0;s->handedLease=0;
    if(x->store.leaseHeld && !x->held.haveData && !x->held.haveResource){closed=GSMacLeave(&x->store);if(!result)result=closed;}
    if(!result)*out=next;GFFree(&inventory);RLSessionFree(opened);RLCFree(candidate);free(opened);free(candidate);return result;
}
