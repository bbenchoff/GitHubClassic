/* Included after the transport and advanced token dialog in Main.c. */
static UserItemUPP gAuthArtProc;
static char gDeviceCode[33];
static pascal void AuthArtDraw(DialogPtr dialog,short number) {
    GrafPtr saved;PenState pen;RGBColor foreground;short font,size,kind,x,y,w,gap=6,total=0;Style face;
    Handle item;Rect r,logo,card;FontInfo metrics;size_t i,n;char character[2];
    GetPort(&saved);SetPort((GrafPtr)dialog);font=((GrafPtr)dialog)->txFont;size=((GrafPtr)dialog)->txSize;face=((GrafPtr)dialog)->txFace;
    GetForeColor(&foreground);GetPenState(&pen);PenNormal();GetDialogItem(dialog,number,&kind,&item,&r);
    Box(r.left,r.top,r.right,r.bottom,255,255,255);
    if(number==3) {
        n=strlen(gDeviceCode);w=n>12?(short)((r.right-r.left-12)/n-gap):36;if(w<6)w=6;
        for(i=0;i<n;++i)total+=(gDeviceCode[i]=='-'?w/2:w)+gap;
        x=(short)(r.left+(r.right-r.left-total+gap)/2);y=(short)(r.top+2);character[1]=0;
        for(i=0;i<n;++i) {
            short width=gDeviceCode[i]=='-'?w/2:w;
            if(gDeviceCode[i]!='-') {
                Box((short)(x+2),(short)(y+2),(short)(x+width+2),(short)(r.bottom-1),218,226,236);
                SetRect(&card,x,y,(short)(x+width),(short)(r.bottom-3));Color(39,104,208);FrameRect(&card);
                InsetRect(&card,1,1);Color(255,255,255);PaintRect(&card);
            }
            character[0]=gDeviceCode[i];TextFont(gMonaco);TextSize(w>=28?24:w>=18?18:12);TextFace(bold);
            GetFontInfo(&metrics);Color(39,104,208);
            MoveTo((short)(x+(width-TextWidth(character,0,1))/2),(short)(y+(r.bottom-y-3-metrics.ascent-metrics.descent)/2+metrics.ascent));
            DrawText(character,0,1);
            x=(short)(x+width+gap);
        }
    } else {
        SetRect(&logo,r.left,(short)(r.top+2),(short)(r.left+44),(short)(r.top+46));
        if(gMonochrome)MonoIcon(128,&logo);else if(gWelcomeIcon)PlotCIcon(&logo,gWelcomeIcon);
        Text((short)(r.left+60),(short)(r.top+22),"Sign in to GitHub",gGeneva,18,39,104,208);
        Text((short)(r.left+60),(short)(r.top+42),"GitHub on your Macintosh.",gGeneva,12,64,64,64);
    }
    RGBForeColor(&foreground);SetPenState(&pen);TextFont(font);TextSize(size);TextFace(face);SetPort(saved);
}
static void ClearSession(void) {
    RCClear(&gRemoteCache);
    VaultForgetRemembered();
    if (gLocal) ClearRemoteAccount();
    else ClearRemote();
    OAClear(&gCredentials, sizeof(gCredentials));
    if (!gLocal) ShowControl(gSignIn);
    else HideControl(gSignIn);
    HideControl(gBrowse);
    strcpy(gDetail, "Connect your GitHub account to browse your repositories.");
}
static void AuthRelease(unsigned char **body, size_t *n) {
    if (*body) {
        OAClear(*body, *n);
        free(*body);
        *body = NULL;
    }
    *n = 0;
}
/* A request can observe Cancel inside the TLS pump, including after its last
   receive. Never parse/install that response or replace the existing account. */
static int AuthFlowRequest(OAFlow *flow,const char *host,const char *path,const char *token,const char *form,
                           unsigned char **body,size_t *n) {
    int result=RawRequest(host,path,token,form,body,n);
    if(result==SSL_CANCELLED || gCancel || gDone) {
        OACancel(flow);AuthRelease(body,n);
        SetStatus("GitHub sign-in cancelled.");return SSL_CANCELLED;
    }
    return result;
}
static void AuthInstall(const OACredentials *c) {
    RCClear(&gRemoteCache);
    VaultResetMemory();
    if (gLocal) ClearRemoteAccount();
    else ClearRemote();
    OAClear(&gCredentials, sizeof(gCredentials));
    gCredentials = *c;
    HideControl(gSignIn);
    if (gLocal) HideControl(gBrowse);
    else ShowControl(gBrowse);
    snprintf(gDetail, sizeof(gDetail), "Signed in as %s.", gUser);
    SetStatus("GitHub account verified. Authorization held only in memory.");
}
static int RefreshCredentials(void) {
    OACredentials *next;
    char *form;
    unsigned char *body = NULL;
    size_t n = 0;
    int error = OA_BAD_RESPONSE;
    char expected[32];
    strcpy(expected, gCredentials.accountID);
    next = (OACredentials *)calloc(1, sizeof(*next));
    form = (char *)calloc(1, 32768);
    if (!next || !form)
        goto done;
    if (OARefreshForm(&gCredentials, gCredentials.clientID, AuthNow(), form, 32768))
        goto done;
    if (RawRequest("github.com", "/login/oauth/access_token", NULL, form, &body, &n))
        goto done;
    OAClear(form, 32768);
    if (OARefreshReply(&gCredentials, (char *)body, n, AuthNow(), next))
        goto done;
    AuthRelease(&body, &n);
    /* The server rotated the pair. Bind the replacement to the same numeric ID
       before making it available to any repository operation. */
    if (RawRequest("api.github.com", "/user", next->access, NULL, &body, &n) ||
        OAAccount(next, (char *)body, n, expected))
        goto done;
    OAClear(&gCredentials, sizeof(gCredentials));
    gCredentials = *next;
    VaultAfterRotation();
    error = 0;
done:
    AuthRelease(&body, &n);
    if (next) {
        OAClear(next, sizeof(*next));
        free(next);
    }
    if (form) {
        OAClear(form, 32768);
        free(form);
    }
    if (error) {
        ClearSession();
        SetStatus("Authorization refresh did not complete. Sign in again.");
    }
    return error;
}
static void AuthDialogText(DialogPtr d, short number, const char *text) {
    short kind;
    Handle item;
    Rect rect;
    Str255 p;
    GetDialogItem(d, number, &kind, &item, &rect);
    Pascal(text, p);
    SetDialogItemText(item, p);
}
/* Bounded nonsecret diagnostic, replaced at each transition. Never write an
   OAuth response, device/user code, access token, refresh token or passphrase. */
typedef struct {
    unsigned long replyTick,lastWaitTicks,minimumWaitTicks,maximumWaitTicks,requiredTicks,earlyPolls;
} AuthPollTiming;
static unsigned long AuthRequiredPollTicks(const OAFlow *flow) {
    /* Classic ticks are nominally60.15Hz.61 ticks/second plus one sampling
       tick conservatively covers that rate and the fractional reply tick. */
    return flow->interval*61UL+1;
}
/* Whole-second protocol clocks alone can make a five-second interval shorter
   than five real seconds. Gate from the completed reply using unrounded ticks.
   Expiry still reaches OAPollForm immediately, even while the tick gate waits. */
static int AuthTimedPollForm(OAFlow *flow,unsigned long now,unsigned long ticks,
                             unsigned long replyTick,char *out,size_t capacity) {
    if(out && capacity && flow->state==OA_WAITING &&
        ((now-flow->started)&0xffffffffUL)<flow->lifetime &&
        ((ticks-replyTick)&0xffffffffUL)<AuthRequiredPollTicks(flow)) {
        out[0]=0;return OA_NOT_DUE;
    }
    return OAPollForm(flow,now,out,capacity);
}
static void AuthPollProbe(const OAFlow *flow,const AuthPollTiming *timing,const char *phase,unsigned long polls,int request,int protocol) {
    FILE *file=fopen("Auth Probe.txt","wb");unsigned long now=AuthNow();
    if(!file)return;
    fprintf(file,"version=2\rphase=%s\rpolls=%lu\rclock_s=%lu\rstate=%d\rinterval_s=%lu\relapsed_s=%lu\rrequest_result=%d\rprotocol_result=%d\r",
            phase,polls,now,flow->state,flow->interval,(now-flow->started)&0xffffffffUL,request,protocol);
    fprintf(file,"clock_ticks=%lu\rreply_tick=%lu\rlast_wait_ticks=%lu\rminimum_wait_ticks=%lu\rmaximum_wait_ticks=%lu\rrequired_ticks=%lu\rearly_polls=%lu\r",
            TickCount(),timing->replyTick,timing->lastWaitTicks,timing->minimumWaitTicks,timing->maximumWaitTicks,timing->requiredTicks,timing->earlyPolls);
    fclose(file);
}
static void SignIn(void) {
    DialogPtr setup;
    short hit = 0, kind;
    Handle item;
    Rect rect;
    int privateAccess = 0, saveCredentials=1, error = OA_BAD_RESPONSE, result=0;
    OAFlow flow;
    AuthPollTiming timing;
    OACredentials *pending = NULL;
    char *form = NULL;
    unsigned char *body = NULL;
    size_t n = 0;unsigned long polls=0,pollTick,now;char pollStatus[200];
    setup = GetNewDialog(134, NULL, (WindowPtr)-1);
    if (!setup)
        return;
    if(!gAuthArtProc)gAuthArtProc=NewUserItemProc(AuthArtDraw);
    if(!gAuthArtProc){DisposeDialog(setup);SetStatus("Not enough memory to open sign-in.");return;}
    GetDialogItem(setup,5,&kind,&item,&rect);SetDialogItem(setup,5,kind,(Handle)gAuthArtProc,&rect);
    GetDialogItem(setup,8,&kind,&item,&rect);SetControlValue((ControlHandle)item,saveCredentials);
    PrepareDialog(setup,1,2);
    do {
        RunModalDialog(gDialogFilter, &hit);
        if (hit == 6) {
            GetDialogItem(setup, 6, &kind, &item, &rect);
            privateAccess = !privateAccess;
            SetControlValue((ControlHandle)item, privateAccess);
        }
        if(hit==8){GetDialogItem(setup,8,&kind,&item,&rect);saveCredentials=!saveCredentials;SetControlValue((ControlHandle)item,saveCredentials);}
    } while (hit != 1 && hit != 2 && hit != 3 && hit!=9);
    DisposeDialog(setup);
    if (hit == 2)
        return;
    if (hit == 3) {
        if(TokenSignIn() && saveCredentials)VaultSaveCredentials();
        return;
    }
    if(hit==9){VaultUnlockCredentials();return;}
    if (!OAClientValid(gOAuthClient)) {
        SetStatus(
            "Classic Github needs its registered public OAuth Client ID. No client secret is used.");
        return;
    }
    OAInit(&flow);
    memset(&timing,0,sizeof(timing));
    pending = (OACredentials *)calloc(1, sizeof(*pending));
    form = (char *)calloc(1, 32768);
    if (!pending || !form) {
        SetStatus("Not enough memory to begin sign-in.");
        goto done;
    }
    if (OAStartForm(&flow, gOAuthClient, privateAccess, form, 32768))
        goto done;
    result=AuthFlowRequest(&flow,"github.com", "/login/device/code", NULL, form, &body, &n);
    if (result)
        goto done;
    OAClear(form, 32768);
    if (OADeviceReply(&flow, (char *)body, n, AuthNow())) {
        SetStatus("GitHub did not issue a device code. Check the app registration and device-flow "
                  "setting.");
        goto done;
    }
    timing.replyTick=TickCount();
    AuthPollProbe(&flow,&timing,"code-issued",polls,0,0);
    AuthRelease(&body, &n);
    gDeviceDialog = GetNewDialog(135, NULL, (WindowPtr)-1);
    if (!gDeviceDialog)
        goto done;
    strcpy(gDeviceCode,flow.userCode);
    GetDialogItem(gDeviceDialog,3,&kind,&item,&rect);SetDialogItem(gDeviceDialog,3,kind,(Handle)gAuthArtProc,&rect);
    GetDialogItem(gDeviceDialog,5,&kind,&item,&rect);SetDialogItem(gDeviceDialog,5,kind,(Handle)gAuthArtProc,&rect);
    FitDialogToScreen(gDeviceDialog);
    ShowWindow((WindowPtr)gDeviceDialog);
    gBusy = 1;
    gCancel = 0;
    while (flow.state == OA_WAITING) {
        if (Pump(NULL)) {
            OACancel(&flow);
            SetStatus("GitHub sign-in cancelled.");
            break;
        }
        pollTick=TickCount();now=AuthNow();
        result = AuthTimedPollForm(&flow,now,pollTick,timing.replyTick,form,32768);
        if (result == OA_NOT_DUE)
            continue;
        if (result) {
            AuthPollProbe(&flow,&timing,"poll-form-failed",polls,0,result);
            SetStatus("The GitHub sign-in code expired. Start sign-in again.");
            break;
        }
        timing.lastWaitTicks=(pollTick-timing.replyTick)&0xffffffffUL;
        timing.requiredTicks=AuthRequiredPollTicks(&flow);
        if(timing.lastWaitTicks<timing.requiredTicks)++timing.earlyPolls;
        if(!polls || timing.lastWaitTicks<timing.minimumWaitTicks)timing.minimumWaitTicks=timing.lastWaitTicks;
        if(timing.lastWaitTicks>timing.maximumWaitTicks)timing.maximumWaitTicks=timing.lastWaitTicks;
        ++polls;AuthPollProbe(&flow,&timing,"request-started",polls,0,0);
        result=AuthFlowRequest(&flow,"github.com", "/login/oauth/access_token", NULL, form, &body, &n);
        timing.replyTick=TickCount();
        if (result) {
            AuthPollProbe(&flow,&timing,"request-failed",polls,result,0);
            break;
        }
        OAClear(form, 32768);
        gBusy = 1;
        result = OATokenReply(&flow, (char *)body, n, AuthNow(), pending);
        AuthPollProbe(&flow,&timing,"reply-processed",polls,0,result);
        AuthRelease(&body, &n);
        if (result == OA_PENDING) {
            snprintf(pollStatus,sizeof(pollStatus),"Waiting for approval. GitHub checked %lu time%s.\rNext check in %lu seconds.",polls,polls==1?"":"s",flow.interval);
            AuthDialogText(gDeviceDialog, 4, pollStatus);
            continue;
        }
        if (result) {
            SetStatus(flow.state == OA_DENIED    ? "GitHub authorization was declined."
                      : flow.state == OA_EXPIRED ? "The GitHub sign-in code expired."
                      : result == OA_PERMISSION
                          ? "GitHub did not grant the required repository permission."
                          : "GitHub authorization could not be completed.");
            break;
        }
    }
    if (flow.state != OA_VERIFY)
        goto done;
    AuthDialogText(gDeviceDialog, 4, "Checking the GitHub account...");
    result=AuthFlowRequest(&flow,"api.github.com", "/user", pending->access, NULL, &body, &n);
    if (result)
        goto done;
    if (OAAccount(pending, (char *)body, n, NULL)) {
        SetStatus("GitHub did not return a valid authenticated account.");
        goto done;
    }
    AuthInstall(pending);
    flow.state = OA_COMPLETE;
    AuthPollProbe(&flow,&timing,"account-verified",polls,0,0);
    error = 0;
done:
    if(flow.state==OA_CANCELLED)AuthPollProbe(&flow,&timing,"cancelled",polls,result==SSL_CANCELLED?result:0,0);
    if (gDeviceDialog) {
        DisposeDialog(gDeviceDialog);
        gDeviceDialog = NULL;
    }
    OAClear(gDeviceCode,sizeof(gDeviceCode));
    AuthRelease(&body, &n);
    OAClear(&flow, sizeof(flow));
    if (pending) {
        OAClear(pending, sizeof(*pending));
        free(pending);
    }
    if (form) {
        OAClear(form, 32768);
        free(form);
    }
    gBusy = 0;
    gCancel = 0;
    if (!error && gLocal)
        SetStatus("GitHub account verified. Local working files preserved.");
    if(!error && saveCredentials)VaultSaveCredentials();
    SetPort(gWindow);
    InvalRect(&gWindow->portRect);
}
