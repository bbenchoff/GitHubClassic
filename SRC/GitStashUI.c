/* Standard Git stash list and separate local working/staging conflict drafts.
   Include after GitWorkspaceUI/GitMergeUI. No lease crosses a modal dialog. */
static GXStashList *gSHList;
static MUIDraft *gSHConflict;
static int StashAvailable(void){return DiscardAvailable() && gWork.haveHead;}
static const SLEntry *SHEntry(const GXStashList *list,size_t at){
    return at<list->state.log.count?list->state.log.entries+list->state.log.count-1-at:NULL;
}
static char *SHMessage(const GXStashList *list,size_t at){
    const SLEntry *e=SHEntry(list,at);char *text;
    if(!e || e->messageOffset>list->state.log.length || e->messageLength>list->state.log.length-e->messageOffset)return NULL;
    text=malloc(e->messageLength+1);if(text){memcpy(text,list->state.log.bytes+e->messageOffset,e->messageLength);text[e->messageLength]=0;}return text;
}
static int SHRow(void *context,size_t at,char label[256],char name[256],char info[256]){
    const GXStashList *list=context;const SLEntry *e=SHEntry(list,at);char *message,*marker,display[256];const char *tail;size_t branchLength;
    if(!e)return 0;message=SHMessage(list,at);if(!message)return 0;
    if(!strncmp(message,"On ",3) && (marker=strstr(message,": !!GitHub_Desktop<"))!=NULL){
        branchLength=(size_t)(marker-message-3);tail=marker+strlen(": !!GitHub_Desktop<");
        if(branchLength && strlen(tail)==branchLength+1 && tail[branchLength]=='>' && !memcmp(tail,message+3,branchLength))*marker=0;
    }
    LocalDisplayPath(message,display);free(message);snprintf(name,256,"stash@{%lu}",(unsigned long)at);
    snprintf(label,256,"%s  %.210s",name,display);strcpy(info,"Apply keeps this entry. Pop restores and removes it.");return 1;
}
static char *SHDetails(void *context,size_t at){
    const GXStashList *list=context;const SLEntry *e=SHEntry(list,at);char id[41],*message,*identity,*text=NULL;size_t n;
    if(!e)return NULL;message=SHMessage(list,at);if(!message)return NULL;
    identity=ChoiceIdentityDetails("Original message",message);free(message);if(!identity)return NULL;
    GBOIDFormat(e->after,id);n=strlen(identity)+900;text=malloc(n);
    if(text)snprintf(text,n,"stash@{%lu}\rCommit: %s\r\r%s\r\rApply restores staged and working changes on the current branch and keeps this stash. Pop removes this entry in the same recoverable operation. Conflicts require separate working and staging choices.\r\rDrop removes this stash entry only. Native Saved Changes recovery copies and immutable archives are retained. Details does not verify the full object graph; each operation checks it before approval.",(unsigned long)at,id,identity);
    free(identity);return text;
}
static void SHSync(DialogPtr d){
    int selected=gSHList && gChoiceValid && gChoiceSelected<gSHList->state.log.count;
    gChoiceActionEnabled=selected && gWork.haveHead;ChoiceEnable(d,1,gChoiceActionEnabled);
    ChoiceEnable(d,3,gChoiceActionEnabled);ChoiceEnable(d,4,selected);ChoiceEnable(d,14,StashAvailable());
}
static pascal Boolean SHFilter(DialogPtr d,EventRecord *event,short *hit){
    Boolean handled;Point point;Rect bounds;short kind;Handle item;Cell cell;int doubled;*hit=0;
    if((event->what==keyDown || event->what==autoKey) && !(event->modifiers&cmdKey) &&
        ((event->message&charCodeMask)==13 || (event->message&charCodeMask)==3)){*hit=2;return true;}
    if(event->what==mouseDown){
        SetPort((GrafPtr)d);point=event->where;GlobalToLocal(&point);GetDialogItem(d,6,&kind,&item,&bounds);
        if(PtInRect(point,&bounds)){
            TextFont(gGeneva);TextSize(12);TextFace(0);doubled=LClick(point,event->modifiers,gChoiceList);cell.h=cell.v=0;
            if(LGetSelect(true,&cell,gChoiceList))ChoiceSelect(d,gChoiceFirst+cell.v);
            SHSync(d);if(doubled && gChoiceActionEnabled)*hit=1;return true;
        }
    }
    handled=ChoiceFilter(d,event,hit);SHSync(d);return handled;
}
static int SHChoose(GXStashList *list,size_t *selected){
    const ChoiceItems items={1,7,6,8,11,12,5};NativeChoices choices;DialogPtr d;ModalFilterUPP filter;
    short hit=0;int answer=0;char repository[256];memset(&choices,0,sizeof(choices));
    choices.context=list;choices.count=list->state.log.count;choices.row=SHRow;choices.details=SHDetails;choices.noun="Stashes";
    gSHList=list;d=GetNewDialog(156,NULL,(WindowPtr)-1);if(!d){gSHList=NULL;return 0;}filter=NewModalFilterProc(SHFilter);
    if(!filter || !PrepareDialogChrome(d,9,10) || !ChoiceCreate(d,&choices,&items,0))goto done;
    MUIRepositoryLabel(&gWork.folder,repository);DialogText(d,13,repository);PrepareDialog(d,2,2);
    if(choices.count)ChoiceSelect(d,*selected<choices.count?*selected:0);else ChoiceRefresh(d);
    SHSync(d);DrawDialog(d);
    while(!gDone){
        hit=0;RunModalDialog(filter,&hit);if(hit==2 || gDone)break;
        if((hit==1 || hit==3) && gChoiceActionEnabled){*selected=gChoiceSelected;answer=hit;break;}
        if(hit==4 && gChoiceSelected<choices.count){*selected=gChoiceSelected;answer=4;break;}
        if(hit==14 && StashAvailable()){answer=14;break;}
        if(hit==5)ChoiceDetails();
        if(hit==11 && gChoiceFirst)ChoiceSelect(d,gChoiceFirst-CHOICE_PAGE);
        if(hit==12 && gChoiceFirst+gChoiceRows<choices.count)ChoiceSelect(d,gChoiceFirst+CHOICE_PAGE);
        SHSync(d);SetPort((GrafPtr)d);InvalRect(&((WindowPtr)d)->portRect);
    }
    ChoiceDispose();
done:
    if(filter)DisposeRoutineDescriptor((UniversalProcPtr)filter);DisposeDialog(d);gSHList=NULL;SetPort(gWindow);return gDone?0:answer;
}
/* The SAReview owns the entire plan. MUIDraft owns only row choices and these
   copied labels. Detach the borrowed TMPlan BEFORE ordinary MUIFree. */
static void SHDraftFree(MUIDraft *d){TMInit(&d->saved.review.files);MUIFree(d);}
static int SHDraft(MUIDraft *d,const TMPlan *plan,const char *branch,const char *title){
    size_t i,at=0,n;MUIInit(d);d->saved.review.files=*plan;d->previewTitle=title;
    n=strlen(branch)+1;d->saved.state.branch=malloc(n);d->saved.state.otherRef=malloc(11);
    if(!d->saved.state.branch || !d->saved.state.otherRef)return GB_MEMORY;
    memcpy(d->saved.state.branch,branch,n);strcpy(d->saved.state.otherRef,"refs/stash");
    d->count=plan->conflicts;if(!d->count)return 0;d->rows=calloc(d->count,sizeof(*d->rows));if(!d->rows)return GB_MEMORY;
    for(i=0;i<plan->count;++i)if(plan->files[i].conflicts){
        if(at==d->count)return GS_FORMAT;d->rows[at].node=d->rows[at].value.node=i;++at;
    }return at==d->count?0:GS_FORMAT;
}
static int SHConflictRow(void *context,size_t at,char label[256],char name[256],char info[256]){
    const MUIDraft *d=context;int result=MUIConflictRow(context,at,label,name,info);
    if(result)snprintf(info,256,"%s; local draft only.",MUIChoiceStatus(d->rows+at));return result;
}
static char *SHConflictDetails(void *context,size_t at){return MUIResolutionDetails(context,at,0);}
static void SHConflictSync(DialogPtr d){
    int selected=gSHConflict && gChoiceValid && gChoiceSelected<gSHConflict->count;
    gChoiceActionEnabled=selected;ChoiceEnable(d,1,gSHConflict && !MUIUnchosen(gSHConflict));
    ChoiceEnable(d,3,selected);ChoiceEnable(d,4,selected);
}
static pascal Boolean SHConflictFilter(DialogPtr d,EventRecord *event,short *hit){
    Boolean handled;Point point;Rect bounds;short kind;Handle item;Cell cell;int doubled;*hit=0;
    if((event->what==keyDown || event->what==autoKey) && !(event->modifiers&cmdKey) &&
        ((event->message&charCodeMask)==13 || (event->message&charCodeMask)==3)){*hit=2;return true;}
    if(event->what==mouseDown){
        SetPort((GrafPtr)d);point=event->where;GlobalToLocal(&point);GetDialogItem(d,6,&kind,&item,&bounds);
        if(PtInRect(point,&bounds)){
            TextFont(gGeneva);TextSize(12);TextFace(0);doubled=LClick(point,event->modifiers,gChoiceList);cell.h=cell.v=0;
            if(LGetSelect(true,&cell,gChoiceList))ChoiceSelect(d,gChoiceFirst+cell.v);
            SHConflictSync(d);if(doubled && gChoiceActionEnabled)*hit=3;return true;
        }
    }
    handled=ChoiceFilter(d,event,hit);SHConflictSync(d);return handled;
}
static int SHConflicts(const FSSpec *folder,MUIDraft *draft){
    const ChoiceItems items={3,7,6,8,11,12,5};NativeChoices choices;DialogPtr d;ModalFilterUPP filter;Str255 title;short hit=0;int approved=0;
    if(!draft->count)return 1;if(gSHConflict)return 0;
    memset(&choices,0,sizeof(choices));choices.context=draft;choices.count=draft->count;choices.row=SHConflictRow;
    choices.details=SHConflictDetails;choices.noun="Conflicts";gSHConflict=draft;
    d=GetNewDialog(157,NULL,(WindowPtr)-1);if(!d){gSHConflict=NULL;return 0;}filter=NewModalFilterProc(SHConflictFilter);
    Pascal(draft->previewTitle,title);SetWTitle((WindowPtr)d,title);
    if(!filter || !PrepareDialogChrome(d,9,10) || !ChoiceCreate(d,&choices,&items,1))goto done;
    DialogText(d,13,"Choices stay in this window until the final Apply or Pop approval.");PrepareDialog(d,2,2);ChoiceSelect(d,0);SHConflictSync(d);DrawDialog(d);
    while(!gDone){
        hit=0;RunModalDialog(filter,&hit);if(hit==2 || gDone)break;
        if(hit==1 && !MUIUnchosen(draft)){approved=1;break;}
        if(hit==3 && gChoiceSelected<draft->count)MUINode(folder,draft,gChoiceSelected);
        if(hit==4 && gChoiceSelected<draft->count)MUICompare(folder,draft,gChoiceSelected);
        if(hit==5)ChoiceDetails();
        if(hit==11 && gChoiceFirst)ChoiceSelect(d,gChoiceFirst-CHOICE_PAGE);
        if(hit==12 && gChoiceFirst+gChoiceRows<draft->count)ChoiceSelect(d,gChoiceFirst+CHOICE_PAGE);
        SHConflictSync(d);SetPort((GrafPtr)d);ChoiceRefresh(d);InvalRect(&((WindowPtr)d)->portRect);
    }
    ChoiceDispose();
done:
    if(filter)DisposeRoutineDescriptor((UniversalProcPtr)filter);DisposeDialog(d);gSHConflict=NULL;SetPort(gWindow);return approved && !gDone;
}
static int SHValues(const MUIDraft *d,TMResolution **out){
    TMResolution *values;size_t i;if(MUIUnchosen(d))return GI_UNMERGED;
    if(!d->count){*out=NULL;return 0;}values=malloc(d->count*sizeof(*values));if(!values)return GB_MEMORY;
    for(i=0;i<d->count;++i)values[i]=d->rows[i].value;*out=values;return 0;
}
static void SHLimits(TMLimits *limits){MMLimits merge;NativeMergeLimits(&merge);*limits=merge.tree;limits->pathBytes=16384;}
static void SHError(const char *title,int result,const GQError *why){
    if(!result || gDone)return;
    if(gCheckoutStopped)SetStatus("Stash operation stopped. Refresh to check recovery; keep this repository intact.");
    else if(why && why->reason)Message("Keep Current Changes","This stash would replace a later change or an existing file or folder. Keep or move the obstructing changes, then review the stash again.");
    else CheckoutError(title,result);
}
static int SHReview(const GXStashList *list,size_t selected,int action){
    GXStashReview review;GXDiscardReview plan;MUIDraft working,staged;TMResolution *wc=NULL,*sc=NULL;
    OperationPrompt prompt;GQError why;TMLimits limits;FSSpec folder;const SLEntry *entry=SHEntry(list,selected);
    char repository[256],state[600],body[600],id[41],tipText[41],*branch=NULL,*details=NULL;
    unsigned char stash[20],tip[20];int result=0,closed,answer=0,drop=action==4,pop=action==3;
    GXStashReviewInit(&review);GXDiscardInit(&plan);MUIInit(&working);MUIInit(&staged);memset(&why,0,sizeof(why));
    if(!entry)return GB_BAD;memcpy(stash,entry->after,20);folder=gWork.folder;gCheckoutStopped=0;
    if(!drop){
        if(!gWork.haveHead){result=GS_CONFLICT;goto done;}
        branch=malloc(strlen(gWork.branch)+1);if(!branch){result=GB_MEMORY;goto done;}strcpy(branch,gWork.branch);memcpy(tip,gWork.tip,20);SHLimits(&limits);
    }
    result=CheckoutAttach(&folder);
    if(!result){
        CheckoutBegin("Verifying the selected stash... Escape cancels review.");
        result=drop?GXStashDropPrepare(&gUICheckout,list,selected,stash,&plan):GXStashApplyPrepare(&gUICheckout,list,selected,stash,branch,tip,&limits,'\r',&review);gBusy=0;
    }
    closed=CheckoutRelease();if(!result)result=closed;LocalRefresh();if(result || gDone || gLocalBlocked)goto done;
    MUIRepositoryLabel(&folder,repository);strcpy(gMUIRepository,repository);
    if(!drop){
        result=SHDraft(&working,&review.review.working,branch,"Working File Conflicts");
        if(!result)result=SHDraft(&staged,&review.review.staged,branch,"Staging Conflicts");if(result)goto done;
        if(!SHConflicts(&folder,&working) || !SHConflicts(&folder,&staged)){SetStatus("Stash review cancelled. Files, staging and stash kept.");goto done;}
        result=SHValues(&working,&wc);if(!result)result=SHValues(&staged,&sc);
        if(!result)result=CheckoutAttach(&folder);
        if(!result){CheckoutBegin("Checking the complete stash proposal... Escape cancels.");result=GXStashApplyBuild(&gUICheckout,&review,wc,working.count,sc,staged.count,pop,&plan,&why);gBusy=0;}
        closed=CheckoutRelease();if(!result)result=closed;LocalRefresh();if(result || gDone || gLocalBlocked)goto done;
    }
    GBOIDFormat(stash,id);memset(&prompt,0,sizeof(prompt));prompt.title=drop?"Drop Stash":pop?"Pop Stashed Changes":"Apply Stashed Changes";
    prompt.repository=repository;prompt.state=state;prompt.primary=drop?"Drop Stash":pop?"Pop Stash":"Apply Stash";prompt.primaryText=body;prompt.canPrimary=1;
    snprintf(state,sizeof(state),"stash@{%lu} / %lu working file change%s\r%s",(unsigned long)selected,(unsigned long)plan.plan.transaction.fileCount,plan.plan.transaction.fileCount==1?"":"s",drop?"Current files, staging and branch will be kept.":"Separate working and staging versions; current branch tip kept.");
    snprintf(body,sizeof(body),"%s",drop?"Remove this stash entry from Git's stash list. Current files and staging are unchanged. Native Saved Changes recovery copies and immutable archives are retained.":
        pop?"Restore the reviewed staged and working versions, including both forks and Finder attributes. Remove this stash entry in the same recoverable operation.":
        "Restore the reviewed staged and working versions, including both forks and Finder attributes. Keep this stash entry for later use.");
    prompt.secondary="Stash Details";prompt.secondaryText="Read the full original message and exact stash identity.";prompt.canSecondary=1;
    prompt.footer="Later overlapping edits or a changed stash list cause refusal. Cancel keeps your files, staging and stash.";
    prompt.labels[0]="Selected stash";prompt.values[0]=id;
    if(!drop){GBOIDFormat(tip,tipText);prompt.labels[1]="Current branch";prompt.values[1]=branch;prompt.labels[2]="Current commit";prompt.values[2]=tipText;}
    do{answer=OperationConfirm(&prompt);if(answer==2 && !gDone){details=SHDetails((void *)list,selected);if(details){Message("Stash Details",details);free(details);details=NULL;}else SysBeep(1);}}while(answer==2 && !gDone);
    if(answer!=1 || gDone){SetStatus("Stash review closed. No operation was approved.");goto done;}
    result=CheckoutAttach(&folder);
    if(!result){CheckoutBegin("Updating stashed changes... Escape stops at a recoverable checkpoint.");result=GXDiscardApply(&gUICheckout,&plan);gBusy=0;}
    closed=CheckoutRelease();if(!result)result=closed;LocalRefresh();
    if(!result && !gLocalBlocked)SetStatus(drop?"Stash entry dropped. Current files and staging kept.":pop?"Stash popped. Staged and working forks restored; entry removed.":"Stash applied. Staged and working forks restored; stash kept.");
done:
    gMUIRepository[0]=0;free(branch);free(details);free(wc);free(sc);SHDraftFree(&working);SHDraftFree(&staged);GXDiscardFree(&plan);GXStashReviewFree(&review);
    SHError(drop?"Drop Stash":pop?"Pop Stash":"Apply Stash",result,&why);return result;
}
static void SHStorePaths(const DUSelection *selection){
    WSRecord view;NativeChoices choices;WSInit(&view);view.paths=selection->paths;view.pathCount=selection->count;
    memset(&choices,0,sizeof(choices));choices.context=&view;choices.count=view.pathCount;choices.row=SUIPathRow;choices.details=SUIPathDetails;
    choices.title="Paths to Stash";choices.description="All changed files are included, even when Changes is filtered. This review does not change files.";
    choices.action="Done";choices.noun="Paths";(void)PickNativeChoice(&choices);
}
static void StashChangesCommand(void){
    DUSelection selected;GFInventory inventory;GPMap map;GXDiscardReview plan;GQProtection paths;GQError why;OperationPrompt prompt;
    FSSpec folder;unsigned char tip[20];char repository[256],seconds[32],state[600],id[41],base[41],*branch=NULL,*identity=NULL;unsigned long macTime;long delta;MachineLocation location;
    int result=0,closed,answer=0;
    if(!StashAvailable())return;LocalRefresh();if(!StashAvailable() || !LocalAuthor(0))return;
    DUInit(&selected);GFInit(&inventory);GPInit(&map);GXDiscardInit(&plan);memset(&why,0,sizeof(why));gCheckoutStopped=0;
    folder=gWork.folder;memcpy(tip,gWork.tip,20);branch=malloc(strlen(gWork.branch)+1);identity=malloc(strlen(gCommitIdentity)+1);
    if(!branch || !identity){result=GB_MEMORY;goto done;}strcpy(branch,gWork.branch);strcpy(identity,gCommitIdentity);
    GetDateTime(&macTime);ReadLocation(&location);delta=location.u.gmtDelta&0x00ffffffL;if(delta&0x00800000L)delta|=0xff000000L;
    snprintf(seconds,sizeof(seconds),"%lu",macTime-delta-2082844800UL);result=CheckoutAttach(&folder);
    if(!result){
        CheckoutBegin("Preparing all changes for Stash... Escape cancels.");result=GSMacEnter(&gUICheckout.store,0);
        if(!result)result=GTNormalWriteAllowed(&gUICheckout.raw);
        if(!result)result=GPLoad(&gUICheckout.raw,GWMacNameEqual,NULL,&map);
        if(!result)result=GFCollect(&gUICheckout.root,&map,&inventory,&gUICheckout.lastError);
        if(!result)result=DUBuild(&gWork,&inventory,&selected);
        if(gUICheckout.store.leaseHeld){closed=GSMacLeave(&gUICheckout.store);if(!result)result=closed;}
        paths.paths=(const char *const *)selected.paths;paths.count=selected.count;paths.changed=0;
        if(!result && selected.files)result=GXStashStorePrepare(&gUICheckout,branch,tip,&paths,identity,seconds,"+0000",&plan,&why);gBusy=0;
    }
    closed=CheckoutRelease();if(!result)result=closed;LocalRefresh();if(result || gDone || gLocalBlocked)goto done;
    if(!selected.files){SetStatus("No changes to stash.");goto done;}
    MUIRepositoryLabel(&folder,repository);GBOIDFormat(tip,base);GBOIDFormat(plan.snapshotOID,id);memset(&prompt,0,sizeof(prompt));
    prompt.title="Stash All Changes";prompt.repository=repository;prompt.state=state;
    snprintf(state,sizeof(state),"%lu changed file%s / %lu staged / %lu untracked\rReset the reviewed changes to the current commit.",(unsigned long)selected.files,selected.files==1?"":"s",(unsigned long)selected.staged,(unsigned long)selected.untracked);
    prompt.primary="Stash Changes";prompt.primaryText="Save separate staged and working versions, both forks and Finder attributes. Add one Git stash entry and reset these changes in the same recoverable operation.";prompt.canPrimary=1;
    prompt.secondary="Review Paths";prompt.secondaryText="Inspect the complete selection, including changes hidden by the current filter.";prompt.canSecondary=1;
    prompt.footer="Ignored files and unrelated folders are kept. A native Saved Changes recovery copy is also retained. Cancel keeps your files and staging.";
    prompt.labels[0]="Current branch";prompt.values[0]=branch;prompt.labels[1]="Current commit";prompt.values[1]=base;prompt.labels[2]="Native saved copy";prompt.values[2]=id;
    do{answer=OperationConfirm(&prompt);if(answer==2 && !gDone)SHStorePaths(&selected);}while(answer==2 && !gDone);
    if(answer!=1 || gDone){SetStatus("Stash cancelled. Files and staging kept.");goto done;}
    result=CheckoutAttach(&folder);if(!result){CheckoutBegin("Stashing changes... Escape stops at a recoverable checkpoint.");result=GXDiscardApply(&gUICheckout,&plan);gBusy=0;}
    closed=CheckoutRelease();if(!result)result=closed;LocalRefresh();
    if(!result && !gLocalBlocked)SetStatus("Changes stashed. Use View > Stashed Changes to apply or pop; branch tip kept.");
done:
    free(branch);free(identity);DUFree(&selected);GFFree(&inventory);GPFree(&map);GXDiscardFree(&plan);SHError("Stash Changes",result,&why);
}
static void StashedChangesCommand(void){
    GXStashList list;size_t selected=0;int result=0,closed,action;
    if(!gLocal || gLocalBlocked || gDone)return;GXStashListInit(&list);LocalRefresh();
    while(!gDone && gLocal && !gLocalBlocked){
        result=CheckoutAttach(&gWork.folder);gCheckoutStopped=0;
        if(!result){gBusy=1;gUICheckout.checkpoint=CheckoutProgress;SetStatus("Reading stashed changes... Escape cancels.");result=GXStashListRead(&gUICheckout,&list);gBusy=0;}
        closed=CheckoutRelease();if(!result)result=closed;if(result){LocalRefresh();break;}
        SetStatus(list.state.log.count?"Choose a stash to review, apply, pop or drop.":"No Git stashes. Store your current changes or close this window.");
        action=SHChoose(&list,&selected);if(!action)break;
        if(action==14)StashChangesCommand();else if(SHReview(&list,selected,action))break;
        GXStashListFree(&list);
    }
    GXStashListFree(&list);gBusy=0;SHError("Stashed Changes",result,NULL);
}
