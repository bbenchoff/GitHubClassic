#include "GitStashLog.h"
#include <stdlib.h>
#include <string.h>
static int SLZero(const unsigned char *p){size_t i;for(i=0;i<20;++i)if(p[i])return 0;return 1;}
static int SLBounds(const SLLimits *l){return l && l->bytes && l->bytes<(size_t)-1 && l->entries && l->lineBytes;}
static int SLTime(const unsigned char *p,size_t n){size_t i=0;if(n && p[0]=='-')++i;if(i==n || n-i>20)return 0;for(;i<n;++i)if(p[i]<'0' || p[i]>'9')return 0;return 1;}
static int SLZone(const unsigned char *p,size_t n){size_t i;if(n!=5 || (p[0]!='+' && p[0]!='-'))return 0;for(i=1;i<5;++i)if(p[i]<'0' || p[i]>'9')return 0;return 1;}
void SLInit(SLLog *l){memset(l,0,sizeof(*l));}
void SLFree(SLLog *l){free(l->bytes);free(l->entries);SLInit(l);}
static int SLLine(const unsigned char *p,size_t offset,size_t length,SLEntry *e){
    size_t i,tab,time,ident,open=(size_t)-1;char hex[41];
    if(length<90 || p[length-1]!='\n' || p[40]!=' ' || p[81]!=' ')return GS_FORMAT;
    memcpy(hex,p,40);hex[40]=0;if(GBOIDParse(hex,e->before))return GS_FORMAT;
    memcpy(hex,p+41,40);if(GBOIDParse(hex,e->after) || SLZero(e->after))return GS_FORMAT;
    for(i=82;i<length-1 && p[i]!='\t';++i)if(!p[i] || p[i]=='\n')return GS_FORMAT;
    if(i==length-1)return GS_FORMAT;tab=i;
    if(tab<6 || p[tab-6]!=' ' || !SLZone(p+tab-5,5))return GS_FORMAT;
    time=tab-6;while(time>82 && p[time-1]!=' ')--time;
    if(time==82 || !SLTime(p+time,tab-6-time))return GS_FORMAT;
    ident=time-1;if(ident<=83 || p[ident-1]!='>')return GS_FORMAT;
    for(i=82;i<ident;++i){
        if(p[i]<32 || p[i]==127)return GS_FORMAT;
        if(p[i]=='<'){if(open!=(size_t)-1)return GS_FORMAT;open=i;}
        if(p[i]=='>' && i!=ident-1)return GS_FORMAT;
    }
    if(open==(size_t)-1 || open+1>=ident-1)return GS_FORMAT;
    for(i=tab+1;i<length-1;++i)if(!p[i] || p[i]=='\n')return GS_FORMAT;
    e->offset=offset;e->length=length;e->messageOffset=offset+tab+1;e->messageLength=length-tab-2;
    return 0;
}
int SLParse(const void *bytes,size_t n,const SLLimits *limits,SLLog *out){
    const unsigned char *p=bytes;SLLog next;SLEntry entry;size_t at=0,end,count=0;int result;
    if(!out || (!p && n) || !SLBounds(limits))return GB_BAD;
    if(n>limits->bytes)return GB_SPACE;
    while(at<n){
        end=at;while(end<n && p[end]!='\n'){if(end-at>=limits->lineBytes)return GB_SPACE;++end;}
        if(end==n)return GS_FORMAT;
        if(end-at+1>limits->lineBytes || count>=limits->entries || count>=(size_t)-1/sizeof(SLEntry))return GB_SPACE;
        result=SLLine(p+at,at,end-at+1,&entry);if(result)return result;
        ++count;at=end+1;
    }
    SLInit(&next);next.bytes=malloc(n+1);next.entries=count?calloc(count,sizeof(SLEntry)):NULL;
    if(!next.bytes || (count && !next.entries)){SLFree(&next);return GB_MEMORY;}
    if(n)memcpy(next.bytes,p,n);next.bytes[n]=0;next.length=n;next.count=count;at=0;
    for(count=0;count<next.count;++count){
        end=at;while(end<next.length && next.bytes[end]!='\n')++end;
        if(end==next.length || end-at+1>limits->lineBytes){SLFree(&next);return GS_FORMAT;}
        result=SLLine(next.bytes+at,at,end-at+1,next.entries+count);
        if(result){SLFree(&next);return result;}at=end+1;
    }
    if(at!=next.length){SLFree(&next);return GS_FORMAT;}
    SLFree(out);*out=next;return 0;
}
static int SLValid(const SLLog *log,const SLLimits *l){
    size_t i,at=0;
    if(!log || !SLBounds(l) || !log->bytes || log->length>l->bytes ||
       log->count>l->entries || (log->count && !log->entries))return 0;
    for(i=0;i<log->count;++i){const SLEntry *e=log->entries+i;
        if(e->offset!=at || e->length<90 || e->length>l->lineBytes || e->length>log->length-at)return 0;
        at+=e->length;
    }
    return at==log->length;
}
int SLAppend(const SLLog *log,const unsigned char *expected,const unsigned char oid[20],
    const char *identity,const char *seconds,const char *zone,const char *message,
    const SLLimits *limits,unsigned char **out,size_t *size){
    size_t a,b,c,total,line;unsigned char *p;char hex[41];
    if(!SLValid(log,limits) || !oid || SLZero(oid) || !out || !size || !identity || !GSValidIdentity(identity) ||
       !seconds || !SLTime((const unsigned char *)seconds,strlen(seconds)) || !zone || !SLZone((const unsigned char *)zone,strlen(zone)) ||
       !message || strchr(message,'\n') || strchr(identity,'\t'))return GB_BAD;
    if((!log->count && expected) || (log->count && (!expected || memcmp(expected,log->entries[log->count-1].after,20))))return GS_CONFLICT;
    /* Git stash store does not append a reflog entry for an unchanged tip. */
    if(expected && !memcmp(expected,oid,20)){
        p=malloc(log->length+1);if(!p)return GB_MEMORY;
        memcpy(p,log->bytes,log->length+1);*out=p;*size=log->length;return 0;
    }
    if(log->count==limits->entries)return GB_SPACE;
    a=strlen(identity);b=strlen(seconds);c=strlen(message);line=91;
    if(a>limits->lineBytes || b>limits->lineBytes-a || c>limits->lineBytes-a-b || line>limits->lineBytes-a-b-c)return GB_SPACE;
    line+=a+b+c;total=log->length;if(line>limits->bytes-total)return GB_SPACE;total+=line;
    p=malloc(total+1);if(!p)return GB_MEMORY;if(log->length)memcpy(p,log->bytes,log->length);
    if(expected)GBOIDFormat(expected,hex);else memset(hex,'0',40);
    memcpy(p+log->length,hex,40);p[log->length+40]=' ';GBOIDFormat(oid,hex);memcpy(p+log->length+41,hex,40);
    total=log->length+81;p[total++]=' ';memcpy(p+total,identity,a);total+=a;p[total++]=' ';
    memcpy(p+total,seconds,b);total+=b;p[total++]=' ';memcpy(p+total,zone,5);total+=5;p[total++]='\t';
    memcpy(p+total,message,c);total+=c;p[total++]='\n';p[total]=0;*out=p;*size=total;return 0;
}
int SLDrop(const SLLog *log,size_t newest,const unsigned char expected[20],const SLLimits *limits,unsigned char **out,size_t *size){
    unsigned char *p,previous[20];size_t skip,i,at=0,total;char hex[41];
    if(!SLValid(log,limits) || !expected || !out || !size || newest>=log->count)return GB_BAD;
    skip=log->count-1-newest;if(memcmp(expected,log->entries[skip].after,20))return GS_CONFLICT;
    total=log->length-log->entries[skip].length;p=malloc(total+1);if(!p)return GB_MEMORY;memset(previous,0,20);
    for(i=0;i<log->count;++i)if(i!=skip){const SLEntry *e=log->entries+i;
        GBOIDFormat(previous,hex);memcpy(p+at,hex,40);p[at+40]=' ';
        GBOIDFormat(e->after,hex);memcpy(p+at+41,hex,40);
        memcpy(p+at+81,log->bytes+e->offset+81,e->length-81);at+=e->length;memcpy(previous,e->after,20);
    }
    p[at]=0;*out=p;*size=at;return 0;
}
