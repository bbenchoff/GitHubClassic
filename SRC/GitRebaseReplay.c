#include "GitRebaseReplay.h"
#include "GitHistory.h"
#include <stdlib.h>
#include <string.h>

void RRInit(RRResult *result){memset(result,0,sizeof(*result));}
void RRFree(RRResult *result){RBFree(&result->plan);free(result->items);RSFree(&result->conflict);RRInit(result);}
static int RRWrite(void *context,const char *key,const void *old,size_t on,const void *next,size_t nn) {
    GOReader *state=(GOReader *)context;
    if(strncmp(key,"objects/",8) || old || on || !next || !nn)return GB_BAD;
    return state->source->replace(state->source->context,key,NULL,0,next,nn);
}
static int RRVerifyTip(GSRepository *source,const unsigned char tip[20],const TMLimits *limits,GDProgress progress,void *context) {
    unsigned char *raw=NULL;size_t n=0;char type[7];GHCommitInfo info;GRSnapshot snapshot;GIReadLimits traversal;int result;
    GRInit(&snapshot);memset(&traversal,0,sizeof(traversal));traversal.entries=limits->entries;traversal.depth=limits->depth;
    traversal.pathBytes=limits->pathBytes;traversal.progress=progress;traversal.context=context;
    result=GSGetObject(source,tip,type,&raw,&n);
    if(!result)result=strcmp(type,"commit")?GS_FORMAT:GHCommitParse(raw,n,&info);
    if(!result)result=GRFromTreeBounded(source,info.tree,&snapshot,&traversal);
    free(raw);GRFree(&snapshot);return result;
}
int RRReplay(GSRepository *source,const unsigned char head[20],const unsigned char onto[20],char newline,
    const RRLimits *limits,const char *committer,const char *seconds,const char *zone,GDProgress progress,void *context,RRResult *destination) {
    GOReader state;GSRepository writer;RRResult *next;RSStep *step;RPResult receipt;RRItem *item;
    size_t i;int result;
    if(!source || !source->read || !source->replace || !head || !onto || !limits || !destination || (newline!='\n' && newline!='\r'))return GB_BAD;
    result=GOReadStart(source,&limits->all,progress,context,&state,&writer);if(result)return result;writer.replace=RRWrite;
    next=(RRResult *)calloc(1,sizeof(*next));step=(RSStep *)calloc(1,sizeof(*step));
    if(!next || !step){free(next);free(step);return GB_MEMORY;}
    result=RBPrepare(&writer,head,onto,&limits->plan,progress,context,&next->plan);
    if(!result) {
        memcpy(next->tip,head,20);
        if(next->plan.kind==RB_MULTIPLE_BASES)next->kind=RR_MULTIPLE_BASES;
        else if(next->plan.kind==RB_UNRELATED)next->kind=RR_UNRELATED;
        else if(next->plan.kind==RB_MERGE_HISTORY)next->kind=RR_MERGE_HISTORY;
        else {
            next->kind=RR_COMPLETE;
            if(next->plan.kind==RB_FAST_FORWARD || next->plan.kind==RB_REPLAY)memcpy(next->tip,onto,20);
            if(next->plan.count>(size_t)-1/sizeof(*next->items))result=GB_SPACE;
            if(!result && next->plan.count){next->items=(RRItem *)calloc(next->plan.count,sizeof(*next->items));if(!next->items)result=GB_MEMORY;}
            for(i=0;!result && i<next->plan.count;++i) {
                result=RSPrepare(&writer,next->plan.commits[i],next->tip,newline,&limits->step,progress,context,step);
                if(!result && step->kind==RS_CONFLICT) {
                    next->kind=RR_CONFLICT;next->conflict=*step;RSInit(step);break;
                }
                if(!result)result=RPPublish(&writer,step,committer,seconds,zone,progress,context,&receipt);
                if(!result) {
                    item=next->items+i;memcpy(item->candidate,next->plan.commits[i],20);memcpy(item->tip,receipt.commit,20);
                    item->kind=receipt.kind;item->droppedSignatures=receipt.droppedSignatures;
                    memcpy(next->tip,receipt.commit,20);++next->completed;
                }
                RSFree(step);
            }
            if(!result && next->kind==RR_COMPLETE)result=RRVerifyTip(&writer,next->tip,&limits->step,progress,context);
        }
    }
    if(!result && progress)result=progress(context);
    if(!result) {
        next->encodedReadBytes=state.bytes;next->expandedReadBytes=state.expanded;next->readCount=state.reads;
        RRFree(destination);*destination=*next;RRInit(next);
    }
    RSFree(step);free(step);RRFree(next);free(next);return result;
}
