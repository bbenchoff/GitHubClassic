#include "GitFileMac.h"
#include "GitWorkMac.h"
#include <Errors.h>
#include <stdlib.h>
#include <string.h>
#include <stdio.h>

void GFInit(GFInventory *i) { memset(i, 0, sizeof(*i)); }
void GFFree(GFInventory *i) {
    size_t n;
    for (n = 0; n < i->count; ++n) {
        free((void *)i->items[n].path);
        free((void *)i->items[n].native);
    }
    free(i->items);
    free(i->catalog);
    GFInit(i);
}
static int GFError(OSErr error, OSErr *last) {
    if (last)
        *last = error;
    return error == fnfErr || error == dirNFErr ? GS_NOT_FOUND : GS_IO;
}
int GFCatalogRead(const FSSpec *spec, GFCatalog *out, OSErr *last) {
    CInfoPBRec pb;
    GFCatalog c;
    OSErr error;
    if (!spec || !out)
        return GB_BAD;
    memset(&pb, 0, sizeof(pb));
    pb.hFileInfo.ioNamePtr = (StringPtr)spec->name;
    pb.hFileInfo.ioVRefNum = spec->vRefNum;
    pb.hFileInfo.ioDirID = spec->parID;
    error = PBGetCatInfoSync(&pb);
    if (error)
        return GFError(error, last);
    memset(&c, 0, sizeof(c));
    c.spec = *spec;
    c.attributes = (unsigned char)pb.hFileInfo.ioFlAttrib;
    if (c.attributes & 16) {
        c.id = pb.dirInfo.ioDrDirID;
        c.children = pb.dirInfo.ioDrNmFls;
        c.created = pb.dirInfo.ioDrCrDat;
        c.modified = pb.dirInfo.ioDrMdDat;
        c.backup = pb.dirInfo.ioDrBkDat;
        memcpy(c.finderInfo, &pb.dirInfo.ioDrUsrWds, 16);
        memcpy(c.finderInfo + 16, &pb.dirInfo.ioDrFndrInfo, 16);
    } else {
        if (pb.hFileInfo.ioFlLgLen < 0 || pb.hFileInfo.ioFlRLgLen < 0)
            return GS_FORMAT;
        c.id = pb.hFileInfo.ioDirID;
        c.dataLength = (GBWord)pb.hFileInfo.ioFlLgLen;
        c.resourceLength = (GBWord)pb.hFileInfo.ioFlRLgLen;
        c.created = pb.hFileInfo.ioFlCrDat;
        c.modified = pb.hFileInfo.ioFlMdDat;
        c.backup = pb.hFileInfo.ioFlBkDat;
        memcpy(c.finderInfo, &pb.hFileInfo.ioFlFndrInfo, 16);
        memcpy(c.finderInfo + 16, &pb.hFileInfo.ioFlXFndrInfo, 16);
    }
    *out = c;
    return 0;
}
int GFDirectoryAt(short volume, long id, GFCatalog *out, OSErr *last) {
    CInfoPBRec pb;
    Str255 name;
    FSSpec spec;
    OSErr error;
    if (!out)
        return GB_BAD;
    memset(&pb, 0, sizeof(pb));
    pb.dirInfo.ioNamePtr = name;
    pb.dirInfo.ioVRefNum = volume;
    pb.dirInfo.ioDrDirID = id;
    pb.dirInfo.ioFDirIndex = -1;
    error = PBGetCatInfoSync(&pb);
    if (!error)
        error = FSMakeFSSpec(volume, pb.dirInfo.ioDrParID, name, &spec);
    if (error)
        return GFError(error, last);
    return GFCatalogRead(&spec, out, last);
}
static int GFName(const char *start, size_t n, Str31 name) {
    char text[32];
    if (!n || n > 31)
        return 0;
    memcpy(text, start, n);
    text[n] = 0;
    if (GWMacNameEqual(NULL, text, ".") || GWMacNameEqual(NULL, text, "..") ||
        GWMacNameEqual(NULL, text, ".git") || GWMacNameEqual(NULL, text, GI_MAC_NAMESPACE))
        return 0;
    name[0] = (unsigned char)n;
    memcpy(name + 1, start, n);
    return 1;
}
int GFResolve(const GSMacStore *root, const char *path, FSSpec *out, int *kind, long *id,
              OSErr *last) {
    const char *p = path, *start = path;
    Str31 name;
    FSSpec spec;
    GFCatalog c;
    long parent;
    int result;
    OSErr error;
    if (!root || !path || !out || !kind || !id)
        return GB_BAD;
    *kind = 0;
    *id = 0;
    memset(out, 0, sizeof(*out));
    parent = root->directory;
    /* Validate the complete path even if an early ancestor is absent. */
    for (;; ++p)
        if (!*p || *p == ':') {
            if (!GFName(start, (size_t)(p - start), name))
                return GB_BAD;
            if (!*p)
                break;
            start = p + 1;
        }
    for (p = start = path;; ++p)
        if (!*p || *p == ':') {
            GFName(start, (size_t)(p - start), name);
            error = FSMakeFSSpec(root->volume, parent, name, &spec);
            if (error == fnfErr || error == dirNFErr) {
                if (!*p)
                    *out = spec;
                return 0;
            }
            if (error)
                return GFError(error, last);
            result = GFCatalogRead(&spec, &c, last);
            if (result)
                return result;
            if (!*p) {
                *out = spec;
                *kind = c.attributes & 16 ? 2 : 1;
                *id = c.id;
                return 0;
            }
            if (!(c.attributes & 16))
                return 0;
            parent = c.id;
            start = p + 1;
        }
}
static int GFSameCatalog(const GFCatalog *a, const GFCatalog *b) {
    return a->id == b->id && a->attributes == b->attributes && a->created == b->created &&
           a->modified == b->modified && a->backup == b->backup && a->dataLength == b->dataLength &&
           a->resourceLength == b->resourceLength && a->children == b->children &&
           !memcmp(a->finderInfo, b->finderInfo, 32);
}
int GFDirectoryRestore(const GFCatalog *desired, const GFCatalog *expected, OSErr *last) {
    GFCatalog current, after;
    CInfoPBRec pb;
    OSErr error;
    int result;
    if (!desired || !expected || !(desired->attributes & 16) || !(expected->attributes & 16))
        return GB_BAD;
    if (desired->attributes != expected->attributes)
        return GI_UNSUPPORTED;
    result = GFCatalogRead(&expected->spec, &current, last);
    if (result)
        return result;
    if (!GFSameCatalog(&current, expected))
        return GS_CONFLICT;
    memset(&pb, 0, sizeof(pb));
    pb.dirInfo.ioNamePtr = (StringPtr)expected->spec.name;
    pb.dirInfo.ioVRefNum = expected->spec.vRefNum;
    pb.dirInfo.ioDrDirID = expected->spec.parID;
    error = PBGetCatInfoSync(&pb);
    if (error)
        return GFError(error, last);
    memcpy(&pb.dirInfo.ioDrUsrWds, desired->finderInfo, 16);
    memcpy(&pb.dirInfo.ioDrFndrInfo, desired->finderInfo + 16, 16);
    pb.dirInfo.ioDrCrDat = desired->created;
    pb.dirInfo.ioDrMdDat = desired->modified;
    pb.dirInfo.ioDrBkDat = desired->backup;
    pb.dirInfo.ioDrDirID = expected->spec.parID;
    error = PBSetCatInfoSync(&pb);
    if (!error)
        error = FlushVol(NULL, expected->spec.vRefNum);
    if (error)
        return GFError(error, last);
    result = GFCatalogRead(&expected->spec, &after, last);
    if (result)
        return result;
    if (after.id != expected->id || after.attributes != expected->attributes ||
        after.created != desired->created || after.modified != desired->modified ||
        after.backup != desired->backup || memcmp(after.finderInfo, desired->finderInfo, 32))
        return GS_CONFLICT;
    return 0;
}
int GFIdentity(const FSSpec *spec, GCFile *out, GFCatalog *catalog, OSErr *last) {
    GFCatalog before, after;
    GCFile f;
    unsigned char *data = NULL, *resource = NULL;
    size_t n = 0, rn = 0;
    int result;
    if (!spec || !out)
        return GB_BAD;
    memset(&f, 0, sizeof(f));
    result = GFCatalogRead(spec, &before, last);
    if (result)
        return result;
    if (before.attributes & 16)
        f.present = 2;
    else {
        result = GWReadFile(spec, &data, &n, f.finderInfo, &resource, &rn);
        if (!result)
            result = GBObjectID("blob", data, n, f.dataOID);
        if (!result)
            result = GBObjectID("blob", resource, rn, f.resourceOID);
        free(data);
        free(resource);
        if (result)
            return result;
        result = GFCatalogRead(spec, &after, last);
        if (result)
            return result;
        if (!GFSameCatalog(&before, &after) || n != after.dataLength || rn != after.resourceLength)
            return GS_CONFLICT;
        f.present = 1;
    }
    *out = f;
    if (catalog)
        *catalog = before;
    return 0;
}
void GFLockInit(GFLockedFile *file) { memset(file, 0, sizeof(*file)); }
/* File open bits are access-path state, not durable file attributes. Directory
   sharing bits use those positions differently and must never be masked. */
static int GFStableCatalog(const GFCatalog *a, const GFCatalog *b) {
    GFCatalog x = *a, y = *b;
    if (!(x.attributes & 16))
        x.attributes &= (unsigned char)~0x8cU;
    if (!(y.attributes & 16))
        y.attributes &= (unsigned char)~0x8cU;
    return GFSameCatalog(&x, &y);
}
static int GFForkID(short ref, unsigned char oid[20], OSErr *last) {
    unsigned char buffer[1024], digest[20];
    char header[40];
    GBSHA1 hash;
    long size, remaining, count;
    OSErr error;
    error = GetEOF(ref, &size);
    if (!error && size < 0)
        error = paramErr;
    if (!error)
        error = SetFPos(ref, fsFromStart, 0);
    if (error)
        return GFError(error, last);
    sprintf(header, "blob %lu", (unsigned long)size);
    GBSHA1Start(&hash);
    GBSHA1Update(&hash, header, strlen(header) + 1);
    remaining = size;
    while (remaining) {
        count = remaining > (long)sizeof(buffer) ? (long)sizeof(buffer) : remaining;
        error = FSRead(ref, &count, buffer);
        if (error)
            return GFError(error, last);
        if (count <= 0 || count > remaining)
            return GS_IO;
        GBSHA1Update(&hash, buffer, (size_t)count);
        remaining -= count;
    }
    GBSHA1Finish(&hash, digest);
    memcpy(oid, digest, 20);
    return 0;
}
static int GFLockedIdentity(GFLockedFile *file, GCFile *identity, GFCatalog *catalog, OSErr *last) {
    GFCatalog before, after;
    GCFile f;
    int result;
    memset(&f, 0, sizeof(f));
    result = GFCatalogRead(&file->file, &before, last);
    if (!result && ((before.attributes & 16) || !GFStableCatalog(&before, &file->catalog)))
        result = GS_CONFLICT;
    if (!result)
        result = GFForkID(file->dataRef, f.dataOID, last);
    if (!result)
        result = GFForkID(file->resourceRef, f.resourceOID, last);
    if (!result)
        result = GFCatalogRead(&file->file, &after, last);
    if (!result && !GFStableCatalog(&before, &after))
        result = GS_CONFLICT;
    if (result)
        return result;
    memcpy(f.finderInfo, before.finderInfo, 32);
    f.finderInfo[8] &= (unsigned char)~1U;
    memset(f.finderInfo + 10, 0, 6);
    memset(f.finderInfo + 28, 0, 4);
    f.present = 1;
    *identity = f;
    *catalog = after;
    return 0;
}
int GFRecheckFile(GFLockedFile *file, GFCatalog *out, OSErr *last) {
    GCFile identity;
    GFCatalog catalog;
    int result;
    if (!file || !out || !file->haveData || !file->haveResource) return GB_BAD;
    result = GFLockedIdentity(file, &identity, &catalog, last);
    if (!result && !GCFileEqual(&identity, &file->identity)) result = GS_CONFLICT;
    if (!result) *out = catalog;
    return result;
}
static int GFReadFork(short ref,long size,unsigned char **out,OSErr *last) {
    unsigned char *p;long at=0,count;OSErr error;
    p=(unsigned char *)malloc(size?(size_t)size:1);if(!p)return GB_MEMORY;
    error=SetFPos(ref,fsFromStart,0);
    while(!error && at<size) {
        count=size-at;if(count>32768)count=32768;
        error=FSRead(ref,&count,p+at);
        if(!error && (count<=0 || count>size-at)){free(p);return GS_IO;}
        at+=count;
    }
    if(error){free(p);return GFError(error,last);}*out=p;return 0;
}
int GFReadLocked(GFLockedFile *file,size_t cap,unsigned char **data,size_t *dn,
    unsigned char **resource,size_t *rn,OSErr *last) {
    GFCatalog checked;long d=0,r=0;unsigned char *a=NULL,*b=NULL;int result;OSErr error;
    if(!data || !dn || !resource || !rn)return GB_BAD;
    *data=*resource=NULL;*dn=*rn=0;
    result=GFRecheckFile(file,&checked,last);
    if(!result) {
        error=GetEOF(file->dataRef,&d);if(!error)error=GetEOF(file->resourceRef,&r);
        if(error)result=GFError(error,last);
        else if(d<0 || r<0 || (size_t)d>cap || (size_t)r>cap-(size_t)d)result=GB_SPACE;
    }
    if(!result)result=GFReadFork(file->dataRef,d,&a,last);
    if(!result)result=GFReadFork(file->resourceRef,r,&b,last);
    if(!result)result=GFRecheckFile(file,&checked,last);
    if(!result){*data=a;*resource=b;*dn=(size_t)d;*rn=(size_t)r;}
    else {free(a);free(b);}return result;
}
int GFUnlockFile(GFLockedFile *file, OSErr *last) {
    OSErr error;
    int result = 0;
    if (!file)
        return GB_BAD;
    if (file->haveResource) {
        error = FSClose(file->resourceRef);
        if (error)
            result = GFError(error, last);
        else {
            file->haveResource = 0;
            file->resourceRef = 0;
        }
    }
    if (file->haveData) {
        error = FSClose(file->dataRef);
        if (error) {
            if (!result)
                result = GFError(error, last);
        } else {
            file->haveData = 0;
            file->dataRef = 0;
        }
    }
    return result;
}
int GFLockFile(const FSSpec *spec, const GCFile *expected, const GFCatalog *catalog,
               GFLockedFile *file, OSErr *last) {
    GFCatalog before, checked;
    GCFile identity;
    OSErr error;
    int result, closed;
    if (!spec || !expected || !catalog || !file || file->haveData || file->haveResource ||
        expected->present != 1 || (catalog->attributes & 16))
        return GB_BAD;
    if (last)
        *last = noErr;
    if (spec->vRefNum != catalog->spec.vRefNum || spec->parID != catalog->spec.parID ||
        spec->name[0] != catalog->spec.name[0] ||
        memcmp(spec->name + 1, catalog->spec.name + 1, spec->name[0]))
        return GS_CONFLICT;
    result = GFCatalogRead(spec, &before, last);
    if (!result && !GFStableCatalog(&before, catalog))
        result = GS_CONFLICT;
    if (result)
        return result;
    file->file = *spec;
    file->catalog = *catalog;
    file->identity = *expected;
    error = FSpOpenDF(spec, fsWrPerm, &file->dataRef);
    if (!error) {
        file->haveData = 1;
        error = FSpOpenRF(spec, fsWrPerm, &file->resourceRef);
        if (!error)
            file->haveResource = 1;
    }
    if (error) {
        if (last)
            *last = error;
        result = error == opWrErr ? GS_CONFLICT : GFError(error, last);
    }
    if (!result)
        result = GFLockedIdentity(file, &identity, &checked, last);
    if (!result && !GCFileEqual(&identity, expected))
        result = GS_CONFLICT;
    if (!result)
        file->catalog = checked;
    else {
        closed = GFUnlockFile(file, last);
        /* Retained flags still expose a failed close; never pretend it closed. */
        if (closed)
            return closed;
    }
    return result;
}
int GFMoveLocked(GFLockedFile *file, long destination, GFCatalog *out, OSErr *last) {
    GFCatalog parent, before, after;
    GCFile identity;
    FSSpec target;
    CMovePBRec pb;
    OSErr error;
    int result;
    if (!file || !out || !file->haveData || !file->haveResource)
        return GB_BAD;
    if (last)
        *last = noErr;
    result = GFDirectoryAt(file->file.vRefNum, destination, &parent, last);
    if (!result && (!(parent.attributes & 16) || parent.id != destination))
        result = GS_CONFLICT;
    if (!result)
        result = GFLockedIdentity(file, &identity, &before, last);
    if (!result && !GCFileEqual(&identity, &file->identity))
        result = GS_CONFLICT;
    if (result)
        return result;
    error = FSMakeFSSpec(file->file.vRefNum, destination, file->file.name, &target);
    if (!error)
        return GS_CONFLICT;
    if (error != fnfErr)
        return GFError(error, last);
    memset(&pb, 0, sizeof(pb));
    pb.ioVRefNum = file->file.vRefNum;
    pb.ioDirID = file->file.parID;
    pb.ioNamePtr = file->file.name;
    pb.ioNewDirID = destination;
    pb.ioNewName = NULL;
    error = PBCatMoveSync(&pb);
    if (error)
        return error == dupFNErr ? GS_CONFLICT : GFError(error, last);
    file->file = target; /* Even a later error may follow a successful move. */
    result = GFCatalogRead(&target, &after, last);
    if (!result && !GFStableCatalog(&before, &after))
        result = GS_CONFLICT;
    if (!result) {
        file->catalog = after;
        error = FlushVol(NULL, target.vRefNum);
        if (error)
            result = GFError(error, last);
    }
    if (!result)
        *out = after;
    return result;
}

typedef struct {
    long id, next;
    size_t seen;
    char *prefix;
    GFCatalog before;
} GFFrame;
static int GFAppend(GFInventory *i, char *path, char *native, const GCFile *file,
                    const GFCatalog *catalog) {
    GQWork *items;
    GFCatalog *records;
    if (i->count >= (size_t)-1 / sizeof(*items) || i->count >= (size_t)-1 / sizeof(*records))
        return GB_SPACE;
    items = (GQWork *)realloc(i->items, (i->count + 1) * sizeof(*items));
    if (!items)
        return GB_MEMORY;
    i->items = items;
    records = (GFCatalog *)realloc(i->catalog, (i->count + 1) * sizeof(*records));
    if (!records)
        return GB_MEMORY;
    i->catalog = records;
    items += i->count;
    items->path = path;
    items->native = native;
    items->file = *file;
    records[i->count++] = *catalog;
    return 0;
}
int GFCollect(const GSMacStore *root, const GPMap *mapping, GFInventory *out, OSErr *last) {
    GFInventory next;
    GFFrame *stack = NULL, *frame, *grown;
    CInfoPBRec pb;
    GFCatalog catalog, after;
    GCFile identity;
    FSSpec spec;
    Str255 name;
    char *native = NULL, *path = NULL, *prefix;
    unsigned char *encoded = NULL;
    size_t depth = 0, frames = 1, a, b, i, n;
    OSErr error;
    int result;
    if (!root || !mapping || !out || !last)
        return GB_BAD;
    *last = noErr;
    GFInit(&next);
    result = GPEncode(mapping, GWMacNameEqual, NULL, &encoded, &n);
    free(encoded);
    if (!result)
        result = GFDirectoryAt(root->volume, root->directory, &next.root, last);
    if (result)
        goto done;
    stack = (GFFrame *)calloc(1, sizeof(*stack));
    if (!stack) {
        result = GB_MEMORY;
        goto done;
    }
    stack[0].id = root->directory;
    stack[0].next = 1;
    stack[0].before = next.root;
    stack[0].prefix = (char *)calloc(1, 1);
    if (!stack[0].prefix) {
        result = GB_MEMORY;
        goto done;
    }
    for (;;) {
        frame = stack + depth;
        if (frame->next > 32767 || frame->before.children > 32767) {
            result = GI_UNSUPPORTED;
            break;
        }
        memset(&pb, 0, sizeof(pb));
        pb.dirInfo.ioNamePtr = name;
        pb.dirInfo.ioVRefNum = root->volume;
        pb.dirInfo.ioDrDirID = frame->id;
        pb.dirInfo.ioFDirIndex = (short)frame->next++;
        error = PBGetCatInfoSync(&pb);
        if (error == fnfErr) {
            result = GFDirectoryAt(root->volume, frame->id, &after, last);
            if (!result &&
                (!GFSameCatalog(&frame->before, &after) || frame->seen != after.children))
                result = GS_CONFLICT;
            if (result)
                break;
            free(frame->prefix);
            frame->prefix = NULL;
            if (!depth)
                break;
            --depth;
            continue;
        }
        if (error) {
            result = GFError(error, last);
            break;
        }
        ++frame->seen;
        if (!name[0] || name[0] > 31 || memchr(name + 1, 0, name[0])) {
            result = GI_UNSUPPORTED;
            break;
        }
        if (!depth) {
            char text[32];
            memcpy(text, name + 1, name[0]);
            text[name[0]] = 0;
            if (GWMacNameEqual(NULL, text, ".git"))
                continue;
        }
        a = strlen(frame->prefix);
        b = name[0];
        if (a > (size_t)-1 - b - 2) {
            result = GB_SPACE;
            break;
        }
        native = (char *)malloc(a + b + 1);
        if (!native) {
            result = GB_MEMORY;
            break;
        }
        memcpy(native, frame->prefix, a);
        memcpy(native + a, name + 1, b);
        native[a + b] = 0;
        result = GPResolveWork(mapping,native,GWMacNameEqual,NULL,&path);
        if (result)
            break;
        error = FSMakeFSSpec(root->volume, frame->id, name, &spec);
        if (error) {
            result = GFError(error, last);
            break;
        }
        result = GFIdentity(&spec, &identity, &catalog, last);
        if (result)
            break;
        if (catalog.id != pb.hFileInfo.ioDirID ||
            !!(catalog.attributes & 16) != !!(pb.dirInfo.ioFlAttrib & 16)) {
            result = GS_CONFLICT;
            break;
        }
        result = GFAppend(&next, path, native, &identity, &catalog);
        if (result)
            break;
        path = NULL;
        native = NULL;
        if (identity.present != 2)
            continue;
        prefix = (char *)malloc(a + b + 2);
        if (!prefix) {
            result = GB_MEMORY;
            break;
        }
        memcpy(prefix, next.items[next.count - 1].native, a + b);
        prefix[a + b] = ':';
        prefix[a + b + 1] = 0;
        if (depth + 1 == frames) {
            if (frames == (size_t)-1 / sizeof(*stack)) {
                free(prefix);
                result = GB_SPACE;
                break;
            }
            grown = (GFFrame *)realloc(stack, (frames + 1) * sizeof(*stack));
            if (!grown) {
                free(prefix);
                result = GB_MEMORY;
                break;
            }
            stack = grown;
            memset(stack + frames, 0, sizeof(*stack));
            ++frames;
        }
        frame = stack + (++depth);
        frame->id = catalog.id;
        frame->next = 1;
        frame->seen = 0;
        frame->prefix = prefix;
        frame->before = catalog;
    }
    /* Catch catalog identity/name changes while later subtrees were scanned. */
    for (i = 0; !result && i < next.count; ++i) {
        result = GFCatalogRead(&next.catalog[i].spec, &after, last);
        if (!result && !GFSameCatalog(next.catalog + i, &after))
            result = GS_CONFLICT;
    }
    if (!result) {
        GFFree(out);
        *out = next;
        GFInit(&next);
    }
done:
    if (stack)
        for (i = 0; i < frames; ++i)
            free(stack[i].prefix);
    free(stack);
    free(native);
    free(path);
    GFFree(&next);
    return result;
}
