#include "GHRemoteCache.h"
#include <stdlib.h>
#include <string.h>
static void RCWipe(void *data,size_t n) {volatile unsigned char *p=data;while(n--)*p++=0;}
static void RCDrop(RCCache *c,size_t i) {
    RCEntry *e=c->entries+i;
    if(!e->path)return;
    c->bytes-=strlen(e->path)+1+e->length+1;
    RCWipe(e->body,e->length+1);free(e->body);free(e->path);memset(e,0,sizeof(*e));
}
void RCClear(RCCache *c) {
    size_t i;if(!c)return;for(i=0;i<RC_SLOTS;++i)RCDrop(c,i);
    c->owner[0]=0;c->clock=0;++c->epoch;
}
int RCBind(RCCache *c,const char *owner) {
    size_t n;if(!c || !owner || !(n=strlen(owner)) || n>=sizeof(c->owner))return 0;
    if(strcmp(c->owner,owner)){RCClear(c);memcpy(c->owner,owner,n+1);}return 1;
}
static int RCPath(const char *path) {return path && path[0]=='/' && strlen(path)<=1024 && !strpbrk(path,"\r\n");}
static unsigned long RCClock(RCCache *c) {
    size_t i;
    /* Keep recency comparisons ordered across unsigned-long rollover. */
    if(c->clock==(unsigned long)-1){for(i=0;i<RC_SLOTS;++i)c->entries[i].used=0;c->clock=0;}
    return ++c->clock;
}
int RCGet(RCCache *c,const char *path,unsigned char **body,size_t *length) {
    size_t i;unsigned char *copy;
    if(!body || !length)return 0;
    *body=NULL;*length=0;
    if(!c || !c->owner[0] || !RCPath(path))return 0;
    for(i=0;i<RC_SLOTS;++i)if(c->entries[i].path && !strcmp(c->entries[i].path,path)) {
        RCEntry *e=c->entries+i;copy=malloc(e->length+1);if(!copy)return -1;
        memcpy(copy,e->body,e->length+1);e->used=RCClock(c);++c->hits;*body=copy;*length=e->length;return 1;
    }
    ++c->misses;return 0;
}
void RCForget(RCCache *c,const char *path) {
    size_t i;if(!c || !path)return;
    for(i=0;i<RC_SLOTS;++i)if(c->entries[i].path && !strcmp(c->entries[i].path,path))RCDrop(c,i);
}
int RCPut(RCCache *c,unsigned long epoch,const char *path,const void *body,size_t length) {
    size_t i,slot=RC_SLOTS,oldest=0,charge,n;char *name;unsigned char *copy;
    if(!c || !c->owner[0] || c->epoch!=epoch || !RCPath(path) || !body || length>RC_ENTRY_BYTES)return 0;
    n=strlen(path)+1;charge=n+length+1;if(charge>RC_BYTES)return 0;
    name=malloc(n);copy=malloc(length+1);
    if(!name || !copy){free(name);free(copy);return 0;}
    memcpy(name,path,n);memcpy(copy,body,length);copy[length]=0;
    RCForget(c,path);
    for(;;) {
        slot=RC_SLOTS;oldest=RC_SLOTS;
        for(i=0;i<RC_SLOTS;++i) {
            if(!c->entries[i].path){if(slot==RC_SLOTS)slot=i;}
            else if(oldest==RC_SLOTS || c->entries[i].used<c->entries[oldest].used)oldest=i;
        }
        if(slot!=RC_SLOTS && c->bytes<=RC_BYTES-charge)break;
        if(oldest==RC_SLOTS){free(name);RCWipe(copy,length+1);free(copy);return 0;}
        RCDrop(c,oldest);
    }
    c->entries[slot].path=name;c->entries[slot].body=copy;c->entries[slot].length=length;
    c->entries[slot].used=RCClock(c);c->bytes+=charge;return 1;
}
