#include "GitEditMac.h"
#include "GitWorkMac.h"
#include <Errors.h>
#include <Script.h>
#include <stdlib.h>
#include <string.h>
#include <stdio.h>

void GEFileInit(GEFile *f) { memset(f, 0, sizeof(*f)); }
static int GEError(GEFile *f, OSErr e) {
    f->lastError = e;
    return e == fnfErr || e == dirNFErr ? GS_NOT_FOUND : GS_IO;
}
static int GECatalogSame(const GFCatalog *a, const GFCatalog *b) {
    return a->id == b->id && (a->attributes & ~0x8cU) == (b->attributes & ~0x8cU) &&
           a->created == b->created && a->modified == b->modified && a->backup == b->backup &&
           a->dataLength == b->dataLength && a->resourceLength == b->resourceLength &&
           !memcmp(a->finderInfo, b->finderInfo, 32);
}
static int GEIdentity(const void *data, size_t n, const void *resource, size_t rn,
                      const unsigned char info[32], GCFile *out) {
    int result;
    memset(out, 0, sizeof(*out)); out->present = 1;
    memcpy(out->finderInfo, info, 32);
    out->finderInfo[8] &= (unsigned char)~1U;
    memset(out->finderInfo + 10, 0, 6); memset(out->finderInfo + 28, 0, 4);
    result = GBObjectID("blob", data, n, out->dataOID);
    if (!result) result = GBObjectID("blob", resource, rn, out->resourceOID);
    return result;
}
int GEFileFree(GEFile *f) {
    int result, other;
    if (!f) return GB_BAD;
    result = GFUnlockFile(&f->temporaryHold, &f->lastError);
    other = GFUnlockFile(&f->originalHold, &f->lastError);
    if (!result) result = other;
    if (result) return result;
    free(f->data); free(f->resource); GEFileInit(f); return 0;
}
int GEFileOpen(GEFile *out, const FSSpec *spec) {
    GEFile f;
    GFCatalog after, parent;
    unsigned char info[32];
    size_t i;
    int result;
    if (!out || !spec || out->ready || out->data || out->resource ||
        out->originalHold.haveData || out->originalHold.haveResource ||
        out->temporaryHold.haveData || out->temporaryHold.haveResource || out->haveTemporary ||
        !spec->name[0] || spec->name[0] > 31) return GB_BAD;
    for (i = 1; i <= spec->name[0]; ++i)
        if (!spec->name[i] || spec->name[i] == ':') return GB_BAD;
    GEFileInit(&f); f.file = *spec;
    result = GFDirectoryAt(spec->vRefNum, spec->parID, &parent, &f.lastError);
    if (!result && !(parent.attributes & 16)) result = GS_CONFLICT;
    if (result) { out->lastError = f.lastError; return result; }
    result = GFCatalogRead(spec, &f.catalog, &f.lastError);
    if (result == GS_NOT_FOUND && f.lastError == fnfErr) result = 0;
    else if (!result) {
        f.present = 1;
        if ((f.catalog.attributes & 17) || (f.catalog.finderInfo[8] & 0x80))
            result = GI_UNSUPPORTED;
        if (!result) result = GWReadFileLimit(spec, &f.data, &f.length, info,
                                              &f.resource, &f.resourceLength, GE_DISK_LIMIT);
        if (!result) result = GFCatalogRead(spec, &after, &f.lastError);
        if (!result && (!GECatalogSame(&f.catalog, &after) || f.length != after.dataLength ||
                        f.resourceLength != after.resourceLength)) result = GS_CONFLICT;
        if (!result) result = GEIdentity(f.data, f.length, f.resource, f.resourceLength,
                                         f.catalog.finderInfo, &f.identity);
    }
    if (result) {
        out->lastError = f.lastError; free(f.data); free(f.resource); return result;
    }
    f.ready = 1; *out = f; return 0;
}
static int GEReadIdentity(const FSSpec *spec, GCFile *identity, GFCatalog *catalog, OSErr *last) {
    GEFile checked;
    int result;
    GEFileInit(&checked); result = GEFileOpen(&checked, spec);
    if (!result && !checked.present) result = GS_NOT_FOUND;
    if (!result) { *identity = checked.identity; *catalog = checked.catalog; }
    *last = checked.lastError;
    GEFileFree(&checked); return result;
}
static int GEWrite(GEFile *f, short ref, const unsigned char *bytes, size_t n) {
    size_t done = 0, request;
    long count;
    OSErr e;
    while (done < n) {
        request = n - done > 32768 ? 32768 : n - done;
        count = (long)request; e = FSWrite(ref, &count, bytes + done);
        if (e) return GEError(f, e);
        if (count <= 0 || (size_t)count > request) return GS_IO;
        done += (size_t)count;
    }
    e = SetEOF(ref, (long)n);
    return e ? GEError(f, e) : 0;
}
static int GETemporary(GEFile *f) {
    static unsigned long serial;
    unsigned attempt;
    char name[32];
    OSErr e;
    GFCatalog cat;
    int result;
    f->temporary = f->file;
    for (attempt = 0; attempt < 256; ++attempt) {
        sprintf(name, "GHClient Save %08lx", ++serial);
        f->temporary.name[0] = (unsigned char)strlen(name);
        memcpy(f->temporary.name + 1, name, strlen(name));
        e = FSpCreate(&f->temporary, 'ttxt', 'TEXT', smSystemScript);
        if (e == dupFNErr) continue;
        if (e) return GEError(f, e);
        f->haveTemporary = 1;
        result = GFCatalogRead(&f->temporary, &cat, &f->lastError);
        if (result) return result;
        f->temporaryID = cat.id;
        f->temporaryHold.file = f->temporary;
        e = FSpOpenDF(&f->temporary, fsWrPerm, &f->temporaryHold.dataRef);
        if (!e) {
            f->temporaryHold.haveData = 1;
            e = FSpOpenRF(&f->temporary, fsWrPerm, &f->temporaryHold.resourceRef);
            if (!e) f->temporaryHold.haveResource = 1;
        }
        return e ? GEError(f, e) : 0;
    }
    return GS_CONFLICT;
}
static int GEPrepare(GEFile *f, const void *bytes, size_t n, GCFile *desired) {
    CInfoPBRec pb;
    GFCatalog cat, verified;
    int result;
    OSErr e;
    result = GETemporary(f);
    if (!result) result = GEWrite(f, f->temporaryHold.dataRef, (const unsigned char *)bytes, n);
    if (!result) result = GEWrite(f, f->temporaryHold.resourceRef, f->resource, f->resourceLength);
    if (result) return result;
    memset(&pb, 0, sizeof(pb)); pb.hFileInfo.ioNamePtr = f->temporary.name;
    pb.hFileInfo.ioVRefNum = f->temporary.vRefNum; pb.hFileInfo.ioDirID = f->temporary.parID;
    e = PBGetCatInfoSync(&pb);
    if (!e && f->present) {
        memcpy(&pb.hFileInfo.ioFlFndrInfo, f->catalog.finderInfo, 16);
        memcpy(&pb.hFileInfo.ioFlXFndrInfo, f->catalog.finderInfo + 16, 16);
        pb.hFileInfo.ioFlCrDat = f->catalog.created;
        pb.hFileInfo.ioFlBkDat = f->catalog.backup;
        /* The prepared content's modification date is retained. */
        pb.hFileInfo.ioDirID = f->temporary.parID;
        e = PBSetCatInfoSync(&pb);
    }
    if (e) return GEError(f, e);
    result = GFCatalogRead(&f->temporary, &cat, &f->lastError);
    if (!result && (cat.id != f->temporaryID || (cat.attributes & 17) ||
                    (cat.finderInfo[8] & 0x80) || cat.dataLength != n ||
                    cat.resourceLength != f->resourceLength)) result = GS_CONFLICT;
    if (!result && f->present && (memcmp(cat.finderInfo, f->catalog.finderInfo, 32) ||
                                  cat.created != f->catalog.created || cat.backup != f->catalog.backup))
        result = GS_CONFLICT;
    if (!result) result = GEIdentity(bytes, n, f->resource, f->resourceLength, cat.finderInfo, desired);
    if (!result) {
        f->temporaryHold.catalog = cat; f->temporaryHold.identity = *desired;
        result = GFRecheckFile(&f->temporaryHold, &verified, &f->lastError);
    }
    return result;
}
int GEFileSave(GEFile *f, const GSMacStore *database, const void *bytes, size_t n) {
    GFCatalog current, saved, backup;
    GCFile desired, identity;
    OSErr e;
    int result, closed, other;
    if (!f || !f->ready || !database || !database->leaseHeld || (!bytes && n)) return GB_BAD;
    if (n > GE_DISK_LIMIT) return GB_SPACE;
    if (f->present && n == f->length && (!n || !memcmp(bytes, f->data, n))) return 0;
    f->ready = 0; f->lastError = noErr;
    if (f->present) result = GFLockFile(&f->file, &f->identity, &f->catalog,
                                       &f->originalHold, &f->lastError);
    else {
        result = GFCatalogRead(&f->file, &current, &f->lastError);
        if (!result) result = GS_CONFLICT;
        else if (result == GS_NOT_FOUND && f->lastError == fnfErr) result = 0;
    }
    if (!result) result = GEPrepare(f, bytes, n, &desired);
    if (!result) {
        e = FlushVol(NULL, f->file.vRefNum);
        if (e) result = GEError(f, e);
    }
    if (!result && f->present) result = GFRecheckFile(&f->originalHold, &current, &f->lastError);
    if (!result) {
        f->phase = GE_ATTEMPTED;
        e = f->present ? FSpExchangeFiles(&f->temporary, &f->file)
                       : FSpRename(&f->temporary, f->file.name);
        if (e) result = GEError(f, e);
        else {
            f->phase = GE_PUBLISHED;
            if (!f->present) f->haveTemporary = 0;
        }
    }
    /* Exchange updates open FCBs: access paths now follow their data into the
       opposite file. Close both sets; never use the old spec/catalog to rehash. */
    closed = GFUnlockFile(&f->temporaryHold, &f->lastError);
    other = GFUnlockFile(&f->originalHold, &f->lastError);
    if (!closed) closed = other;
    if (!result) result = closed;
    if (!result) result = GEReadIdentity(&f->file, &identity, &saved, &f->lastError);
    if (!result && (!GCFileEqual(&identity, &desired) || saved.id !=
                    (f->present ? f->catalog.id : f->temporaryID))) result = GS_CONFLICT;
    if (!result && f->present && (saved.created != f->catalog.created ||
        saved.backup != f->catalog.backup || memcmp(saved.finderInfo, f->catalog.finderInfo, 32)))
        result = GS_CONFLICT;
    if (!result) {
        e = FlushVol(NULL, f->file.vRefNum);
        if (e) result = GEError(f, e);
    }
    if (!result && f->present) {
        result = GEReadIdentity(&f->temporary, &identity, &backup, &f->lastError);
        if (!result && (backup.id != f->temporaryID || !GCFileEqual(&identity, &f->identity) ||
            backup.created != f->catalog.created || backup.modified != f->catalog.modified ||
            backup.backup != f->catalog.backup || memcmp(backup.finderInfo, f->catalog.finderInfo, 32)))
            result = GS_CONFLICT;
        if (!result) {
            e = FSpDelete(&f->temporary);
            if (e) result = GEError(f, e); else f->haveTemporary = 0;
        }
    }
    if (!result) {
        e = FlushVol(NULL, f->file.vRefNum);
        if (e) result = GEError(f, e);
    }
    if (!result) f->phase = GE_SAVED;
    return result;
}
