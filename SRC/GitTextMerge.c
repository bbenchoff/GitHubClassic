#include "GitTextMerge.h"
#include <stdlib.h>
#include <string.h>

typedef struct {
    GMTextResult result;
    const GMTextLimits *limits;
    GDProgress progress;
    void *context;
    size_t capacity, conflictCapacity;
    char newline;
} GMTextWork;
void GMTextInit(GMTextResult *r) { memset(r, 0, sizeof(*r)); }
void GMTextFree(GMTextResult *r) {
    free(r->bytes); free(r->conflicts); GMTextInit(r);
}
static int GMTick(GMTextWork *w) { return w->progress ? w->progress(w->context) : 0; }
static int GMEqual(const unsigned char *a, size_t an, const unsigned char *b, size_t bn) {
    return an == bn && (!an || !memcmp(a, b, an));
}
static int GMAppend(GMTextWork *w, const void *bytes, size_t length) {
    size_t wanted, cap;
    unsigned char *grown;
    int error = GMTick(w);
    if (error) return error;
    if (length > w->limits->outputBytes - w->result.length) return GB_SPACE;
    wanted = w->result.length + length + 1;
    if (wanted > w->capacity) {
        cap = w->capacity ? w->capacity : 256;
        while (cap < wanted) cap *= 2;
        if (cap > w->limits->outputBytes + 1) cap = w->limits->outputBytes + 1;
        grown = (unsigned char *)realloc(w->result.bytes, cap);
        if (!grown) return GB_MEMORY;
        w->result.bytes = grown; w->capacity = cap;
    }
    if (length) memcpy(w->result.bytes + w->result.length, bytes, length);
    w->result.length += length; w->result.bytes[w->result.length] = 0;
    return 0;
}
static int GMRecord(GMTextWork *w, const GMTextConflict *conflict) {
    size_t cap;
    GMTextConflict *grown;
    if (w->result.count == w->limits->conflicts) return GB_SPACE;
    if (w->result.count == w->conflictCapacity) {
        cap = w->conflictCapacity ? w->conflictCapacity * 2 : 8;
        if (cap > w->limits->conflicts) cap = w->limits->conflicts;
        grown = (GMTextConflict *)realloc(w->result.conflicts, cap * sizeof(*grown));
        if (!grown) return GB_MEMORY;
        w->result.conflicts = grown; w->conflictCapacity = cap;
    }
    w->result.conflicts[w->result.count++] = *conflict;
    return 0;
}
static int GMLineStart(GMTextWork *w) {
    unsigned char last;
    if (!w->result.length) return 0;
    last = w->result.bytes[w->result.length - 1];
    return last == '\r' || last == '\n' ? 0 : GMAppend(w, &w->newline, 1);
}
static int GMMarker(GMTextWork *w, const char *text) {
    int error = GMLineStart(w);
    if (!error) error = GMAppend(w, text, strlen(text));
    if (!error) error = GMAppend(w, &w->newline, 1);
    return error;
}
/* Move a side cursor over a whole union cluster, validating shared-diff offsets.
   Unchanged gaps in a valid script have identical byte lengths on both sides. */
static int GMAdvance(const GDEditScript *script, size_t first, size_t last,
                         size_t start, size_t end, size_t side, size_t total, size_t *out) {
    size_t i, at = start, gap;
    const GDEdit *e;
    for (i = first; i < last; ++i) {
        e = script->edits + i;
        if (e->oldStart < at || e->oldEnd < e->oldStart || e->oldEnd > end ||
            e->newEnd < e->newStart || e->newEnd > total) return GB_BAD;
        gap = e->oldStart - at;
        if (side > total || gap > total - side || side + gap != e->newStart) return GB_BAD;
        side = e->newEnd; at = e->oldEnd;
    }
    gap = end - at;
    if (side > total || gap > total - side) return GB_BAD;
    *out = side + gap; return 0;
}
static int GMConflict(GMTextWork *w, GMTextConflict *c, const unsigned char *base,
                         const unsigned char *current, const unsigned char *other) {
    int error = GMLineStart(w);
    if (error) return error;
    c->outputStart = w->result.length;
    error = GMMarker(w, "<<<<<<< CURRENT");
    if (!error) error = GMAppend(w, current + c->currentStart, c->currentEnd - c->currentStart);
    if (!error) error = GMMarker(w, "||||||| BASE");
    if (!error) error = GMAppend(w, base + c->baseStart, c->baseEnd - c->baseStart);
    if (!error) error = GMMarker(w, "=======");
    if (!error) error = GMAppend(w, other + c->otherStart, c->otherEnd - c->otherStart);
    if (!error) error = GMMarker(w, ">>>>>>> OTHER");
    c->outputEnd = w->result.length;
    if (!error) error = GMRecord(w, c);
    return error;
}
int GMTextMerge(const void *original, size_t bn, const void *ours, size_t cn,
                  const void *theirs, size_t on, char newline, const GMTextLimits *limits,
                  GDProgress progress, void *context, GMTextResult *destination) {
    static const unsigned char empty[1] = {0};
    const unsigned char *base = original ? (const unsigned char *)original : empty;
    const unsigned char *current = ours ? (const unsigned char *)ours : empty;
    const unsigned char *other = theirs ? (const unsigned char *)theirs : empty;
    GDEditScript c, o;
    GMTextWork w;
    GMTextConflict conflict;
    size_t ci = 0, oi = 0, cf, of, bpos = 0, cpos = 0, opos = 0;
    size_t start, end, gap, ce, oe, oldci, oldoi;
    int error;
    if (!destination || !limits || (!original && bn) || (!ours && cn) || (!theirs && on) ||
        bn > 2UL * 1024 * 1024 || cn > 2UL * 1024 * 1024 || on > 2UL * 1024 * 1024 ||
        limits->outputBytes > 16UL * 1024 * 1024 || limits->conflicts > 8192 ||
        (newline != '\r' && newline != '\n')) return GB_BAD;
    memset(&w, 0, sizeof(w)); GDEditsInit(&c); GDEditsInit(&o);
    w.limits = limits; w.progress = progress; w.context = context; w.newline = newline;
    error = GMTick(&w); if (error) goto done;
    w.result.binary = (bn && memchr(base, 0, bn)) || (cn && memchr(current, 0, cn)) ||
                      (on && memchr(other, 0, on));
    if (GMEqual(current, cn, other, on) || GMEqual(base, bn, other, on)) {
        error = GMAppend(&w, current, cn); goto publish;
    }
    if (GMEqual(base, bn, current, cn)) { error = GMAppend(&w, other, on); goto publish; }
    if (w.result.binary) {
        memset(&conflict, 0, sizeof(conflict));
        conflict.baseEnd = bn; conflict.currentEnd = cn; conflict.otherEnd = on;
        error = GMRecord(&w, &conflict); goto publish;
    }
    error = GDComputeEdits(base, bn, current, cn, progress, context, &c);
    if (!error) error = GDComputeEdits(base, bn, other, on, progress, context, &o);
    if (error) goto done;
    w.result.coarse = c.coarse || o.coarse;
    while (ci < c.count || oi < o.count) {
        error = GMTick(&w); if (error) goto done;
        start = oi == o.count || (ci < c.count && c.edits[ci].oldStart <= o.edits[oi].oldStart) ?
            c.edits[ci].oldStart : o.edits[oi].oldStart;
        gap = start - bpos;
        if (cpos > cn || gap > cn - cpos || opos > on || gap > on - opos) { error = GB_BAD; goto done; }
        error = GMAppend(&w, base + bpos, gap); if (error) goto done;
        cpos += gap; opos += gap; cf = ci; of = oi; end = start;
        do {
            oldci = ci; oldoi = oi;
            while (ci < c.count && c.edits[ci].oldStart <= end) {
                if (end < c.edits[ci].oldEnd) end = c.edits[ci].oldEnd;
                ++ci;
            }
            while (oi < o.count && o.edits[oi].oldStart <= end) {
                if (end < o.edits[oi].oldEnd) end = o.edits[oi].oldEnd;
                ++oi;
            }
        } while (ci != oldci || oi != oldoi);
        error = GMAdvance(&c, cf, ci, start, end, cpos, cn, &ce);
        if (!error) error = GMAdvance(&o, of, oi, start, end, opos, on, &oe);
        if (error) goto done;
        if (GMEqual(current + cpos, ce - cpos, other + opos, oe - opos) ||
            GMEqual(base + start, end - start, other + opos, oe - opos))
            error = GMAppend(&w, current + cpos, ce - cpos);
        else if (GMEqual(base + start, end - start, current + cpos, ce - cpos))
            error = GMAppend(&w, other + opos, oe - opos);
        else {
            memset(&conflict, 0, sizeof(conflict));
            conflict.baseStart = start; conflict.baseEnd = end;
            conflict.currentStart = cpos; conflict.currentEnd = ce;
            conflict.otherStart = opos; conflict.otherEnd = oe;
            error = GMConflict(&w, &conflict, base, current, other);
        }
        if (error) goto done;
        bpos = end; cpos = ce; opos = oe;
    }
    gap = bn - bpos;
    if (cpos > cn || gap != cn - cpos || opos > on || gap != on - opos) { error = GB_BAD; goto done; }
    error = GMAppend(&w, base + bpos, gap);
publish:
    if (!error) {
        error = GMTick(&w);
        if (!error) { GMTextFree(destination); *destination = w.result; GMTextInit(&w.result); }
    }
done:
    GDEditsFree(&c); GDEditsFree(&o); GMTextFree(&w.result); return error;
}
