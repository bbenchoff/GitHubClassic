#include "GitRebaseState.h"
#include <stdlib.h>
#include <string.h>

void RZInit(RZState *s){memset(s,0,sizeof(*s));}
void RZFree(RZState *s) {
    size_t i;free(s->branch);free(s->ontoRef);free(s->committer);free(s->seconds);free(s->zone);
    for(i=0;i<5;++i)free(s->before[i].bytes);
    free(s->commits);free(s->receipts);free(s->proofs);MSChoicesFree(&s->choices);free(s->original);RZInit(s);
}
static int RZZero(const unsigned char *p,size_t n){size_t i;for(i=0;i<n;++i)if(p[i])return 0;return 1;}
static int RZLimitsOK(const RZLimits *l) {
    return l && l->records.bytes && l->records.bytes<=16777216UL && l->records.pathBytes && l->records.pathBytes<=4096 &&
        l->records.choices<=65536UL && l->records.files<=65535UL && l->steps && l->steps<=4096 && l->nodes && l->nodes<=65536UL;
}
static int RZText(const char *p,size_t max) {
    size_t i;if(!p || !*p)return 0;
    for(i=0;p[i];++i)if(i>=max || (unsigned char)p[i]<32 || (unsigned char)p[i]==127)return 0;
    return 1;
}
static int RZTime(const char *s,const char *z) {
    size_t i,n;if(!s || !z)return 0;n=strlen(s);
    if(!n || n>19 || (n>1 && s[0]=='0') || (n==19 && strcmp(s,"9223372036854775807")>0) || strlen(z)!=5 || (z[0]!='+' && z[0]!='-'))return 0;
    for(i=0;i<n;++i)if(s[i]<'0' || s[i]>'9')return 0;
    for(i=1;i<5;++i)if(z[i]<'0' || z[i]>'9')return 0;
    return (z[1]-'0')*10+z[2]-'0'<=23 && (z[3]-'0')*10+z[4]-'0'<=59;
}
static int RZRef(const MSBytes *b,const char *ref,const unsigned char tip[20]) {
    char hex[41];size_t n=strlen(ref);GBOIDFormat(tip,hex);
    return b->present && b->length==n+42 && !memcmp(b->bytes,ref,n+1) && !memcmp(b->bytes+n+1,hex,40) && b->bytes[n+41]=='\n';
}
static int RZOrder(const void *a,const void *b){return memcmp(a,b,20);}
static int RZChoiceShape(const MSChoices *choices,const RZLimits *l) {
    size_t i,j,files=0;char metadataPath[96];const MSChoice *c;const MSFile *f;
    if(!RZLimitsOK(l) || !choices || RZZero(choices->planID,20) || choices->count>l->records.choices || (choices->count && !choices->items))return GB_BAD;
    for(i=0;i<choices->count;++i) {
        c=choices->items+i;if(c->node>=l->nodes || (i && c->node<=choices->items[i-1].node) || c->count>l->records.files-files || (c->count && !c->files))return GB_BAD;files+=c->count;
        for(j=0;j<c->count;++j) {
            f=c->files+j;
            if(!RZText(f->path,l->records.pathBytes) || GIMacMetadataPath(f->path,metadataPath) || (j && strcmp(c->files[j-1].path,f->path)>=0) ||
               (f->mode!=0100644 && f->mode!=0100755 && f->mode!=0120000 && f->mode!=0160000) || RZZero(f->dataOID,20) ||
               ((f->mode&0170000)!=0100000 && !RZZero(f->metadataOID,20)))return GB_BAD;
        }
    }
    return 0;
}
static int RZShape(const RZState *s,const RZLimits *l,GPEqual eq,void *ctx) {
    size_t i,n,total=0;unsigned char (*sorted)[20];const MSBytes *b;const RRItem *r;GIIndex index;GPMap map;int error=0;
    if(!s || !RZLimitsOK(l) || !eq || !RZText(s->branch,l->records.pathBytes) || !GSValidRef(s->branch) ||
       !RZText(s->ontoRef,l->records.pathBytes) || (!GSValidRef(s->ontoRef) && !GSValidTrackingRef(s->ontoRef)) || !strcmp(s->branch,s->ontoRef) ||
       !RZText(s->committer,1024) || !RZTime(s->seconds,s->zone) || (s->newline!='\r' && s->newline!='\n') ||
       !s->generation || s->revision<s->generation || RZZero(s->binding,32) || RZZero(s->head,20) || RZZero(s->onto,20) || RZZero(s->tip,20) ||
       !memcmp(s->head,s->onto,20) || RZZero(s->planID,20) || memcmp(s->planID,s->choices.planID,20) || !s->count || s->count>l->steps || s->completed>=s->count ||
       !s->commits || (s->completed && (!s->receipts || !s->proofs)) || s->choices.count>l->records.choices || (s->choices.count && !s->choices.items))return GB_BAD;
    for(i=0;i<5;++i){b=s->before+i;if((b->present!=0 && b->present!=1) || (!b->present && b->length) || (b->present && !b->bytes) || b->length>l->records.bytes-total)return GB_BAD;total+=b->length;}
    n=strlen(s->branch);b=s->before;
    if(!b->present || b->length!=n+6 || memcmp(b->bytes,"ref: ",5) || memcmp(b->bytes+5,s->branch,n) || b->bytes[n+5]!='\n' ||
       !RZRef(b+1,s->branch,s->head) || !RZRef(b+4,s->ontoRef,s->onto) || !b[2].present)return GS_FORMAT;
    GIInit(&index);GPInit(&map);error=GIParse(b[2].bytes,b[2].length,&index);
    for(i=0;!error && i<index.count;++i)if((index.entries[i].flags&0x3000) || (index.entries[i].extended&0x6000))error=GI_UNMERGED;
    if(!error && b[3].present)error=GPParse(b[3].bytes,b[3].length,eq,ctx,&map);
    GIFree(&index);GPFree(&map);if(error)return error;
    sorted=(unsigned char (*)[20])malloc(s->count*20);if(!sorted)return GB_MEMORY;
    memcpy(sorted,s->commits,s->count*20);qsort(sorted,s->count,20,RZOrder);
    for(i=0;i<s->count;++i)if(RZZero(sorted[i],20) || !memcmp(sorted[i],s->onto,20) || (i && !memcmp(sorted[i-1],sorted[i],20))){error=GB_BAD;break;}
    free(sorted);if(error)return error;
    if(memcmp(s->commits[s->count-1],s->head,20) || memcmp(s->tip,s->completed?s->receipts[s->completed-1].tip:s->onto,20))return GS_FORMAT;
    for(i=0;i<s->completed;++i) {
        r=s->receipts+i;
        if(memcmp(r->candidate,s->commits[i],20) || RZZero(r->tip,20) || r->kind<RS_APPLY || r->kind>RS_DROP_EMPTY || r->droppedSignatures&~3U ||
           (r->kind==RS_DROP_EMPTY && (r->droppedSignatures || memcmp(r->tip,i?s->receipts[i-1].tip:s->onto,20))))return GS_FORMAT;
    }
    return RZChoiceShape(&s->choices,l);
}
int RZStepID(const RSStep *s,const char *branch,const char *ontoRef,unsigned char id[20]) {
    MMPlan p;unsigned char core[20];GBSHA1 hash;int result;
    if(!s || !id || s->kind!=RS_CONFLICT || !s->merge.conflicts || !branch || !ontoRef || !GSValidRef(branch) ||
        (!GSValidRef(ontoRef) && !GSValidTrackingRef(ontoRef)))return GB_BAD;
    memset(&p,0,sizeof(p));p.kind=MM_CONFLICT;p.branch=(char *)branch;p.otherRef=(char *)ontoRef;
    memcpy(p.tips,s->candidate,20);memcpy(p.tips+20,s->onto,20);memcpy(p.trees,s->trees,60);p.haveBase=1;p.newline=s->merge.newline;p.files=s->merge;
    result=MSPlanID(&p,core);if(result)return result;
    GBSHA1Start(&hash);GBSHA1Update(&hash,"GHClient replay conflict 1",sizeof("GHClient replay conflict 1")-1);GBSHA1Update(&hash,core,20);GBSHA1Finish(&hash,id);return 0;
}

/* One bounded transfer routine: measure, encode, or decode into new ownership. */
typedef struct {unsigned char *p;size_t at,length;int mode,error;const RZLimits *limits;} RZWire;
static void RZFixed(RZWire *w,void *p,size_t n) {
    if(w->error)return;if(n>w->length-w->at){w->error=w->mode==2?GS_FORMAT:GB_SPACE;return;}
    if(w->mode==1 && n)memcpy(w->p+w->at,p,n);else if(w->mode==2 && n)memcpy(p,w->p+w->at,n);w->at+=n;
}
static void RZWord(RZWire *w,GBWord *v) {
    unsigned char raw[4];if(w->mode!=2){raw[0]=(unsigned char)(*v>>24);raw[1]=(unsigned char)(*v>>16);raw[2]=(unsigned char)(*v>>8);raw[3]=(unsigned char)*v;}
    RZFixed(w,raw,4);if(w->mode==2 && !w->error)*v=((GBWord)raw[0]<<24)|((GBWord)raw[1]<<16)|((GBWord)raw[2]<<8)|raw[3];
}
static void RZField(RZWire *w,unsigned char **p,size_t *n,size_t textMax) {
    int text=textMax!=0;
    GBWord size=w->mode==2?0:(GBWord)*n;RZWord(w,&size);if(w->error)return;
    if(size>w->length-w->at || (text && (!size || size>textMax || (w->mode==2 && memchr(w->p+w->at,0,size))))){w->error=GS_FORMAT;return;}
    if(w->mode==2){*p=(unsigned char *)malloc(size+(text || !size));if(!*p){w->error=GB_MEMORY;return;}*n=size;}
    RZFixed(w,*p,size);if(w->mode==2 && text)(*p)[size]=0;
}
static void RZString(RZWire *w,char **p,size_t max){size_t n=w->mode==2?0:strlen(*p);RZField(w,(unsigned char **)p,&n,max);}
static void RZChoiceTransfer(RZWire *w,MSChoices *choices) {
    GBWord count=w->mode==2?0:(GBWord)choices->count,value;size_t i,j,total=0;MSChoice *c;MSFile *f;
    RZWord(w,&count);
    if(!w->error && (count>w->limits->records.choices || count>(w->length-w->at)/8))w->error=GS_FORMAT;
    if(w->mode==2 && !w->error && count){choices->items=(MSChoice *)calloc(count,sizeof(*choices->items));if(!choices->items)w->error=GB_MEMORY;else choices->count=count;}
    for(i=0;!w->error && i<count;++i) {
        c=choices->items+i;value=(GBWord)c->node;RZWord(w,&value);if(w->mode==2)c->node=value;value=(GBWord)c->count;RZWord(w,&value);
        if(!w->error && (value>w->limits->records.files-total || value>(w->length-w->at)/49))w->error=GS_FORMAT;
        if(w->mode==2 && !w->error && value){c->files=(MSFile *)calloc(value,sizeof(*c->files));if(!c->files)w->error=GB_MEMORY;else c->count=value;}total+=value;
        for(j=0;!w->error && j<c->count;++j){f=c->files+j;RZString(w,&f->path,w->limits->records.pathBytes);RZWord(w,&f->mode);RZFixed(w,f->dataOID,20);RZFixed(w,f->metadataOID,20);}
    }
}
static void RZTransfer(RZWire *w,RZState *s) {
    GBWord count=0,complete=0,value=0;size_t i;RRItem *r;
    RZWord(w,&s->generation);RZWord(w,&s->revision);if(w->mode!=2)value=(unsigned char)s->newline;RZWord(w,&value);if(w->mode==2 && !w->error){if(value!='\n' && value!='\r')w->error=GS_FORMAT;else s->newline=(char)value;}
    RZString(w,&s->branch,w->limits->records.pathBytes);RZString(w,&s->ontoRef,w->limits->records.pathBytes);RZString(w,&s->committer,1024);RZString(w,&s->seconds,19);RZString(w,&s->zone,5);
    RZFixed(w,s->head,20);RZFixed(w,s->onto,20);RZFixed(w,s->tip,20);RZFixed(w,s->planID,20);RZFixed(w,s->binding,32);
    for(i=0;!w->error && i<5;++i){value=(GBWord)s->before[i].present;RZWord(w,&value);RZField(w,&s->before[i].bytes,&s->before[i].length,0);if(w->mode==2)s->before[i].present=(int)value;if(value>1 || (!value && s->before[i].length))w->error=GS_FORMAT;}
    if(w->mode!=2){count=(GBWord)s->count;complete=(GBWord)s->completed;}RZWord(w,&count);RZWord(w,&complete);
    if(!w->error && (!count || count>w->limits->steps || complete>=count || count>(w->length-w->at)/20))w->error=GS_FORMAT;
    if(w->mode==2 && !w->error){s->commits=(unsigned char (*)[20])calloc(count,20);if(!s->commits)w->error=GB_MEMORY;else s->count=count;}
    if(!w->error)RZFixed(w,s->commits,(size_t)count*20);
    if(!w->error && complete>(w->length-w->at)/48)w->error=GS_FORMAT;
    if(w->mode==2 && !w->error && complete){s->receipts=(RRItem *)calloc(complete,sizeof(*s->receipts));s->proofs=(unsigned char (*)[20])calloc(complete,20);if(!s->receipts || !s->proofs)w->error=GB_MEMORY;else s->completed=complete;}
    for(i=0;!w->error && i<complete;++i){r=s->receipts+i;RZFixed(w,r->tip,20);value=(GBWord)r->kind;RZWord(w,&value);if(w->mode==2){r->kind=(int)value;memcpy(r->candidate,s->commits[i],20);}value=r->droppedSignatures;RZWord(w,&value);if(w->mode==2)r->droppedSignatures=value;RZFixed(w,s->proofs[i],20);}
    RZChoiceTransfer(w,&s->choices);
    if(w->mode==2)memcpy(s->choices.planID,s->planID,20);
}
int RZEncode(const RZState *s,const RZLimits *l,GPEqual eq,void *ctx,unsigned char **out,size_t *n) {
    RZWire w;RZState borrowed;unsigned char *raw,digest[20];GBSHA1 hash;int result;
    if(!out || !n)return GB_BAD;result=RZShape(s,l,eq,ctx);if(result)return result;
    memset(&w,0,sizeof(w));w.length=l->records.bytes;w.limits=l;w.at=8;borrowed=*s;RZTransfer(&w,&borrowed);
    if(w.error)return w.error;if(w.at>l->records.bytes || 20>l->records.bytes-w.at)return GB_SPACE;
    raw=(unsigned char *)malloc(w.at+20);if(!raw)return GB_MEMORY;
    w.p=raw;w.length=w.at;w.at=8;w.mode=1;memcpy(raw,"GHRB0001",8);borrowed=*s;RZTransfer(&w,&borrowed);
    if(w.error){free(raw);return w.error;}GBSHA1Start(&hash);GBSHA1Update(&hash,raw,w.at);GBSHA1Finish(&hash,digest);memcpy(raw+w.at,digest,20);*out=raw;*n=w.at+20;return 0;
}
int RZParse(const void *raw,size_t n,const RZLimits *l,GPEqual eq,void *ctx,RZState *out) {
    const unsigned char *p=(const unsigned char *)raw;RZWire w;RZState next;GBSHA1 hash;unsigned char digest[20];int result;
    if(!raw || !out || !RZLimitsOK(l) || !eq || n<28)return GB_BAD;if(n>l->records.bytes)return GB_SPACE;
    if(memcmp(raw,"GHRB0001",8))return GS_FORMAT;GBSHA1Start(&hash);GBSHA1Update(&hash,raw,n-20);GBSHA1Finish(&hash,digest);if(memcmp(digest,p+n-20,20))return GB_CHECKSUM;
    RZInit(&next);memset(&w,0,sizeof(w));w.p=(unsigned char *)raw;w.at=8;w.length=n-20;w.mode=2;w.limits=l;RZTransfer(&w,&next);result=w.error;
    if(!result && w.at!=w.length)result=GS_FORMAT;if(!result)result=RZShape(&next,l,eq,ctx);
    if(!result){next.original=(unsigned char *)malloc(n);if(!next.original)result=GB_MEMORY;else {memcpy(next.original,raw,n);next.originalLength=n;}}
    if(!result){RZFree(out);*out=next;RZInit(&next);}RZFree(&next);return result;
}
int RZChoicesEncode(const MSChoices *s,const RZLimits *l,unsigned char **out,size_t *n) {
    RZWire w;MSChoices borrowed;unsigned char *raw,digest[20];GBSHA1 hash;int result;
    if(!out || !n)return GB_BAD;result=RZChoiceShape(s,l);if(result)return result;
    memset(&w,0,sizeof(w));w.length=l->records.bytes;w.limits=l;w.at=28;borrowed=*s;
    if(w.at>w.length)return GB_SPACE;RZChoiceTransfer(&w,&borrowed);
    if(w.error)return w.error;if(20>w.length-w.at)return GB_SPACE;
    raw=(unsigned char *)malloc(w.at+20);if(!raw)return GB_MEMORY;
    w.p=raw;w.length=w.at;w.at=28;w.mode=1;memcpy(raw,"GHRC0001",8);memcpy(raw+8,s->planID,20);borrowed=*s;RZChoiceTransfer(&w,&borrowed);
    if(w.error){free(raw);return w.error;}GBSHA1Start(&hash);GBSHA1Update(&hash,raw,w.at);GBSHA1Finish(&hash,digest);memcpy(raw+w.at,digest,20);*out=raw;*n=w.at+20;return 0;
}
int RZChoicesParse(const void *raw,size_t n,const RZLimits *l,MSChoices *out) {
    const unsigned char *p=(const unsigned char *)raw;RZWire w;MSChoices next;GBSHA1 hash;unsigned char digest[20];int result;
    if(!raw || !out || !RZLimitsOK(l) || n<52)return GB_BAD;if(n>l->records.bytes)return GB_SPACE;
    if(memcmp(raw,"GHRC0001",8))return GS_FORMAT;GBSHA1Start(&hash);GBSHA1Update(&hash,raw,n-20);GBSHA1Finish(&hash,digest);if(memcmp(digest,p+n-20,20))return GB_CHECKSUM;
    MSChoicesInit(&next);memcpy(next.planID,p+8,20);memset(&w,0,sizeof(w));w.p=(unsigned char *)raw;w.at=28;w.length=n-20;w.mode=2;w.limits=l;
    RZChoiceTransfer(&w,&next);result=w.error;if(!result && w.at!=w.length)result=GS_FORMAT;if(!result)result=RZChoiceShape(&next,l);
    if(!result){MSChoicesFree(out);*out=next;MSChoicesInit(&next);}MSChoicesFree(&next);return result;
}
