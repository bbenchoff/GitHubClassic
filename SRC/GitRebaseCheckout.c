#include "GitRebaseCheckout.h"
#include "GitCheckoutSession.h"
#include "GitHistory.h"
#include <stdlib.h>
#include <string.h>

typedef struct {GSRepository *source,objects;GOReader reads;size_t stateBytes;GDProgress progress;void *context;} RQIO;
void RQInit(RQReview *r){memset(r,0,sizeof(*r));}
void RQFree(RQReview *r){size_t i;free(r->branch);free(r->ontoRef);for(i=0;i<5;++i)free(r->guards[i].bytes);RBFree(&r->graph);GRFree(&r->original);RQInit(r);}
void RQCheckoutInit(RQCheckout *p){memset(p,0,sizeof(*p));}
void RQCheckoutFree(RQCheckout *p){RRFree(&p->replay);GQFree(&p->checkout);RQCheckoutInit(p);}
static int RQTick(RQIO *io){return io->progress?io->progress(io->context):0;}
static int RQRead(void *context,const char *key,unsigned char **bytes,size_t *n) {
    RQIO *io=(RQIO *)context;int result;*bytes=NULL;*n=0;
    if(!strncmp(key,"objects/",8))return io->objects.read(io->objects.context,key,bytes,n);
    result=RQTick(io);if(!result)result=io->source->read(io->source->context,key,bytes,n);
    if(!result && *n>io->stateBytes)result=GB_SPACE;if(!result)result=RQTick(io);
    if(result){free(*bytes);*bytes=NULL;*n=0;}return result;
}
static int RQWrite(void *context,const char *key,const void *old,size_t on,const void *next,size_t nn) {
    RQIO *io=(RQIO *)context;int result;
    if(strncmp(key,"objects/",8) || old || on)return GB_BAD;
    result=RQTick(io);if(!result)result=io->source->replace(io->source->context,key,NULL,0,next,nn);
    if(!result)result=RQTick(io);return result;
}
static int RQStart(GSRepository *source,const RQLimits *limits,GDProgress progress,void *context,RQIO *io,GSRepository *r) {
    int result;if(!source || !source->read || !source->replace || !limits || !limits->stateBytes)return GB_BAD;
    memset(io,0,sizeof(*io));io->source=source;io->stateBytes=limits->stateBytes;io->progress=progress;io->context=context;
    result=GOReadStart(source,&limits->replay.all,progress,context,&io->reads,&io->objects);
    if(!result){r->context=io;r->read=RQRead;r->replace=RQWrite;}return result;
}
static char *RQString(const char *s){size_t n=strlen(s)+1;char *p=(char *)malloc(n);if(p)memcpy(p,s,n);return p;}
static int RQCapture(GSRepository *r,const char *key,MMGuard *guard,size_t maximum,size_t *used) {
    int result;if(strlen(key)>=sizeof(guard->key))return GB_BAD;strcpy(guard->key,key);
    result=r->read(r->context,key,&guard->bytes,&guard->length);
    if(result==GS_NOT_FOUND)return 0;if(result)return result;
    if(guard->length>maximum-*used)return GB_SPACE;*used+=guard->length;guard->present=1;return 0;
}
static int RQHead(const MMGuard *g,const char *branch) {
    size_t n=strlen(branch);return g->present && g->length==n+6 && !memcmp(g->bytes,"ref: ",5) && !memcmp(g->bytes+5,branch,n) && g->bytes[n+5]=='\n';
}
static int RQRef(const MMGuard *g,const char *name,const unsigned char tip[20]) {
    size_t n=strlen(name);char hex[41];GBOIDFormat(tip,hex);
    return g->present && g->length==n+42 && !memcmp(g->bytes,name,n+1) && !memcmp(g->bytes+n+1,hex,40) && g->bytes[n+41]=='\n';
}
int RQRecheck(GSRepository *source,const RQReview *review) {
    unsigned char *raw=NULL;size_t i,n=0;int result,present;
    if(!source || !source->read || !review)return GB_BAD;result=GTNormalWriteAllowed(source);
    for(i=0;!result && i<5;++i) {
        result=source->read(source->context,review->guards[i].key,&raw,&n);present=!result;
        if(result==GS_NOT_FOUND)result=0;
        if(!result && (present!=review->guards[i].present || (present && (n!=review->guards[i].length || memcmp(raw,review->guards[i].bytes,n)))))result=GS_CONFLICT;
        free(raw);raw=NULL;
    }
    return result;
}
static int RQCleanIndex(const RQReview *review) {
    GIIndex index;size_t i;const GIEntry *a,*b;int result;
    if(!review->guards[2].present)return GS_CONFLICT;GIInit(&index);
    result=GIParse(review->guards[2].bytes,review->guards[2].length,&index);
    if(!result && index.count!=review->original.index.count)result=GS_CONFLICT;
    for(i=0;!result && i<index.count;++i) {
        a=index.entries+i;b=review->original.index.entries+i;
        if(strcmp(a->path,b->path) || a->stat[6]!=b->stat[6] || memcmp(a->oid,b->oid,20) || (a->flags&0x3000) || (a->extended&0x6000))result=GS_CONFLICT;
    }
    GIFree(&index);return result;
}
int RQPrepare(GSRepository *source,const char *branch,const unsigned char head[20],const char *ontoRef,const unsigned char onto[20],
    char newline,const RQLimits *limits,GDProgress progress,void *context,RQReview *destination) {
    RQReview *next;RQIO io;GSRepository reader;unsigned char *raw=NULL;size_t n=0;GHCommitInfo info;char type[7],key[64];GIReadLimits traversal;int result;
    if(!branch || !head || !ontoRef || !onto || !destination || !GSValidRef(branch) || (!GSValidRef(ontoRef) && !GSValidTrackingRef(ontoRef)) || (newline!='\n' && newline!='\r'))return GB_BAD;
    result=RQStart(source,limits,progress,context,&io,&reader);if(result)return result;
    if(strlen(branch)>limits->stateBytes || strlen(ontoRef)>limits->stateBytes)return GB_SPACE;
    next=(RQReview *)calloc(1,sizeof(*next));if(!next)return GB_MEMORY;next->limits=*limits;next->newline=newline;
    next->branch=RQString(branch);next->ontoRef=RQString(ontoRef);result=next->branch && next->ontoRef?0:GB_MEMORY;
    if(!result)result=GTNormalWriteAllowed(&reader);
    if(!result)result=RQCapture(&reader,"HEAD",next->guards,limits->stateBytes,&next->stateBytes);
    if(!result)result=GSRefKey(branch,key);if(!result)result=RQCapture(&reader,key,next->guards+1,limits->stateBytes,&next->stateBytes);
    if(!result)result=RQCapture(&reader,"index",next->guards+2,limits->stateBytes,&next->stateBytes);
    if(!result)result=RQCapture(&reader,"ghclient-map",next->guards+3,limits->stateBytes,&next->stateBytes);
    if(!result)result=GSRefKey(ontoRef,key);if(!result)result=RQCapture(&reader,key,next->guards+4,limits->stateBytes,&next->stateBytes);
    if(!result && (!RQHead(next->guards,branch) || !RQRef(next->guards+1,branch,head) || !RQRef(next->guards+4,ontoRef,onto)))result=GS_CONFLICT;
    if(!result)result=RBPrepare(&reader,head,onto,&limits->replay.plan,progress,context,&next->graph);
    if(!result)result=GSGetObject(&reader,head,type,&raw,&n);
    if(!result)result=strcmp(type,"commit")?GS_FORMAT:GHCommitParse(raw,n,&info);
    memset(&traversal,0,sizeof(traversal));traversal.entries=limits->replay.step.entries;traversal.depth=limits->replay.step.depth;
    traversal.pathBytes=limits->replay.step.pathBytes;traversal.progress=progress;traversal.context=context;
    if(!result)result=GRFromTreeBounded(&reader,info.tree,&next->original,&traversal);
    if(!result){next->original.haveCommit=1;memcpy(next->original.commit,head,20);result=RQCleanIndex(next);}
    if(!result)result=RQRecheck(&reader,next);
    if(!result){RQFree(destination);*destination=*next;RQInit(next);}free(raw);RQFree(next);free(next);return result;
}
static int RQBefore(const GCMetadata *m,const MMGuard *g) {
    return m->beforePresent==g->present && m->beforeLength==g->length && (!g->present || !memcmp(m->before,g->bytes,g->length));
}
static int RQSeal(const RQReview *review,GQPlan *plan,const unsigned char tip[20]) {
    size_t i,j;GCMetadata *m,*grown;MMGuard after;
    for(i=0;i<5;++i) {
        for(j=0;j<plan->transaction.metadataCount;++j)if(!strcmp(plan->transaction.metadata[j].path,review->guards[i].key))break;
        if(j==plan->transaction.metadataCount) {
            if(i!=4)return GS_FORMAT;
            if(j>=(size_t)-1/sizeof(*grown))return GB_SPACE;
            grown=(GCMetadata *)realloc(plan->transaction.metadata,(j+1)*sizeof(*grown));if(!grown)return GB_MEMORY;
            plan->transaction.metadata=grown;m=grown+j;memset(m,0,sizeof(*m));++plan->transaction.metadataCount;
            m->path=RQString(review->guards[i].key);m->beforePresent=m->afterPresent=review->guards[i].present;
            m->beforeLength=m->afterLength=review->guards[i].length;
            if(m->beforePresent){m->before=(unsigned char *)malloc(m->beforeLength?m->beforeLength:1);m->after=(unsigned char *)malloc(m->afterLength?m->afterLength:1);
                if(!m->before || !m->after)return GB_MEMORY;memcpy(m->before,review->guards[i].bytes,m->beforeLength);memcpy(m->after,review->guards[i].bytes,m->afterLength);}
            if(!m->path)return GB_MEMORY;
        }
        m=plan->transaction.metadata+j;if(!RQBefore(m,review->guards+i))return GS_CONFLICT;
        after=review->guards[i];after.present=m->afterPresent;after.bytes=m->after;after.length=m->afterLength;
        if(i==0 && !RQHead(&after,review->branch))return GS_CONFLICT;
        if(i==1 && !RQRef(&after,review->branch,tip))return GS_CONFLICT;
        if(i==4 && (after.present!=review->guards[i].present || after.length!=review->guards[i].length || (after.present && memcmp(after.bytes,review->guards[i].bytes,after.length))))return GS_CONFLICT;
    }
    return 0;
}
int RQBuildCheckout(GSRepository *source,const RQReview *review,const GQWork *work,size_t count,GPEqual eq,void *eqContext,
    const char *committer,const char *seconds,const char *zone,GDProgress progress,void *context,RQCheckout *destination,GQError *why) {
    RQCheckout *next;RQIO io;GSRepository reader;GQPlan clean;GQProtection protection;const char **paths=NULL;size_t i;int result;
    if(!review || !review->branch || !review->ontoRef || !destination || !eq || (count && !work))return GB_BAD;
    if(why)memset(why,0,sizeof(*why));result=RQStart(source,&review->limits,progress,context,&io,&reader);if(result)return result;
    next=(RQCheckout *)calloc(1,sizeof(*next));if(!next)return GB_MEMORY;GQInit(&clean);memset(&protection,0,sizeof(protection));
    result=RQRecheck(&reader,review);
    if(!result && (review->graph.kind==RB_MULTIPLE_BASES || review->graph.kind==RB_UNRELATED || review->graph.kind==RB_MERGE_HISTORY))next->kind=RQ_POLICY;
    else if(!result) {
        if(review->original.count>(size_t)-1/sizeof(*paths))result=GB_SPACE;
        if(!result && review->original.count){paths=(const char **)malloc(review->original.count*sizeof(*paths));if(!paths)result=GB_MEMORY;}
        for(i=0;!result && i<review->original.count;++i)paths[i]=review->original.files[i].path;
        protection.paths=paths;protection.count=review->original.count;protection.changed=1;
        if(!result)result=GQToCommitProtected(&reader,review->branch,review->graph.graph.left,review->graph.graph.left,work,count,&protection,eq,eqContext,&clean,why);
        GQFree(&clean);
        if(!result)result=RRReplay(&reader,review->graph.graph.left,review->graph.graph.right,review->newline,&review->limits.replay,committer,seconds,zone,progress,context,&next->replay);
        if(!result && next->replay.kind==RR_CONFLICT)next->kind=RQ_CONFLICT;
        else if(!result && next->replay.kind!=RR_COMPLETE)next->kind=RQ_POLICY;
        else if(!result && !memcmp(next->replay.tip,review->graph.graph.left,20))next->kind=RQ_NO_CHANGE;
        else if(!result) {
            result=GQToCommitProtected(&reader,review->branch,review->graph.graph.left,next->replay.tip,work,count,&protection,eq,eqContext,&next->checkout,why);
            if(!result)result=RQSeal(review,&next->checkout,next->replay.tip);if(!result)next->kind=RQ_READY;
        }
    }
    if(!result)result=RQRecheck(&reader,review);
    if(!result && progress)result=progress(context);
    if(!result){RQCheckoutFree(destination);*destination=*next;RQCheckoutInit(next);}GQFree(&clean);free(paths);RQCheckoutFree(next);free(next);return result;
}
