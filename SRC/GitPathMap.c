#include "GitPathMap.h"
#include <stdlib.h>
#include <string.h>
#include <stdio.h>

/* Unicode values are generated from the standard MacRoman mapping. */
static const unsigned short gpRoman[128] = {
    0xc4,   0xc5,   0xc7,   0xc9,   0xd1,   0xd6,  0xdc,   0xe1,   0xe0,   0xe2,   0xe4,   0xe3,
    0xe5,   0xe7,   0xe9,   0xe8,   0xea,   0xeb,  0xed,   0xec,   0xee,   0xef,   0xf1,   0xf3,
    0xf2,   0xf4,   0xf6,   0xf5,   0xfa,   0xf9,  0xfb,   0xfc,   0x2020, 0xb0,   0xa2,   0xa3,
    0xa7,   0x2022, 0xb6,   0xdf,   0xae,   0xa9,  0x2122, 0xb4,   0xa8,   0x2260, 0xc6,   0xd8,
    0x221e, 0xb1,   0x2264, 0x2265, 0xa5,   0xb5,  0x2202, 0x2211, 0x220f, 0x3c0,  0x222b, 0xaa,
    0xba,   0x3a9,  0xe6,   0xf8,   0xbf,   0xa1,  0xac,   0x221a, 0x192,  0x2248, 0x2206, 0xab,
    0xbb,   0x2026, 0xa0,   0xc0,   0xc3,   0xd5,  0x152,  0x153,  0x2013, 0x2014, 0x201c, 0x201d,
    0x2018, 0x2019, 0xf7,   0x25ca, 0xff,   0x178, 0x2044, 0x20ac, 0x2039, 0x203a, 0xfb01, 0xfb02,
    0x2021, 0xb7,   0x201a, 0x201e, 0x2030, 0xc2,  0xca,   0xc1,   0xcb,   0xc8,   0xcd,   0xce,
    0xcf,   0xcc,   0xd3,   0xd4,   0xf8ff, 0xd2,  0xda,   0xdb,   0xd9,   0x131,  0x2c6,  0x2dc,
    0xaf,   0x2d8,  0x2d9,  0x2da,  0xb8,   0x2dd, 0x2db,  0x2c7};
int GPRomanCharacter(unsigned u) {
    size_t i;
    if (u < 128) return (int)u;
    for (i = 0; i < 128; ++i) if (gpRoman[i] == u) return (int)i+128;
    return -1;
}
unsigned GPRomanUnicode(unsigned char c) {
    return c < 128 ? (unsigned)c : (unsigned)gpRoman[c - 128];
}
int GPDirectGit(const char *input, char **output) {
    size_t i, n = 0, length;
    unsigned u;
    char *p;
    if (!input || !output) return GB_BAD;
    *output = NULL; length = strlen(input);
    if (length > ((size_t)-1 - 1) / 3) return GB_SPACE;
    p = (char *)malloc(length * 3 + 1);
    if (!p)
        return GB_MEMORY;
    for (i = 0; i < length; ++i) {
        u = (unsigned char)input[i];
        if (!u) {
            free(p);
            return GI_UNSUPPORTED;
        }
        if (u == ':') u = '/';
        else if (u == '/') u = ':';
        if (u >= 128)
            u = gpRoman[u - 128];
        if (u < 128)
            p[n++] = (char)u;
        else if (u < 2048) {
            p[n++] = (char)(192 | (u >> 6));
            p[n++] = (char)(128 | (u & 63));
        } else {
            p[n++] = (char)(224 | (u >> 12));
            p[n++] = (char)(128 | ((u >> 6) & 63));
            p[n++] = (char)(128 | (u & 63));
        }
    }
    p[n] = 0;
    *output = p;
    return 0;
}
int GPDirectNative(const char *path, char **output) {
    const unsigned char *p = (const unsigned char *)path;
    unsigned u, next, minimum;
    size_t n = 0, component = 0, i;
    char *native;
    int trailing;
    if (!output) return GB_BAD;
    *output = NULL;
    if (!GIValidPath(path)) return GB_BAD;
    native = (char *)malloc(strlen(path) + 1);
    if (!native) return GB_MEMORY;
    while (*p) {
        u = *p++;
        if (u == '/') { native[n++] = ':'; component = 0; continue; }
        if (u >= 128) {
            if (u >= 194 && u <= 223) { trailing = 1; minimum = 128; u &= 31; }
            else if (u >= 224 && u <= 239) { trailing = 2; minimum = 2048; u &= 15; }
            else { free(native); return GI_UNSUPPORTED; }
            while (trailing--) {
                next = *p;
                if (next < 128 || next > 191) { free(native); return GI_UNSUPPORTED; }
                ++p; u = (u << 6) | (next & 63);
            }
            if (u < minimum || (u >= 0xd800 && u <= 0xdfff)) {
                free(native); return GI_UNSUPPORTED;
            }
            for (i = 0; i < 128 && gpRoman[i] != u; ++i) { }
            if (i == 128) { free(native); return GI_UNSUPPORTED; }
            u = (unsigned)i + 128;
        } else if (u == ':') u = '/';
        if (++component > 31) { free(native); return GI_UNSUPPORTED; }
        native[n++] = (char)u;
    }
    native[n] = 0; *output = native;
    return 0;
}
static char *GPString(const char *p, size_t n) {
    char *s;
    if (n == (size_t)-1) return NULL;
    s = (char *)malloc(n + 1);
    if (s) { memcpy(s, p, n); s[n] = 0; }
    return s;
}
static GBWord GPWord(const unsigned char *p) {
    return ((GBWord)p[0] << 24) | ((GBWord)p[1] << 16) | ((GBWord)p[2] << 8) | p[3];
}
static void GPPut(unsigned char *p, GBWord n) {
    p[0] = (unsigned char)(n >> 24); p[1] = (unsigned char)(n >> 16);
    p[2] = (unsigned char)(n >> 8); p[3] = (unsigned char)n;
}
void GPInit(GPMap *m) { memset(m, 0, sizeof(*m)); }
void GPFree(GPMap *m) {
    size_t i;
    for (i = 0; i < m->count; ++i) { free(m->entries[i].path); free(m->entries[i].native); }
    free(m->entries); free(m->original); GPInit(m);
}
const GPEntry *GPFind(const GPMap *m, const char *path) {
    size_t lo = 0, hi = m->count, mid;
    while (lo < hi) {
        mid = lo + (hi - lo) / 2;
        if (strcmp(m->entries[mid].path, path) < 0) lo = mid + 1; else hi = mid;
    }
    return lo < m->count && !strcmp(m->entries[lo].path, path) ? m->entries + lo : NULL;
}
static int GPOrder(const void *a, const void *b) {
    return strcmp(((const GPEntry *)a)->path, ((const GPEntry *)b)->path);
}
static const char *GPLeaf(const char *path, int native) {
    const char *last = strrchr(path, native ? ':' : '/');
    return last ? last + 1 : path;
}
static size_t GPParentLength(const char *path, int native) {
    const char *leaf = GPLeaf(path, native);
    return leaf == path ? 0 : (size_t)(leaf - path - 1);
}
static int GPMode(GBWord mode) {
    return mode == GP_DIRECTORY || mode == 0100644 || mode == 0100755 ||
           mode == 0120000 || mode == 0160000;
}
static int GPReserved(const char *path) {
    size_t n = strlen(GI_MAC_NAMESPACE);
    return !strncmp(path, GI_MAC_NAMESPACE, n) && (!path[n] || path[n] == '/');
}
static int GPNameValid(const char *name, GPEqual equal, void *ctx) {
    size_t i, n;
    if (!name || !(n = strlen(name)) || n > 31) return 0;
    for (i = 0; i < n; ++i)
        if (name[i] == ':') return 0;
    return !equal(ctx, name, ".") && !equal(ctx, name, "..") &&
           !equal(ctx, name, ".git") && !equal(ctx, name, GI_MAC_NAMESPACE);
}
static int GPReadable(const char *name) {
    const unsigned char *p = (const unsigned char *)name;
    for (; *p; ++p) if (*p < 32 || *p == 127) return 0;
    return 1;
}
static int GPValidate(const GPMap *m, GPEqual equal, void *ctx) {
    size_t i, j, a, b, n, depth, logicalDepth;
    const GPEntry *e, *parent;
    const char *p, *start;
    char leaf[32], *prefix;
    unsigned char zero[72];
    memset(zero, 0, sizeof(zero));
    if (!m || !equal || (m->count && !m->entries)) return GB_BAD;
    for (i = 0; i < m->count; ++i) {
        e = m->entries + i;
        if (!GIValidPath(e->path) || GPReserved(e->path) || !e->native ||
            !GPMode(e->mode) || (e->flags & ~(GP_FORKS | GP_LOCAL)) ||
            ((e->flags & GP_FORKS) && e->mode != 0100644 && e->mode != 0100755) ||
            (i && strcmp(m->entries[i-1].path, e->path) >= 0)) return GS_FORMAT;
        if ((e->flags & GP_LOCAL) && (e->flags != GP_LOCAL || e->mode != 0100644 ||
            memcmp(e->dataOID, zero, 20) || memcmp(e->metadataOID, zero, 20) ||
            memcmp(e->finderInfo, zero, 32))) return GS_FORMAT;
        if (e->mode == GP_DIRECTORY && (e->flags || memcmp(e->dataOID, zero, 20) ||
            memcmp(e->metadataOID, zero, 20) || memcmp(e->finderInfo, zero, 32))) return GS_FORMAT;
        if (!(e->flags & GP_FORKS) && memcmp(e->metadataOID, zero, 20)) return GS_FORMAT;
        depth = logicalDepth = 0;
        for (p = e->path; *p; ++p) if (*p == '/') ++logicalDepth;
        for (p = start = e->native;; ++p) {
            if (*p && *p != ':') continue;
            n = (size_t)(p - start);
            if (!n || n > 31) return GS_FORMAT;
            memcpy(leaf, start, n); leaf[n] = 0;
            if (!GPNameValid(leaf, equal, ctx)) return GS_FORMAT;
            if (!*p) break;
            ++depth; start = p+1;
        }
        if (depth != logicalDepth) return GS_FORMAT;
        a = GPParentLength(e->path, 0); b = GPParentLength(e->native, 1);
        if (a) {
            prefix = GPString(e->path, a);
            if (!prefix) return GB_MEMORY;
            parent = GPFind(m, prefix); free(prefix);
            if (!parent || parent->mode != GP_DIRECTORY || strlen(parent->native) != b ||
                memcmp(parent->native, e->native, b)) return GS_FORMAT;
        } else if (b) return GS_FORMAT;
        /* Compare only sibling leaves using the destination's own collation. */
        for (j = 0; j < i; ++j) {
            p = m->entries[j].path;
            if (GPParentLength(p, 0) == a && !memcmp(p, e->path, a) &&
                equal(ctx, GPLeaf(m->entries[j].native, 1), GPLeaf(e->native, 1))) return GS_CONFLICT;
        }
    }
    return 0;
}
static int GPAppend(GPMap *m, const char *path, size_t n, GBWord mode, GPEntry **entry) {
    GPEntry *e;
    size_t i;
    for (i = 0; i < m->count; ++i)
        if (strlen(m->entries[i].path) == n && !memcmp(m->entries[i].path, path, n)) {
            *entry = m->entries + i;
            return mode == GP_DIRECTORY && (*entry)->mode == mode ? 0 : GS_CONFLICT;
        }
    if (m->count >= (size_t)-1 / sizeof(*e)) return GB_SPACE;
    e = (GPEntry *)realloc(m->entries, (m->count + 1) * sizeof(*e));
    if (!e) return GB_MEMORY;
    m->entries = e; e += m->count; memset(e, 0, sizeof(*e));
    e->path = GPString(path, n);
    if (!e->path) return GB_MEMORY;
    e->mode = mode; ++m->count; *entry = e;
    return 0;
}
static int GPAvailable(const GPMap *m, size_t which, const char *leaf, GPEqual equal, void *ctx) {
    size_t i, n = GPParentLength(m->entries[which].path, 0);
    for (i = 0; i < m->count; ++i)
        if (i != which && m->entries[i].native &&
            GPParentLength(m->entries[i].path, 0) == n &&
            !memcmp(m->entries[i].path, m->entries[which].path, n) &&
            equal(ctx, GPLeaf(m->entries[i].native, 1), leaf)) return 0;
    return GPNameValid(leaf, equal, ctx);
}
static int GPAlias(const GPMap *m, size_t i, GPEqual equal, void *ctx, char **name) {
    const char *logical = GPLeaf(m->entries[i].path, 0);
    unsigned char oid[20];
    GBSHA1 hash;
    GBWord attempt;
    char alias[32], hex[41], counter[16];
    size_t j, n;
    /* The complete raw Git prefix is hashed; readable stem is cosmetic only. */
    for (attempt = 0;; ++attempt) {
        GBSHA1Start(&hash); GBSHA1Update(&hash, m->entries[i].path, strlen(m->entries[i].path));
        if (attempt) {
            sprintf(counter, "#%lu", (unsigned long)attempt);
            GBSHA1Update(&hash, counter, strlen(counter));
        }
        GBSHA1Finish(&hash, oid); GBOIDFormat(oid, hex);
        n = 0;
        for (j = 0; logical[j] && n < 10; ++j) {
            unsigned char c = (unsigned char)logical[j];
            if ((c >= 'a' && c <= 'z') || (c >= 'A' && c <= 'Z') ||
                (c >= '0' && c <= '9') || c == '-' || c == '_') alias[n++] = (char)c;
        }
        if (!n) { memcpy(alias, "file", 4); n = 4; }
        alias[n++] = '~'; memcpy(alias+n, hex, 20); alias[n+20] = 0;
        if (GPAvailable(m, i, alias, equal, ctx)) {
            *name = GPString(alias, n+20); return *name ? 0 : GB_MEMORY;
        }
        if (attempt == 0xffffffffU) return GS_CONFLICT;
    }
}
int GPBuildProtected(const GRSnapshot *snapshot, const GPMap *previous,
                      const GPReservation *reserved, size_t reservedCount,
                      GPEqual equal, void *ctx, GPMap *out) {
    GPMap next;
    GPEntry *e;
    const GPEntry *old, *parent;
    const GRFile *file;
    const char *p, *q, *nativeStart;
    char *name = NULL, *prefix, *full;
    size_t i, n, a, b;
    int result;
    if (!snapshot || !out || !equal || (reservedCount && !reserved)) return GB_BAD;
    if (previous) {
        result = GPValidate(previous, equal, ctx);
        if (result) return result;
    }
    GPInit(&next); memcpy(next.tree, snapshot->tree, 20);
    for (i = 0; i < snapshot->count; ++i) {
        file = snapshot->files + i;
        if (!GIValidPath(file->path) || GPReserved(file->path) || !GPMode(file->mode) ||
            file->mode == GP_DIRECTORY || file->entry >= snapshot->index.count) { result = GS_FORMAT; goto fail; }
        for (p = file->path; *p; ++p) if (*p == '/') {
            result = GPAppend(&next, file->path, (size_t)(p-file->path), GP_DIRECTORY, &e);
            if (result) goto fail;
        }
        result = GPAppend(&next, file->path, strlen(file->path), file->mode, &e);
        if (result) goto fail;
        memcpy(e->dataOID, snapshot->index.entries[file->entry].oid, 20);
        if (file->hasFinderInfo) {
            if (file->metadataEntry >= snapshot->index.count) { result = GS_FORMAT; goto fail; }
            e->flags = GP_FORKS; memcpy(e->metadataOID, snapshot->index.entries[file->metadataEntry].oid, 20);
            memcpy(e->finderInfo, file->finderInfo, 32);
        } else { memset(e->finderInfo, 0, 32); memcpy(e->finderInfo, "????????", 8); }
        e->finderInfo[8] &= (unsigned char)~1U;
        memset(e->finderInfo+10, 0, 6); memset(e->finderInfo+28, 0, 4);
    }
    /* Reserve actual retained names first, including all directory prefixes. */
    for (i = 0; i < reservedCount; ++i) {
        if (!GIValidPath(reserved[i].path) || GPReserved(reserved[i].path) || !reserved[i].native) {
            result = GB_BAD; goto fail;
        }
        p = reserved[i].path; q = nativeStart = reserved[i].native;
        for (;;) {
            GBWord kind;
            while (*p && *p != '/') ++p;
            while (*q && *q != ':') ++q;
            if (!!*p != !!*q || q == nativeStart || (size_t)(q-nativeStart) > 31) {
                result = GS_FORMAT; goto fail;
            }
            kind = *p || reserved[i].directory ? GP_DIRECTORY : 0100644;
            e = NULL;
            for (n = 0; n < next.count; ++n)
                if (strlen(next.entries[n].path) == (size_t)(p-reserved[i].path) &&
                    !memcmp(next.entries[n].path, reserved[i].path, (size_t)(p-reserved[i].path))) {
                    e = next.entries+n; break;
                }
            if (e) {
                if ((e->mode == GP_DIRECTORY) != (kind == GP_DIRECTORY)) { result = GS_CONFLICT; goto fail; }
            } else {
                result = GPAppend(&next, reserved[i].path, (size_t)(p-reserved[i].path), kind, &e);
                if (result) goto fail;
                /* Retain old mapped untracked files as identities. New local
                   files need identities too, without a synthetic Git baseline. */
                prefix = GPString(e->path, strlen(e->path));
                if (!prefix) { result = GB_MEMORY; goto fail; }
                old = previous ? GPFind(previous, prefix) : NULL; free(prefix);
                if (old && kind != GP_DIRECTORY && old->mode != GP_DIRECTORY) {
                    e->mode = old->mode; e->flags = old->flags;
                    memcpy(e->dataOID, old->dataOID, 20); memcpy(e->metadataOID, old->metadataOID, 20);
                    memcpy(e->finderInfo, old->finderInfo, 32);
                } else if (kind != GP_DIRECTORY) e->flags = GP_LOCAL;
            }
            name = GPString(nativeStart, (size_t)(q-nativeStart));
            if (!name) { result = GB_MEMORY; goto fail; }
            if (!GPNameValid(name, equal, ctx) || (e->native && strcmp(e->native, name))) {
                free(name); result = GS_CONFLICT; goto fail;
            }
            free(e->native); e->native = name;
            if (!*p) break;
            ++p; nativeStart = ++q;
        }
    }
    if (next.count > 1) qsort(next.entries, next.count, sizeof(*next.entries), GPOrder);
    /* Reserve every surviving alias before new paths are allowed to claim names. */
    for (i = 0; previous && i < next.count; ++i) {
        e = next.entries+i; old = GPFind(previous, e->path);
        if (!old || e->native) continue;
        name = GPString(GPLeaf(old->native, 1), strlen(GPLeaf(old->native, 1)));
        if (!name) { result = GB_MEMORY; goto fail; }
        if (!GPAvailable(&next, i, name, equal, ctx)) { free(name); result = GS_CONFLICT; goto fail; }
        e->native = name;
    }
    for (i = 0; i < next.count; ++i) if (!next.entries[i].native) {
        result = GPDirectNative(GPLeaf(next.entries[i].path, 0), &name);
        if (result && result != GI_UNSUPPORTED && result != GB_BAD) goto fail;
        if (result || !GPReadable(name) || !GPAvailable(&next, i, name, equal, ctx)) {
            free(name); name = NULL;
            result = GPAlias(&next, i, equal, ctx, &name);
            if (result) goto fail;
        }
        next.entries[i].native = name;
    }
    for (i = 0; i < next.count; ++i) {
        e = next.entries+i; n = GPParentLength(e->path, 0);
        if (!n) continue;
        prefix = GPString(e->path, n);
        if (!prefix) { result = GB_MEMORY; goto fail; }
        parent = GPFind(&next, prefix); free(prefix);
        if (!parent || parent->mode != GP_DIRECTORY) { result = GS_FORMAT; goto fail; }
        a = strlen(parent->native); b = strlen(e->native);
        if (a > (size_t)-1-b-2) { result = GB_SPACE; goto fail; }
        full = (char *)malloc(a+b+2);
        if (!full) { result = GB_MEMORY; goto fail; }
        memcpy(full, parent->native, a); full[a] = ':'; memcpy(full+a+1, e->native, b+1);
        free(e->native); e->native = full;
    }
    result = GPValidate(&next, equal, ctx);
    if (result) goto fail;
    if (previous && previous->original) {
        next.original = (unsigned char *)malloc(previous->originalLength);
        if (!next.original) { result = GB_MEMORY; goto fail; }
        memcpy(next.original, previous->original, previous->originalLength);
        next.originalLength = previous->originalLength;
    }
    GPFree(out); *out = next; return 0;
fail:
    GPFree(&next); return result;
}
int GPBuild(const GRSnapshot *snapshot, const GPMap *previous, GPEqual equal, void *ctx, GPMap *out) {
    return GPBuildProtected(snapshot, previous, NULL, 0, equal, ctx, out);
}
int GPEncode(const GPMap *m, GPEqual equal, void *ctx, unsigned char **bytes, size_t *length) {
    unsigned char *out, *p, digest[20];
    size_t i, n = 52, a, b;
    GBSHA1 hash;
    int result;
    if (!bytes || !length) return GB_BAD;
    *bytes = NULL; *length = 0;
    result = GPValidate(m, equal, ctx);
    if (result) return result;
    if (m->count > 0xffffffffUL) return GB_SPACE;
    for (i = 0; i < m->count; ++i) {
        a = strlen(m->entries[i].path); b = strlen(m->entries[i].native);
        if (a > 0xffffffffUL || b > 0xffffffffUL || a > (size_t)-1-88 ||
            b > (size_t)-1-88-a || n > (size_t)-1-88-a-b) return GB_SPACE;
        n += 88+a+b;
    }
    out = (unsigned char *)malloc(n);
    if (!out) return GB_MEMORY;
    memcpy(out, "GHMAP001", 8); GPPut(out+8, (GBWord)m->count); memcpy(out+12, m->tree, 20); p = out+32;
    for (i = 0; i < m->count; ++i) {
        const GPEntry *e = m->entries+i;
        a = strlen(e->path); b = strlen(e->native);
        GPPut(p, (GBWord)a); GPPut(p+4, (GBWord)b); GPPut(p+8, e->mode); GPPut(p+12, e->flags);
        memcpy(p+16, e->dataOID, 20); memcpy(p+36, e->metadataOID, 20); memcpy(p+56, e->finderInfo, 32);
        p += 88; memcpy(p, e->path, a); p += a; memcpy(p, e->native, b); p += b;
    }
    GBSHA1Start(&hash); GBSHA1Update(&hash, out, n-20); GBSHA1Finish(&hash, digest);
    memcpy(p, digest, 20); *bytes = out; *length = n; return 0;
}
int GPParse(const void *bytes, size_t length, GPEqual equal, void *ctx, GPMap *out) {
    const unsigned char *p = (const unsigned char *)bytes, *end;
    unsigned char digest[20];
    GPMap next;
    GPEntry *e;
    GBSHA1 hash;
    size_t count, i, a, b;
    int result = GS_FORMAT;
    if (!bytes || !out || !equal) return GB_BAD;
    if (length < 52 || memcmp(p, "GHMAP001", 8)) return GS_FORMAT;
    GBSHA1Start(&hash); GBSHA1Update(&hash, p, length-20); GBSHA1Finish(&hash, digest);
    if (memcmp(digest, p+length-20, 20)) return GB_CHECKSUM;
    count = GPWord(p+8);
    if (count > (length-52)/90 || count > (size_t)-1/sizeof(*e)) return GS_FORMAT;
    GPInit(&next); memcpy(next.tree, p+12, 20); end = p+length-20; p += 32;
    next.entries = (GPEntry *)calloc(count ? count : 1, sizeof(*e));
    if (!next.entries) return GB_MEMORY;
    next.count = count;
    for (i = 0; i < count; ++i) {
        if ((size_t)(end-p) < 88) goto fail;
        e = next.entries+i; a = GPWord(p); b = GPWord(p+4);
        e->mode = GPWord(p+8); e->flags = GPWord(p+12);
        memcpy(e->dataOID, p+16, 20); memcpy(e->metadataOID, p+36, 20); memcpy(e->finderInfo, p+56, 32); p += 88;
        if (!a || !b || a > (size_t)(end-p) || b > (size_t)(end-p)-a ||
            memchr(p, 0, a+b)) goto fail;
        e->path = GPString((const char *)p, a); p += a;
        e->native = GPString((const char *)p, b); p += b;
        if (!e->path || !e->native) { result = GB_MEMORY; goto fail; }
    }
    if (p != end) goto fail;
    result = GPValidate(&next, equal, ctx);
    if (result) goto fail;
    next.original = (unsigned char *)malloc(length);
    if (!next.original) { result = GB_MEMORY; goto fail; }
    memcpy(next.original, bytes, length); next.originalLength = length;
    GPFree(out); *out = next; return 0;
fail:
    GPFree(&next); return result;
}
int GPLoad(GSRepository *r, GPEqual equal, void *ctx, GPMap *m) {
    unsigned char *bytes;
    size_t n;
    int result = r->read(r->context, "ghclient-map", &bytes, &n);
    if (result == GS_NOT_FOUND) { GPFree(m); return 0; }
    if (result) return result;
    result = GPParse(bytes, n, equal, ctx, m); free(bytes); return result;
}
int GPSave(GSRepository *r, GPEqual equal, void *ctx, GPMap *m) {
    unsigned char *bytes;
    size_t n;
    int result = GPEncode(m, equal, ctx, &bytes, &n);
    if (result) return result;
    result = r->replace(r->context, "ghclient-map", m->original, m->originalLength, bytes, n);
    if (!result) { free(m->original); m->original = bytes; m->originalLength = n; }
    else free(bytes);
    return result;
}
static int GPResolvePath(const GPMap *m, const char *native, GPEqual equal, void *ctx, char **path,int work) {
    const char *p = native, *start = native;
    char *logical = NULL, *leaf = NULL, *next, name[32];
    const GPEntry *entry, *chosen;
    size_t n, a = 0, b, i;
    int result = 0;
    if (!m || !native || !path || !equal) return GB_BAD;
    *path = NULL;
    for (;;) {
        while (*p && *p != ':') ++p;
        n = (size_t)(p-start);
        if (!n || n > 31) { result = GI_UNSUPPORTED; goto done; }
        memcpy(name, start, n); name[n] = 0;
        if (!GPNameValid(name, equal, ctx)) { result = GS_CONFLICT; goto done; }
        chosen = NULL;
        for (i = 0; i < m->count; ++i) {
            entry = m->entries+i;
            if (GPParentLength(entry->path, 0) == a && (!a || !memcmp(entry->path, logical, a)) &&
                equal(ctx, GPLeaf(entry->native, 1), name)) {
                if (chosen) { result = GS_CONFLICT; goto done; }
                chosen = entry;
            }
        }
        if (chosen) {
            if (*p && chosen->mode != GP_DIRECTORY && !work) { result = GS_CONFLICT; goto done; }
            leaf = GPString(GPLeaf(chosen->path, 0), strlen(GPLeaf(chosen->path, 0)));
            if (!leaf) { result = GB_MEMORY; goto done; }
        } else {
            result = GPDirectGit(name, &leaf);
            if (result) goto done;
        }
        b = strlen(leaf);
        if (a > (size_t)-1-b-2) { result = GB_SPACE; goto done; }
        next = (char *)malloc(a+b+2);
        if (!next) { result = GB_MEMORY; goto done; }
        if (a) { memcpy(next, logical, a); next[a++] = '/'; }
        memcpy(next+a, leaf, b+1); a += b;
        free(leaf); leaf = NULL; free(logical); logical = next;
        entry = GPFind(m, logical);
        if (!chosen && entry) { result = GS_CONFLICT; goto done; }
        if (!*p) break;
        start = ++p;
    }
    if (!GIValidPath(logical) || GPReserved(logical)) { result = GS_CONFLICT; goto done; }
    *path = logical; logical = NULL;
done:
    free(logical); free(leaf); return result;
}
int GPResolve(const GPMap *m,const char *native,GPEqual equal,void *ctx,char **path) {
    return GPResolvePath(m,native,equal,ctx,path,0);
}
int GPResolveWork(const GPMap *m,const char *native,GPEqual equal,void *ctx,char **path) {
    return GPResolvePath(m,native,equal,ctx,path,1);
}
int GPWorkPolicy(const GPEntry *mapped, const GIEntry *indexed, const unsigned char info[32],
                 size_t resourceLength, GBWord *mode, int *forks) {
    if (!info || !mode || !forks) return GB_BAD;
    if(mapped && mapped->mode==GP_DIRECTORY)mapped=NULL; /* A new native file replaces the old directory. */
    *forks = 0;
    *mode = indexed ? indexed->stat[6] : mapped ? mapped->mode : 0100644;
    if (*mode != 0100644 && *mode != 0100755 && *mode != 0120000) return GI_UNSUPPORTED;
    *forks = !mapped || (mapped->flags & (GP_FORKS | GP_LOCAL)) || resourceLength ||
             memcmp(info, mapped->finderInfo, 32);
    if (*mode == 0120000 && *forks) return GI_UNSUPPORTED;
    return 0;
}
static int GPExistingMetadata(GSRepository *r, const GIIndex *index, const char *path,
                               const unsigned char info[32], const void *resource, size_t rn,
                               unsigned char oid[20], int *same) {
    char key[96], type[7], *logical = NULL;
    unsigned char *bytes = NULL, oldInfo[32];
    const unsigned char *oldRF;
    const GIEntry *entry;
    size_t n, oldRN;
    int result;
    *same = 0;
    result = GIMacMetadataPath(path, key);
    if (!result) result = GIValidateMacNamespace(r, index);
    if (result) return result;
    entry = GIFind(index, key, 0);
    if (!entry) return 0;
    if (entry->stat[6] != 0100644) return GS_FORMAT;
    result = GSGetObject(r, entry->oid, type, &bytes, &n);
    if (!result && strcmp(type, "blob")) result = GS_FORMAT;
    if (!result) result = GIMacDecode(bytes, n, &logical, oldInfo, &oldRF, &oldRN);
    if (!result && strcmp(logical, path)) result = GS_FORMAT;
    if (!result) {
        oldInfo[8] &= (unsigned char)~1U; memset(oldInfo+10, 0, 6); memset(oldInfo+28, 0, 4);
        *same = !memcmp(oldInfo, info, 32) && oldRN == rn && (!rn || !memcmp(oldRF, resource, rn));
        if (*same) memcpy(oid, entry->oid, 20);
    }
    free(logical); free(bytes); return result;
}
int GPMetadataOID(GSRepository *r, const GIIndex *index, const char *path,
                   const unsigned char info[32], const void *resource, size_t rn,
                   unsigned char oid[20], int *same) {
    unsigned char *bytes;
    size_t n;
    int result;
    if (!r || !index || !info || (!resource && rn) || !oid || !same) return GB_BAD;
    result = GPExistingMetadata(r, index, path, info, resource, rn, oid, same);
    if (result || *same) return result;
    result = GIMacEncode(path, info, resource, rn, &bytes, &n);
    if (result) return result;
    result = GBObjectID("blob", bytes, n, oid); free(bytes); return result;
}
int GPStageWork(GSRepository *r, GIIndex *index, const GPEntry *mapped, const char *path,
                const void *data, size_t n, const unsigned char info[32], const void *resource, size_t rn) {
    GBWord mode;
    char metadata[96];
    int forks, same, result;
    unsigned char existing[20];
    if (!r || !index || !GIValidPath(path) || (!data && n) || (!resource && rn) ||
        (mapped && strcmp(mapped->path, path))) return GB_BAD;
    result = GIMacMetadataPath(path, metadata);
    if (!result) result = GPWorkPolicy(mapped, GIFind(index, path, 0), info, rn, &mode, &forks);
    if (result) return result;
    if (forks) {
        result = GPExistingMetadata(r, index, path, info, resource, rn, existing, &same);
        if (result) return result;
        if (same) return GIStageBlob(r, index, path, mode, data, n);
        return GIStageMacMode(r, index, path, mode, data, n, info, resource, rn);
    }
    result = GIValidateMacNamespace(r, index);
    if (!result) result = GIStageBlob(r, index, path, mode, data, n);
    if (!result) result = GIRemove(index, metadata);
    return result;
}
